# Allegro board Alpine15_LA-A101PR10-0826C.brd (continued)
## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated) (continued)
IDTVMM2320BKG8_BGA_168P-NH
  round 0.279 smd: A1(0,0) A2(0.65,0) A3(1.3,0) A4(1.95,0) A5(2.6,0) A6(3.25,0) A7(3.9,0) A8(4.55,0) A9(5.2,0) A10(5.85,0) A11(6.5,0) A12(7.15,0) A13(7.8,0) A14(8.45,0) B1(0,-0.65) B2(0.65,-0.65) B3(1.3,-0.65) B4(1.95,-0.65) B5(2.6,-0.65) B6(3.25,-0.65) B7(3.9,-0.65) B8(4.55,-0.65) B9(5.2,-0.65) B10(5.85,-0.65) B11(6.5,-0.65) B12(7.15,-0.65) B13(7.8,-0.65) B14(8.45,-0.65) C1(0,-1.3) C2(0.65,-1.3) C3(1.3,-1.3) C4(1.95,-1.3) C5(2.6,-1.3) C6(3.25,-1.3) C7(3.9,-1.3) C8(4.55,-1.3) C9(5.2,-1.3) C10(5.85,-1.3) C11(6.5,-1.3) C12(7.15,-1.3) C13(7.8,-1.3) C14(8.45,-1.3) D1(0,-1.95) D2(0.65,-1.95) D3(1.3,-1.95) D4(1.95,-1.95) D5(2.6,-1.95) D6(3.25,-1.95) D7(3.9,-1.95) D8(4.55,-1.95) D9(5.2,-1.95) D10(5.85,-1.95) D11(6.5,-1.95) D12(7.15,-1.95) D13(7.8,-1.95) D14(8.45,-1.95) E1(0,-2.6) E2(0.65,-2.6) E3(1.3,-2.6) E4(1.95,-2.6) E5(2.6,-2.6) E6(3.25,-2.6) E7(3.9,-2.6) E8(4.55,-2.6) E9(5.2,-2.6) E10(5.85,-2.6) E11(6.5,-2.6) E12(7.15,-2.6) E13(7.8,-2.6) E14(8.45,-2.6) F1(0,-3.25) F2(0.65,-3.25) F3(1.3,-3.25) F4(1.95,-3.25) F5(2.6,-3.25) F6(3.25,-3.25) F7(3.9,-3.25) F8(4.55,-3.25) F9(5.2,-3.25) F10(5.85,-3.25) F11(6.5,-3.25) F12(7.15,-3.25) F13(7.8,-3.25) F14(8.45,-3.25) G1(0,-3.9) G2(0.65,-3.9) G3(1.3,-3.9) G4(1.95,-3.9) G5(2.6,-3.9) G6(3.25,-3.9) G7(3.9,-3.9) G8(4.55,-3.9) G9(5.2,-3.9) G10(5.85,-3.9) G11(6.5,-3.9) G12(7.15,-3.9) G13(7.8,-3.9) G14(8.45,-3.9) H1(0,-4.55) H2(0.65,-4.55) H3(1.3,-4.55) H4(1.95,-4.55) H5(2.6,-4.55) H6(3.25,-4.55) H7(3.9,-4.55) H8(4.55,-4.55) H9(5.2,-4.55) H10(5.85,-4.55) H11(6.5,-4.55) H12(7.15,-4.55) H13(7.8,-4.55) H14(8.45,-4.55) J1(0,-5.2) J2(0.65,-5.2) J3(1.3,-5.2) J4(1.95,-5.2) J5(2.6,-5.2) J6(3.25,-5.2) J7(3.9,-5.2) J8(4.55,-5.2) J9(5.2,-5.2) J10(5.85,-5.2) J11(6.5,-5.2) J12(7.15,-5.2) J13(7.8,-5.2) J14(8.45,-5.2) K1(0,-5.85) K2(0.65,-5.85) K3(1.3,-5.85) K4(1.95,-5.85) K5(2.6,-5.85) K6(3.25,-5.85) K7(3.9,-5.85) K8(4.55,-5.85) K9(5.2,-5.85) K10(5.85,-5.85) K11(6.5,-5.85) K12(7.15,-5.85) K13(7.8,-5.85) K14(8.45,-5.85) L1(0,-6.5) L2(0.65,-6.5) L3(1.3,-6.5) L4(1.95,-6.5) L5(2.6,-6.5) L6(3.25,-6.5) L7(3.9,-6.5) L8(4.55,-6.5) L9(5.2,-6.5) L10(5.85,-6.5) L11(6.5,-6.5) L12(7.15,-6.5) L13(7.8,-6.5) L14(8.45,-6.5) M1(0,-7.15) M2(0.65,-7.15) M3(1.3,-7.15) M4(1.95,-7.15) M5(2.6,-7.15) M6(3.25,-7.15) M7(3.9,-7.15) M8(4.55,-7.15) M9(5.2,-7.15) M10(5.85,-7.15) M11(6.5,-7.15) M12(7.15,-7.15) M13(7.8,-7.15) M14(8.45,-7.15)
IMD2AGZT108_SC74-6
  oval 0.787x0.991 smd: 1(0,0) 3(-2,0) 4(-2,2.4) 6(0,2.4)
  oval 0.61x0.991 smd: 2(-1,0) 5(-1,2.4)
INA199A1DCKR_SC70-6
  oval 0.406x0.889 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,2.2) 5(0.65,2.2) 6(0,2.2)
IP4292CZ10-TBR_XSON10_2P5X1
  oval 0.254x0.889 smd: 1(0,0)
  oval 0.254x0.838 smd: 2(0.5,-0.025) 3(1,-0.025) 4(1.5,-0.025) 5(2,-0.025) 6(2,1.125) 7(1.5,1.125) 8(1,1.125) 9(0.5,1.125) 10(0,1.125)
J-L_TNBNRACB0007022_22P-T
  round 1.194 hole 1.194 unplated: (-36.075,-1.61) (6.375,-1.61)
  oval 0.711x2.997 smd: 1(0,0) 7(-7.62,0) 8(-13.97,0) 9(-15.24,0) 10(-16.51,0) 11(-17.78,0) 12(-19.05,0) 13(-20.32,0) 14(-21.59,0) 15(-22.86,0) 16(-24.13,0) 17(-25.4,0) 18(-26.67,0) 19(-27.94,0) 20(-29.21,0) 21(-30.48,0) 22(-31.75,0)
  oval 0.711x2.489 smd: 2(-1.27,-0.25) 3(-2.54,-0.25) 4(-3.81,-0.25) 5(-5.08,-0.25) 6(-6.35,-0.25)
  custom 1.49x1.49 hole 2.311: 23(-39.65,-1.61) 24(9.95,-1.61)
JAE_WD2F144WB3R300_144P
  oval 1.905x1.194 hole 1.905x1.194 unplated: (5,-4) (32.5,-4)
  oval 0.254x1.803 smd: 1(0,0) 2(0,-8) 3(0.5,0) 4(0.5,-8) 5(1,0) 6(1,-8) 7(1.5,0) 8(1.5,-8) 9(2,0) 10(2,-8) 11(2.5,0) 12(2.5,-8) 13(3,0) 14(3,-8) 15(3.5,0) 16(3.5,-8) 17(4,0) 18(4,-8) 19(4.5,0) 20(4.5,-8) 21(5,0) 22(5,-8) 23(5.5,0) 24(5.5,-8) 25(6,0) 26(6,-8) 27(6.5,0) 28(6.5,-8) 29(7,0) 30(7,-8) 31(7.5,0) 32(7.5,-8) 33(8,0) 34(8,-8) 35(8.5,0) 36(8.5,-8) 37(9,0) 38(9,-8) 39(9.5,0) 40(9.5,-8) 41(10,0) 42(10,-8) 43(10.5,0) 44(10.5,-8) 45(11,0) 46(11,-8) 47(11.5,0) 48(11.5,-8) 49(12,0) 50(12,-8) 51(13.5,0) 52(13.5,-8) 53(14,0) 54(14,-8) 55(14.5,0) 56(14.5,-8) 57(15,0) 58(15,-8) 59(15.5,0) 60(15.5,-8) 61(16,0) 62(16,-8) 63(16.5,0) 64(16.5,-8) 65(17,0) 66(17,-8) 67(17.5,0) 68(17.5,-8) 69(18,0) 70(18,-8) 71(18.5,0) 72(18.5,-8) 73(19,0) 74(19,-8) 75(19.5,0) 76(19.5,-8) 77(20,0) 78(20,-8) 79(20.5,0) 80(20.5,-8) 81(21,0) 82(21,-8) 83(21.5,0) 84(21.5,-8) 85(22,0) 86(22,-8) 87(22.5,0) 88(22.5,-8) 89(23,0) 90(23,-8) 91(23.5,0) 92(23.5,-8) 93(24,0) 94(24,-8) 95(25.5,0) 96(25.5,-8) 97(26,0) 98(26,-8) 99(26.5,0) 100(26.5,-8) 101(27,0) 102(27,-8) 103(27.5,0) 104(27.5,-8) 105(28,0) 106(28,-8) 107(28.5,0) 108(28.5,-8) 109(29,0) 110(29,-8) 111(29.5,0) 112(29.5,-8) 113(30,0) 114(30,-8) 115(30.5,0) 116(30.5,-8) 117(31,0) 118(31,-8) 119(31.5,0) 120(31.5,-8) 121(32,0) 122(32,-8) 123(32.5,0) 124(32.5,-8) 125(33,0) 126(33,-8) 127(33.5,0) 128(33.5,-8) 129(34,0) 130(34,-8) 131(34.5,0) 132(34.5,-8) 133(35,0) 134(35,-8) 135(35.5,0) 136(35.5,-8) 137(36,0) 138(36,-8) 139(36.5,0) 140(36.5,-8) 141(37,0) 142(37,-8) 143(37.5,0) 144(37.5,-8)
  oval 1.753x3.607 hole 0.991x2.845: 145(-5.425,-4) 152(42.925,-4)
  oval 1.905x1.702 hole 1.143x0.94: 146(-1.55,-2.275) 148(-1.55,-5.725) 149(39.05,-2.275) 151(39.05,-5.725)
  oval 1.702x2.667 hole 0.94x1.905: 147(-2.475,-4) 150(39.975,-4)
  oval 3.759x1.6 hole 2.997x0.838: 153(-3.75,-0.075) 156(41.25,-0.075) 161(-3.75,-7.925) 164(41.25,-7.925)
  oval 1.753x1.6 hole 0.991x0.838: 154(12.75,-0.075) 155(24.75,-0.075) 162(12.75,-7.925) 163(24.75,-7.925)
  round 1.753 hole 0.991: 157(0.75,-4) 158(12.75,-4) 159(24.75,-4) 160(36.75,-4)
JUMP_43X39
  custom 0.191x0.191 smd: 1(0,0) 2(0.914,0)
JUMP_43X79
  custom 0.188x0.188 smd: 1(0,0) 2(1.1,0)
JUMP_43X118
  custom 0.187x0.187 smd: 1(0,0) 2(1.1,0)
KC_FBMA-L11-453215800LMA90T_2P
  rect 1.803x3.404 smd: 1(0,0) 2(3.8,0)
L2N7002WT1G_SC-70-3
  oval 0.711x0.889 smd: 1(0,0) 2(-0.65,-1.9) 3(0.65,-1.9)
L30ESD24VC3-2_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
L30ESDL5V0C3-2_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
LM358DR2G_SO8
  oval 0.635x1.854 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0) 5(3.81,5.165) 6(2.54,5.165) 7(1.27,5.165) 8(0,5.165)
LM393DR_SO8
  oval 0.635x1.854 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0) 5(3.81,5.165) 6(2.54,5.165) 7(1.27,5.165) 8(0,5.165)
LNG3DMTR_LGA16_3X3
  oval 0.305x0.864 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 9(2,2.958) 10(1.5,2.958) 11(1,2.958) 12(0.5,2.958) 13(0,2.958)
  oval 0.864x0.305 smd: 6(2.479,0.979) 7(2.479,1.479) 8(2.479,1.979) 14(-0.479,1.979) 15(-0.479,1.479) 16(-0.479,0.979)
LOTES_AAA-PCI-041-K01_52P
  round 1.6 hole 1.6 unplated: (-0.7,4.1)
  round 1.092 hole 1.092 unplated: (24.3,4.1)
  oval 0.61x2.007 smd: 1(0,0) 2(0.4,8.2) 3(0.8,0) 4(1.2,8.2) 5(1.6,0) 6(2,8.2) 7(2.4,0) 8(2.8,8.2) 9(3.2,0) 10(3.6,8.2) 11(4,0) 12(4.4,8.2) 13(4.8,0) 14(5.2,8.2) 15(5.6,0) 16(6,8.2) 17(9.6,0) 18(10,8.2) 19(10.4,0) 20(10.8,8.2) 21(11.2,0) 22(11.6,8.2) 23(12,0) 24(12.4,8.2) 25(12.8,0) 26(13.2,8.2) 27(13.6,0) 28(14,8.2) 29(14.4,0) 30(14.8,8.2) 31(15.2,0) 32(15.6,8.2) 33(16,0) 34(16.4,8.2) 35(16.8,0) 36(17.2,8.2) 37(17.6,0) 38(18,8.2) 39(18.4,0) 40(18.8,8.2) 41(19.2,0) 42(19.6,8.2) 43(20,0) 44(20.4,8.2) 45(20.8,0) 46(21.2,8.2) 47(21.6,0) 48(22,8.2) 49(22.4,0) 50(22.8,8.2) 51(23.2,0) 52(23.6,8.2)
  rect 2.311x3.2 smd: 53(-2.85,0.6) 54(26.45,0.6)
LP2301ALT1G_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
MEC5075-LZY_DQFN132_11X11
  oval 0.279x0.711 smd: A1(0,0) A2(0.5,0) A3(1,0) A4(1.5,0) A5(2,0) A6(2.5,0) A7(3,0) A8(3.5,0) A9(4,0) A10(4.5,0) A11(5,0) A12(5.5,0) A13(6,0) A14(6.5,0) A15(7,0) A16(7.5,0) A33(7.5,10.9) A34(7,10.9) A35(6.5,10.9) A36(6,10.9) A37(5.5,10.9) A38(5,10.9) A39(4.5,10.9) A40(4,10.9) A41(3.5,10.9) A42(3,10.9) A43(2.5,10.9) A44(2,10.9) A45(1.5,10.9) A46(1,10.9) A47(0.5,10.9) A48(0,10.9)
  oval 0.711x0.279 smd: A17(9.2,1.7) A18(9.2,2.2) A19(9.2,2.7) A20(9.2,3.2) A21(9.2,3.7) A22(9.2,4.2) A23(9.2,4.7) A24(9.2,5.2) A25(9.2,5.7) A26(9.2,6.2) A27(9.2,6.7) A28(9.2,7.2) A29(9.2,7.7) A30(9.2,8.2) A31(9.2,8.7) A32(9.2,9.2) A49(-1.7,9.2) A50(-1.7,8.7) A51(-1.7,8.2) A52(-1.7,7.7) A53(-1.7,7.2) A54(-1.7,6.7) A55(-1.7,6.2) A56(-1.7,5.7) A57(-1.7,5.2) A58(-1.7,4.7) A59(-1.7,4.2) A60(-1.7,3.7) A61(-1.7,3.2) A62(-1.7,2.7) A63(-1.7,2.2) A64(-1.7,1.7)
  oval 0.305x0.61 smd: B1(-0.25,0.85) B2(0.25,0.85) B3(0.75,0.85) B4(1.25,0.85) B5(1.75,0.85) B6(2.25,0.85) B7(2.75,0.85) B8(3.25,0.85) B9(3.75,0.85) B10(4.25,0.85) B11(4.75,0.85) B12(5.25,0.85) B13(5.75,0.85) B14(6.25,0.85) B15(6.75,0.85) B16(7.25,0.85) B17(7.75,0.85) B35(7.75,10.05) B36(7.25,10.05) B37(6.75,10.05) B38(6.25,10.05) B39(5.75,10.05) B40(5.25,10.05) B41(4.75,10.05) B42(4.25,10.05) B43(3.75,10.05) B44(3.25,10.05) B45(2.75,10.05) B46(2.25,10.05) B47(1.75,10.05) B48(1.25,10.05) B49(0.75,10.05) B50(0.25,10.05) B51(-0.25,10.05)
  oval 0.61x0.305 smd: B18(8.35,1.45) B19(8.35,1.95) B20(8.35,2.45) B21(8.35,2.95) B22(8.35,3.45) B23(8.35,3.95) B24(8.35,4.45) B25(8.35,4.95) B26(8.35,5.45) B27(8.35,5.95) B28(8.35,6.45) B29(8.35,6.95) B30(8.35,7.45) B31(8.35,7.95) B32(8.35,8.45) B33(8.35,8.95) B34(8.35,9.45) B52(-0.85,9.45) B53(-0.85,8.95) B54(-0.85,8.45) B55(-0.85,7.95) B56(-0.85,7.45) B57(-0.85,6.95) B58(-0.85,6.45) B59(-0.85,5.95) B60(-0.85,5.45) B61(-0.85,4.95) B62(-0.85,4.45) B63(-0.85,3.95) B64(-0.85,3.45) B65(-0.85,2.95) B66(-0.85,2.45) B67(-0.85,1.95) B68(-0.85,1.45)
  rect 5.004x5.004 smd: C1(3.75,5.45)
MMST3904-7-F_SOT323-3
  oval 0.711x0.889 smd: 1(0,0) 2(0.65,1.9) 3(-0.65,1.9)
MT41K256M16HA-125M-E_FBGA_96P
  round 0.343 smd: A1(0,0) A2(0.8,0) A3(1.6,0) A7(4.801,0) A8(5.601,0) A9(6.401,0) B1(0,-0.8) B2(0.8,-0.8) B3(1.6,-0.8) B7(4.801,-0.8) B8(5.601,-0.8) B9(6.401,-0.8) C1(0,-1.6) C2(0.8,-1.6) C3(1.6,-1.6) C7(4.801,-1.6) C8(5.601,-1.6) C9(6.401,-1.6) D1(0,-2.4) D2(0.8,-2.4) D3(1.6,-2.4) D7(4.801,-2.4) D8(5.601,-2.4) D9(6.401,-2.4) E1(0,-3.2) E2(0.8,-3.2) E3(1.6,-3.2) E7(4.801,-3.2) E8(5.601,-3.2) E9(6.401,-3.2) F1(0,-4) F2(0.8,-4) F3(1.6,-4) F7(4.801,-4) F8(5.601,-4) F9(6.401,-4) G1(0,-4.801) G2(0.8,-4.801) G3(1.6,-4.801) G7(4.801,-4.801) G8(5.601,-4.801) G9(6.401,-4.801) H1(0,-5.601) H2(0.8,-5.601) H3(1.6,-5.601) H7(4.801,-5.601) H8(5.601,-5.601) H9(6.401,-5.601) J1(0,-6.401) J2(0.8,-6.401) J3(1.6,-6.401) J7(4.801,-6.401) J8(5.601,-6.401) J9(6.401,-6.401) K1(0,-7.201) K2(0.8,-7.201) K3(1.6,-7.201) K7(4.801,-7.201) K8(5.601,-7.201) K9(6.401,-7.201) L1(0,-8.001) L2(0.8,-8.001) L3(1.6,-8.001) L7(4.801,-8.001) L8(5.601,-8.001) L9(6.401,-8.001) M1(0,-8.801) M2(0.8,-8.801) M3(1.6,-8.801) M7(4.801,-8.801) M8(5.601,-8.801) M9(6.401,-8.801) N1(0,-9.601) N2(0.8,-9.601) N3(1.6,-9.601) N7(4.801,-9.601) N8(5.601,-9.601) N9(6.401,-9.601) P1(0,-10.401) P2(0.8,-10.401) P3(1.6,-10.401) P7(4.801,-10.401) P8(5.601,-10.401) P9(6.401,-10.401) R1(0,-11.201) R2(0.8,-11.201) R3(1.6,-11.201) R7(4.801,-11.201) R8(5.601,-11.201) R9(6.401,-11.201) T1(0,-12.002) T2(0.8,-12.002) T3(1.6,-12.002) T7(4.801,-12.002) T8(5.601,-12.002) T9(6.401,-12.002)
MURAT_BLM18AG102SN1D_2P
  rect 0.66x1.041 smd: 1(0,0) 2(1.2,0)
MURAT_BLM18AG121SN1D_2P
  rect 0.66x1.041 smd: 1(0,0) 2(1.2,0)
MURAT_BLM18BD102SN1D_2P
  oval 0.66x1.041 smd: 1(0,0) 2(1.2,0)
MURAT_BLM18BD601SN1D_2P
  rect 0.61x0.711 smd: 1(0,0) 2(1.3,0)
MURAT_BLM18PG181SN1D_2P
  rect 0.66x1.041 smd: 1(0,0) 2(1.2,0)
MURAT_BLM18PG300SN1D_2P
  rect 0.66x1.041 smd: 1(0,0) 2(1.2,0)
MURAT_BLM18PG471SN1D_2P
  rect 0.66x1.041 smd: 1(0,0) 2(1.2,0)
MURAT_BLM21PG600SN1D_2P
  rect 0.991x1.753 smd: 1(0,0) 2(1.5,0)
MURAT_DLW21SN900HQ2L_0805_4P
  rect 0.889x0.356 smd: 1(0,0) 2(1.7,0) 3(1.7,0.85) 4(0,0.85)
MURAT_DLW21SN900SQ2L_0805_4P
  rect 0.889x0.356 smd: 1(0,0) 2(1.7,0) 3(1.7,0.85) 4(0,0.85)
MURAT_LQM2MPN2R2NG0L_2P
  rect 0.787x1.803 smd: 1(0,0) 2(1.6,0)
N14M-GE-S-A2_FCBGA_595P
  round 0.381 smd: A2(0.8,0) A3(1.6,0) A4(2.4,0) A6(4.1,0) A7(4.9,0) A9(6.58,0) A10(7.38,0) A12(9.06,0) A13(9.86,0) A15(11.54,0) A16(12.34,0) A18(14.02,0) A19(14.82,0) A21(16.5,0) A22(17.3,0) A24(19,0) A25(19.8,0) A26(20.6,0) AA1(0,-16.5) AA2(0.8,-16.5) AA3(1.6,-16.5) AA4(2.4,-16.5) AA5(3.2,-16.5) AA6(4.04,-16.5) AA7(4.9,-16.5) AA8(5.74,-16.5) AA9(6.58,-16.56) AA10(7.38,-16.56) AA12(9.06,-16.56) AA13(9.86,-16.56) AA14(10.7,-16.56) AA15(11.54,-16.56) AA16(12.34,-16.56) AA18(14.02,-16.56) AA19(14.82,-16.56) AA20(15.66,-16.5) AA21(16.5,-16.5) AA22(17.36,-16.5) AA23(18.2,-16.5) AA24(19,-16.5) AA25(19.8,-16.5) AA26(20.6,-16.5) AA27(21.4,-16.5) AB1(0,-17.3) AB2(0.8,-17.3) AB3(1.6,-17.3) AB4(2.4,-17.3) AB5(3.2,-17.3) AB6(4.1,-17.3) AB7(4.9,-17.36) AB8(5.74,-17.36) AB9(6.58,-17.36) AB10(7.38,-17.36) AB11(8.22,-17.36) AB12(9.06,-17.36) AB13(9.86,-17.36) AB14(10.7,-17.36) AB15(11.54,-17.36) AB16(12.34,-17.36) AB17(13.18,-17.36) AB18(14.02,-17.36) AB19(14.82,-17.36) AB20(15.66,-17.36) AB21(16.5,-17.36) AB22(17.3,-17.3) AB23(18.2,-17.3) AB24(19,-17.3) AB25(19.8,-17.3) AB26(20.6,-17.3) AB27(21.4,-17.3) AC2(0.8,-18.15) AC3(1.6,-18.15) AC4(2.4,-18.15) AC5(3.25,-18.15) AC6(4.1,-18.2) AC7(4.9,-18.2) AC8(5.74,-18.2) AC9(6.58,-18.2) AC10(7.38,-18.2) AC11(8.22,-18.2) AC12(9.06,-18.2) AC13(9.86,-18.2) AC14(10.7,-18.2) AC15(11.54,-18.2) AC16(12.34,-18.2) AC17(13.18,-18.2) AC18(14.02,-18.2) AC19(14.82,-18.2) AC20(15.66,-18.2) AC21(16.5,-18.2) AC22(17.3,-18.2) AC23(18.15,-18.15) AC24(19,-18.15) AC25(19.8,-18.15) AC26(20.6,-18.15) AD1(0,-19) AD2(0.8,-19) AD3(1.6,-19) AD4(2.4,-19) AD5(3.25,-19) AD6(4.1,-19) AD7(4.9,-19) AD8(5.74,-19) AD9(6.58,-19) AD10(7.38,-19) AD11(8.22,-19) AD12(9.06,-19) AD13(9.86,-19) AD14(10.7,-19) AD15(11.54,-19) AD16(12.34,-19) AD17(13.18,-19) AD18(14.02,-19) AD19(14.82,-19) AD20(15.66,-19) AD21(16.5,-19) AD22(17.3,-19) AD23(18.15,-19) AD24(19,-19) AD25(19.8,-19) AD26(20.6,-19) AD27(21.4,-19) AE1(0,-19.8) AE2(0.8,-19.8) AE3(1.6,-19.8) AE4(2.4,-19.8) AE5(3.25,-19.8) AE6(4.1,-19.8) AE7(4.9,-19.8) AE8(5.74,-19.8) AE9(6.58,-19.8) AE10(7.38,-19.8) AE11(8.22,-19.8) AE12(9.06,-19.8) AE13(9.86,-19.8) AE14(10.7,-19.8) AE15(11.54,-19.8) AE16(12.34,-19.8) AE17(13.18,-19.8) AE18(14.02,-19.8) AE19(14.82,-19.8) AE20(15.66,-19.8) AE21(16.5,-19.8) AE22(17.3,-19.8) AE23(18.15,-19.8) AE24(19,-19.8) AE25(19.8,-19.8) AE26(20.6,-19.8) AE27(21.4,-19.8) AF1(0,-20.6) AF2(0.8,-20.6) AF3(1.6,-20.6) AF4(2.4,-20.6) AF5(3.25,-20.6) AF6(4.1,-20.6) AF7(4.9,-20.6) AF8(5.74,-20.6) AF9(6.58,-20.6) AF10(7.38,-20.6) AF11(8.22,-20.6) AF12(9.06,-20.6) AF13(9.86,-20.6) AF14(10.7,-20.6) AF15(11.54,-20.6) AF16(12.34,-20.6) AF17(13.18,-20.6) AF18(14.02,-20.6) AF19(14.82,-20.6) AF20(15.66,-20.6) AF21(16.5,-20.6) AF22(17.3,-20.6) AF23(18.15,-20.6) AF24(19,-20.6) AF25(19.8,-20.6) AF26(20.6,-20.6) AF27(21.4,-20.6) AG2(0.8,-21.4) AG3(1.6,-21.4) AG4(2.4,-21.4) AG6(4.1,-21.4) AG7(4.9,-21.4) AG9(6.58,-21.4) AG10(7.38,-21.4) AG12(9.06,-21.4) AG13(9.86,-21.4) AG15(11.54,-21.4) AG16(12.34,-21.4) AG18(14.02,-21.4) AG19(14.82,-21.4) AG21(16.5,-21.4) AG22(17.3,-21.4) AG24(19,-21.4) AG25(19.8,-21.4) AG26(20.6,-21.4) B1(0,-0.8) B2(0.8,-0.8) B3(1.6,-0.8) B4(2.4,-0.8) B5(3.25,-0.8) B6(4.1,-0.8) B7(4.9,-0.8) B8(5.74,-0.8) B9(6.58,-0.8) B10(7.38,-0.8) B11(8.22,-0.8) B12(9.06,-0.8) B13(9.86,-0.8) B14(10.7,-0.8) B15(11.54,-0.8) B16(12.34,-0.8) B17(13.18,-0.8) B18(14.02,-0.8) B19(14.82,-0.8) B20(15.66,-0.8) B21(16.5,-0.8) B22(17.3,-0.8) B23(18.15,-0.8) B24(19,-0.8) B25(19.8,-0.8) B26(20.6,-0.8) B27(21.4,-0.8) C1(0,-1.6) C2(0.8,-1.6) C3(1.6,-1.6) C4(2.4,-1.6) C5(3.25,-1.6) C6(4.1,-1.6) C7(4.9,-1.6) C8(5.74,-1.6) C9(6.58,-1.6) C10(7.38,-1.6) C11(8.22,-1.6) C12(9.06,-1.6) C13(9.86,-1.6) C14(10.7,-1.6) C15(11.54,-1.6) C16(12.34,-1.6) C17(13.18,-1.6) C18(14.02,-1.6) C19(14.82,-1.6) C20(15.66,-1.6) C21(16.5,-1.6) C22(17.3,-1.6) C23(18.15,-1.6) C24(19,-1.6) C25(19.8,-1.6) C26(20.6,-1.6) C27(21.4,-1.6) D1(0,-2.4) D2(0.8,-2.4) D3(1.6,-2.4) D4(2.4,-2.4) D5(3.25,-2.4) D6(4.1,-2.4) D7(4.9,-2.4) D8(5.74,-2.4) D9(6.58,-2.4) D10(7.38,-2.4) D11(8.22,-2.4) D12(9.06,-2.4) D13(9.86,-2.4) D14(10.7,-2.4) D15(11.54,-2.4) D16(12.34,-2.4) D17(13.18,-2.4) D18(14.02,-2.4) D19(14.82,-2.4) D20(15.66,-2.4) D21(16.5,-2.4) D22(17.3,-2.4) D23(18.15,-2.4) D24(19,-2.4) D25(19.8,-2.4) D26(20.6,-2.4) D27(21.4,-2.4) E2(0.8,-3.25) E3(1.6,-3.25) E4(2.4,-3.25) E5(3.25,-3.25) E6(4.1,-3.2) E7(4.9,-3.2) E8(5.74,-3.2) E9(6.58,-3.2) E10(7.38,-3.2) E11(8.22,-3.2) E12(9.06,-3.2) E13(9.86,-3.2) E14(10.7,-3.2) E15(11.54,-3.2) E16(12.34,-3.2) E17(13.18,-3.2) E18(14.02,-3.2) E19(14.82,-3.2) E20(15.66,-3.2) E21(16.5,-3.2) E22(17.3,-3.2) E23(18.15,-3.25) E24(19,-3.25) E25(19.8,-3.25) E26(20.6,-3.25) F1(0,-4.1) F2(0.8,-4.1) F3(1.6,-4.1) F4(2.4,-4.1) F5(3.2,-4.1) F6(4.1,-4.1) F7(4.9,-4.04) F8(5.74,-4.04) F9(6.58,-4.04) F10(7.38,-4.04) F11(8.22,-4.04) F12(9.06,-4.04) F13(9.86,-4.04) F14(10.7,-4.04) F15(11.54,-4.04) F16(12.34,-4.04) F17(13.18,-4.04) F18(14.02,-4.04) F19(14.82,-4.04) F20(15.66,-4.04) F21(16.5,-4.04) F22(17.3,-4.1) F23(18.2,-4.1) F24(19,-4.1) F25(19.8,-4.1) F26(20.6,-4.1) F27(21.4,-4.1) G1(0,-4.9) G2(0.8,-4.9) G3(1.6,-4.9) G4(2.4,-4.9) G5(3.2,-4.9) G6(4.04,-4.9) G7(4.9,-4.9) G8(5.74,-4.9) G9(6.58,-4.84) G10(7.38,-4.84) G12(9.06,-4.84) G13(9.86,-4.84) G14(10.7,-4.84) G15(11.54,-4.84) G16(12.34,-4.84) G18(14.02,-4.84) G19(14.82,-4.84) G20(15.66,-4.9) G21(16.5,-4.9) G22(17.36,-4.9) G23(18.2,-4.9) G24(19,-4.9) G25(19.8,-4.9) G26(20.6,-4.9) G27(21.4,-4.9) H2(0.8,-5.74) H3(1.6,-5.74) H4(2.4,-5.74) H5(3.2,-5.74) H6(4.04,-5.74) H22(17.36,-5.74) H23(18.2,-5.74) H24(19,-5.74) H25(19.8,-5.74) H26(20.6,-5.74) J1(0,-6.58) J2(0.8,-6.58) J3(1.6,-6.58) J4(2.4,-6.58) J5(3.2,-6.58) J6(4.04,-6.58) J7(4.84,-6.58) J21(16.56,-6.58) J22(17.36,-6.58) J23(18.2,-6.58) J24(19,-6.58) J25(19.8,-6.58) J26(20.6,-6.58) J27(21.4,-6.58) K1(0,-7.38) K2(0.8,-7.38) K3(1.6,-7.38) K4(2.4,-7.38) K5(3.2,-7.38) K6(4.04,-7.38) K7(4.84,-7.38) K21(16.56,-7.38) K22(17.36,-7.38) K23(18.2,-7.38) K24(19,-7.38) K25(19.8,-7.38) K26(20.6,-7.38) K27(21.4,-7.38) L2(0.8,-8.22) L3(1.6,-8.22) L4(2.4,-8.22) L5(3.2,-8.22) L6(4.04,-8.22) L22(17.36,-8.22) L23(18.2,-8.22) L24(19,-8.22) L25(19.8,-8.22) L26(20.6,-8.22) M1(0,-9.06) M2(0.8,-9.06) M3(1.6,-9.06) M4(2.4,-9.06) M5(3.2,-9.06) M6(4.04,-9.06) M7(4.84,-9.06) M21(16.56,-9.06) M22(17.36,-9.06) M23(18.2,-9.06) M24(19,-9.06) M25(19.8,-9.06) M26(20.6,-9.06) M27(21.4,-9.06) N1(0,-9.86) N2(0.8,-9.86) N3(1.6,-9.86) N4(2.4,-9.86) N5(3.2,-9.86) N6(4.04,-9.86) N7(4.84,-9.86) N21(16.56,-9.86) N22(17.36,-9.86) N23(18.2,-9.86) N24(19,-9.86) N25(19.8,-9.86) N26(20.6,-9.86) N27(21.4,-9.86) P2(0.8,-10.7) P3(1.6,-10.7) P4(2.4,-10.7) P5(3.2,-10.7) P6(4.04,-10.7) P22(17.36,-10.7) P23(18.2,-10.7) P24(19,-10.7) P25(19.8,-10.7) P26(20.6,-10.7) R1(0,-11.54) R2(0.8,-11.54) R3(1.6,-11.54) R4(2.4,-11.54) R5(3.2,-11.54) R6(4.04,-11.54) R7(4.84,-11.54) R21(16.56,-11.54) R22(17.36,-11.54) R23(18.2,-11.54) R24(19,-11.54) R25(19.8,-11.54) R26(20.6,-11.54) R27(21.4,-11.54) T1(0,-12.34) T2(0.8,-12.34) T3(1.6,-12.34) T4(2.4,-12.34) T5(3.2,-12.34) T6(4.04,-12.34) T7(4.84,-12.34) T21(16.56,-12.34) T22(17.36,-12.34) T23(18.2,-12.34) T24(19,-12.34) T25(19.8,-12.34) T26(20.6,-12.34) T27(21.4,-12.34) U2(0.8,-13.18) U3(1.6,-13.18) U4(2.4,-13.18) U5(3.2,-13.18) U6(4.04,-13.18) U22(17.36,-13.18) U23(18.2,-13.18) U24(19,-13.18) U25(19.8,-13.18) U26(20.6,-13.18) V1(0,-14.02) V2(0.8,-14.02) V3(1.6,-14.02) V4(2.4,-14.02) V5(3.2,-14.02) V6(4.04,-14.02) V7(4.84,-14.02) V21(16.56,-14.02) V22(17.36,-14.02) V23(18.2,-14.02) V24(19,-14.02) V25(19.8,-14.02) V26(20.6,-14.02) V27(21.4,-14.02) W1(0,-14.82) W2(0.8,-14.82) W3(1.6,-14.82) W4(2.4,-14.82) W5(3.2,-14.82) W6(4.04,-14.82) W7(4.84,-14.82) W21(16.56,-14.82) W22(17.36,-14.82) W23(18.2,-14.82) W24(19,-14.82) W25(19.8,-14.82) W26(20.6,-14.82) W27(21.4,-14.82) Y2(0.8,-15.66) Y3(1.6,-15.66) Y4(2.4,-15.66) Y5(3.2,-15.66) Y6(4.04,-15.66) Y22(17.36,-15.66) Y23(18.2,-15.66) Y24(19,-15.66) Y25(19.8,-15.66) Y26(20.6,-15.66)
  round 0.406 smd: K10(6.7,-6.7) K11(7.7,-6.7) K12(8.7,-6.7) K13(9.7,-6.7) K14(10.7,-6.7) K15(11.7,-6.7) K16(12.7,-6.7) K17(13.7,-6.7) K18(14.7,-6.7) L10(6.7,-7.7) L11(7.7,-7.7) L12(8.7,-7.7) L13(9.7,-7.7) L14(10.7,-7.7) L15(11.7,-7.7) L16(12.7,-7.7) L17(13.7,-7.7) L18(14.7,-7.7) M10(6.7,-8.7) M11(7.7,-8.7) M12(8.7,-8.7) M13(9.7,-8.7) M14(10.7,-8.7) M15(11.7,-8.7) M16(12.7,-8.7) M17(13.7,-8.7) M18(14.7,-8.7) N10(6.7,-9.7) N11(7.7,-9.7) N12(8.7,-9.7) N13(9.7,-9.7) N14(10.7,-9.7) N15(11.7,-9.7) N16(12.7,-9.7) N17(13.7,-9.7) N18(14.7,-9.7) P10(6.7,-10.7) P11(7.7,-10.7) P12(8.7,-10.7) P13(9.7,-10.7) P14(10.7,-10.7) P15(11.7,-10.7) P16(12.7,-10.7) P17(13.7,-10.7) P18(14.7,-10.7) R10(6.7,-11.7) R11(7.7,-11.7) R12(8.7,-11.7) R13(9.7,-11.7) R14(10.7,-11.7) R15(11.7,-11.7) R16(12.7,-11.7) R17(13.7,-11.7) R18(14.7,-11.7) T10(6.7,-12.7) T11(7.7,-12.7) T12(8.7,-12.7) T13(9.7,-12.7) T14(10.7,-12.7) T15(11.7,-12.7) T16(12.7,-12.7) T17(13.7,-12.7) T18(14.7,-12.7) U10(6.7,-13.7) U11(7.7,-13.7) U12(8.7,-13.7) U13(9.7,-13.7) U14(10.7,-13.7) U15(11.7,-13.7) U16(12.7,-13.7) U17(13.7,-13.7) U18(14.7,-13.7) V10(6.7,-14.7) V11(7.7,-14.7) V12(8.7,-14.7) V13(9.7,-14.7) V14(10.7,-14.7) V15(11.7,-14.7) V16(12.7,-14.7) V17(13.7,-14.7) V18(14.7,-14.7)
NTR4502PT1G_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
OZ777FJ2LN_QFN48_6X6
  oval 0.203x0.889 smd: 1(0,0) 2(0.4,0) 3(0.8,0) 4(1.2,0) 5(1.6,0) 6(2,0) 7(2.4,0) 8(2.8,0) 9(3.2,0) 10(3.6,0) 11(4,0) 12(4.4,0) 25(4.4,6.1) 26(4,6.1) 27(3.6,6.1) 28(3.2,6.1) 29(2.8,6.1) 30(2.4,6.1) 31(2,6.1) 32(1.6,6.1) 33(1.2,6.1) 34(0.8,6.1) 35(0.4,6.1) 36(0,6.1)
  oval 0.889x0.203 smd: 13(5.25,0.85) 14(5.25,1.25) 15(5.25,1.65) 16(5.25,2.05) 17(5.25,2.45) 18(5.25,2.85) 19(5.25,3.25) 20(5.25,3.65) 21(5.25,4.05) 22(5.25,4.45) 23(5.25,4.85) 24(5.25,5.25) 37(-0.85,5.25) 38(-0.85,4.85) 39(-0.85,4.45) 40(-0.85,4.05) 41(-0.85,3.65) 42(-0.85,3.25) 43(-0.85,2.85) 44(-0.85,2.45) 45(-0.85,2.05) 46(-0.85,1.65) 47(-0.85,1.25) 48(-0.85,0.85)
  rect 4.343x4.343 smd: 49(2.2,3.05)
PANAS_ETQP3W2R2WFN_2P
  rect 2.362x3.505 smd: 1(0,0) 2(-6.05,0)
PDS5100H-13_POWERDI5-3
  rect 4.851x3.353 smd: 1(0,0)
  rect 1.397x1.397 smd: 2(3.982,-0.92) 3(3.982,0.92)
PDTA114EU_SC70-3
  oval 0.61x0.559 smd: 1(0,0) 2(-0.65,-1.85) 3(0.65,-1.85)
PESD5V0U2BT_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
PESD24VS2UT_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
PI2DBS212ZHEX_TQFN28_5P5X3P5
  oval 0.254x1.041 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0) 9(4,0) 10(4.5,0) 15(4.5,3.45) 16(4,3.45) 17(3.5,3.45) 18(3,3.45) 19(2.5,3.45) 20(2,3.45) 21(1.5,3.45) 22(1,3.45) 23(0.5,3.45) 24(0,3.45)
  oval 1.041x0.254 smd: 11(4.975,0.975) 12(4.975,1.475) 13(4.975,1.975) 14(4.975,2.475) 25(-0.475,2.475) 26(-0.475,1.975) 27(-0.475,1.475) 28(-0.475,0.975)
  rect 3.988x2.007 smd: 29(2.25,1.725)
PI3C3125LEX_TSSOP14
  oval 0.381x1.626 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.95,0) 5(2.6,0) 6(3.25,0) 7(3.9,0) 8(3.9,5.8) 9(3.25,5.8) 10(2.6,5.8) 11(1.95,5.8) 12(1.3,5.8) 13(0.65,5.8) 14(0,5.8)
PI3L720ZHEX_TQFN42_9X3P5
  oval 0.254x1.041 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0) 9(4,0) 10(4.5,0) 11(5,0) 12(5.5,0) 13(6,0) 14(6.5,0) 15(7,0) 16(7.5,0) 17(8,0) 22(8,3.45) 23(7.5,3.45) 24(7,3.45) 25(6.5,3.45) 26(6,3.45) 27(5.5,3.45) 28(5,3.45) 29(4.5,3.45) 30(4,3.45) 31(3.5,3.45) 32(3,3.45) 33(2.5,3.45) 34(2,3.45) 35(1.5,3.45) 36(1,3.45) 37(0.5,3.45) 38(0,3.45)
  oval 1.041x0.254 smd: 18(8.475,0.975) 19(8.475,1.475) 20(8.475,1.975) 21(8.475,2.475) 39(-0.475,2.475) 40(-0.475,1.975) 41(-0.475,1.475) 42(-0.475,0.975)
  rect 7.544x2.057 smd: 43(4,1.725)
PI3USB102ZLEX_TQFN10_1P6X1P3
  oval 0.203x0.711 smd: 1(0,0) 2(0.4,0.001) 6(0.4,0.9) 7(0,0.9)
  oval 0.66x0.203 smd: 3(1.025,0.051) 4(1.025,0.451) 5(1.025,0.85) 8(-0.625,0.85) 9(-0.625,0.451) 10(-0.625,0.051)
PI3V713-AZLEX_TQFN32_6X3
  oval 0.203x0.813 smd: 1(0,0) 2(0.4,0) 3(0.8,0) 4(1.2,0) 5(1.6,0) 6(2,0) 7(2.4,0) 8(2.8,0) 9(3.2,0) 10(3.6,0) 11(4,0) 17(4,3.177) 18(3.6,3.177) 19(3.2,3.177) 20(2.8,3.177) 21(2.4,3.177) 22(2,3.177) 23(1.6,3.177) 24(1.2,3.177) 25(0.8,3.177) 26(0.4,3.177) 27(0,3.177)
  oval 0.813x0.203 smd: 12(5.088,0.789) 13(5.088,1.189) 14(5.088,1.589) 15(5.088,1.989) 16(5.088,2.389) 28(-1.089,2.389) 29(-1.089,1.989) 30(-1.089,1.589) 31(-1.089,1.189) 32(-1.089,0.789)
  rect 5.004x2.007 smd: 33(2,1.589)
PI5A3157CEX_SC70-6
  oval 0.406x0.508 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.9) 5(0.65,1.9) 6(0,1.9)
PMST3904_SOT323-3
  oval 0.508x0.559 smd: 1(0,0) 2(-0.65,-1.85) 3(0.65,-1.85)
PROCO_879J-N006-00A0_8P
  round 1.092 hole 1.092 unplated: (-9.41,1.19)
  round 1.6 hole 1.6 unplated: (3.53,11.04)
  rect 1.092x1.194 smd: 1(0,0) 2(0,7.6) 3(-2.54,0) 4(-2.54,7.6) 5(-5.08,0) 6(-5.08,7.6)
  rect 1.194x1.092 smd: 7(-7.85,11.41)
  rect 1.194x1.194 smd: 8(-1.255,11.41)
  rect 1.448x2.692 smd: 9(7.285,1.39) 10(-11.215,1.39) 11(7.285,11.34) 12(-11.215,11.34)
PS8713BTQFN24GTR2_TQFN24_4X4
  oval 0.254x1.016 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 13(2.5,3.975) 14(2,3.975) 15(1.5,3.975) 16(1,3.975) 17(0.5,3.975) 18(0,3.975)
  oval 1.016x0.254 smd: 7(3.238,0.738) 8(3.238,1.238) 9(3.238,1.738) 10(3.238,2.238) 11(3.238,2.738) 12(3.238,3.238) 19(-0.738,3.238) 20(-0.738,2.738) 21(-0.738,2.238) 22(-0.738,1.738) 23(-0.738,1.238) 24(-0.738,0.738)
  rect 2.692x2.692 smd: 25(1.25,1.988)
R0402_0OHM
  rect 0.508x0.559 smd: 1(0,0) 2(0.914,0)
R0603_0OHM
  rect 0.635x0.889 smd: 1(0,0) 2(1.397,0)
R0805_0OHM
  rect 0.813x1.397 smd: 1(0,0) 2(1.702,0)
R_0402
  rect 0.508x0.559 smd: 1(0,0) 2(0.914,0)
R_0603
  rect 0.635x0.889 smd: 1(0,0) 2(1.397,0)
R_0805
  rect 0.813x1.397 smd: 1(0,0) 2(1.702,0)
R_1206
  rect 1.016x1.651 smd: 1(0,0) 2(2.667,0)
R_1206_4P-D
  custom 0.445x0.445 smd: 1(0,0) 4(5.004,0)
  custom 0.114x0.114 smd: 2(1.194,0) 3(3.81,0)
RB751S40T1_SOD523-2
  rect 0.406x0.406 smd: 1(0,0) 2(1.4,0)
RB751VM-40TE-17_SOD323-2
  rect 0.787x0.889 smd: 1(0,0) 2(2.1,0)
RP_0804_8P4R
  oval 0.66x0.254 smd: 1(0,0) 2(0,-0.5) 3(0,-1) 4(0,-1.5) 5(1.15,-1.5) 6(1.15,-1) 7(1.15,-0.5) 8(1.15,0)
RT8237EZQW-2_WDFN10_3X3
  oval 0.254x0.889 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2,3.1) 7(1.5,3.1) 8(1,3.1) 9(0.5,3.1) 10(0,3.1)
  rect 2.464x1.626 smd: 11(1,1.55)
RT8813AGQW_WQFN24_4X4
  oval 0.254x1.041 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 13(2.5,3.95) 14(2,3.95) 15(1.5,3.95) 16(1,3.95) 17(0.5,3.95) 18(0,3.95)
  oval 1.041x0.254 smd: 7(3.225,0.725) 8(3.225,1.225) 9(3.225,1.725) 10(3.225,2.225) 11(3.225,2.725) 12(3.225,3.225) 19(-0.725,3.225) 20(-0.725,2.725) 21(-0.725,2.225) 22(-0.725,1.725) 23(-0.725,1.225) 24(-0.725,0.725)
  rect 2.515x2.515 smd: 25(1.25,1.975)
RT9818A-44GU3_SC70-3
  oval 0.61x0.787 smd: 1(0,0) 2(-0.65,-1.9) 3(0.65,-1.9)
RTD2136S-VE-CG_QFN48_6X6
  oval 0.203x1.041 smd: 1(0,0) 2(0.4,0) 3(0.8,0) 4(1.2,0) 5(1.6,0) 6(2,0) 7(2.4,0) 8(2.8,0) 9(3.2,0) 10(3.6,0) 11(4,0) 12(4.4,0) 25(4.4,5.95) 26(4,5.95) 27(3.6,5.95) 28(3.2,5.95) 29(2.8,5.95) 30(2.4,5.95) 31(2,5.95) 32(1.6,5.95) 33(1.2,5.95) 34(0.8,5.95) 35(0.4,5.95) 36(0,5.95)
  oval 1.041x0.203 smd: 13(5.175,0.775) 14(5.175,1.175) 15(5.175,1.575) 16(5.175,1.975) 17(5.175,2.375) 18(5.175,2.775) 19(5.175,3.175) 20(5.175,3.575) 21(5.175,3.975) 22(5.175,4.375) 23(5.175,4.775) 24(5.175,5.175) 37(-0.775,5.175) 38(-0.775,4.775) 39(-0.775,4.375) 40(-0.775,3.975) 41(-0.775,3.575) 42(-0.775,3.175) 43(-0.775,2.775) 44(-0.775,2.375) 45(-0.775,1.975) 46(-0.775,1.575) 47(-0.775,1.175) 48(-0.775,0.775)
  rect 3.962x3.962 smd: 49(2.2,2.975)
SAMTE_BSH-030-01-L-D-A_60P
  round 1.016 hole 1.016 unplated: (-2.81,5.53) (17.316,5.53)
  oval 0.279x2.261 smd: 1(0,0) 2(0,5.728) 3(0.5,0) 4(0.5,5.728) 5(1,0) 6(1,5.728) 7(1.5,0) 8(1.5,5.728) 9(2,0) 10(2,5.728) 11(2.5,0) 12(2.5,5.728) 13(3,0) 14(3,5.728) 15(3.5,0) 16(3.5,5.728) 17(4,0) 18(4,5.728) 19(4.5,0) 20(4.5,5.728) 21(5,0) 22(5,5.728) 23(5.5,0) 24(5.5,5.728) 25(6,0) 26(6,5.728) 27(6.5,0) 28(6.5,5.728) 29(7,0) 30(7,5.728) 31(7.5,0) 32(7.5,5.728) 33(8,0) 34(8,5.728) 35(8.5,0) 36(8.5,5.728) 37(9,0) 38(9,5.728) 39(9.5,0) 40(9.5,5.728) 41(10,0) 42(10,5.728) 43(10.5,0) 44(10.5,5.728) 45(11,0) 46(11,5.728) 47(11.5,0) 48(11.5,5.728) 49(12,0) 50(12,5.728) 51(12.5,0) 52(12.5,5.728) 53(13,0) 54(13,5.728) 55(13.5,0) 56(13.5,5.728) 57(14,0) 58(14,5.728) 59(14.5,0) 60(14.5,5.728)
SANTA_201902-1_13P
  oval 0.711x2.54 smd: 1(0,0) 2(-1.27,0) 3(-2.54,0) 4(-3.81,0) 5(-5.08,0) 6(-6.35,0) 7(-7.62,0) 8(-13.83,0.345) 9(-14.83,0.345) 10(-15.83,0.345) 11(-16.83,0.345) 12(-17.83,0.345) 13(-18.83,0.345)
  oval 1.194x2.438 hole 0.508x1.753: 14(1.895,0.145) 15(-20.655,0.145)
SANTA_373130-1_9P
  round 0.991 hole 0.711: 1(0,0) 2(-2.5,0) 3(-4.5,0) 4(-7,0) 5(-7.5,-1.5) 6(-5.5,-1.5) 7(-3.5,-1.5) 8(-1.5,-1.5) 9(0.5,-1.5)
  oval 1.397x3.2 hole 0.787x2.591: 10(4.35,-2.38) 13(-11.35,-2.38)
  oval 1.397x2.388 hole 0.787x1.803: 11(4.35,-9.48) 12(-11.35,-9.48)
SDMK0340L-7-F_SOD323-2
  rect 1.346x0.66 smd: 1(0,0) 2(2.4,0)
SHORTPADS
  custom 0.19x0.19 smd: 1(-0.483,0) 2(0.483,0)
SI3456DDV-T1-GE3_TSOP6
  oval 0.508x1.422 smd: 1(0,0) 2(0.95,0) 3(1.9,0) 4(1.9,2.44) 5(0.95,2.44) 6(0,2.44)
SI3457CDV-T1-GE3_TSOP6
  oval 0.508x1.422 smd: 1(0,0) 2(0.95,0) 3(1.9,0) 4(1.9,2.44) 5(0.95,2.44) 6(0,2.44)
SI3993CDV-T1-GE3_TSOP6
  oval 0.508x1.422 smd: 1(0,0) 2(0.95,0) 3(1.9,0) 4(1.9,2.44) 5(0.95,2.44) 6(0,2.44)
SI4128DY-T1-GE3_SO8
  oval 0.635x1.727 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0) 5(3.81,5.285) 6(2.54,5.285) 7(1.27,5.285) 8(0,5.285)
SI4134DY-T1-GE3_SO8
  oval 0.635x1.727 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0) 5(3.81,5.285) 6(2.54,5.285) 7(1.27,5.285) 8(0,5.285)
SI4835DDY-T1-GE3_SO8
  oval 0.635x1.727 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0) 5(3.81,5.285) 6(2.54,5.285) 7(1.27,5.285) 8(0,5.285)
SI7716ADN-T1-GE3_POWERPAK8-5
  oval 0.406x0.991 smd: 1(0,0) 2(0.66,0) 3(1.32,0) 4(1.98,0)
  custom 0.559x0.559 smd: 5(0.99,2.247)
SIR472DP-T1-GE3_POWERPAK8-5
  oval 0.61x1.27 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0)
  custom 1.105x1.105 smd: 5(1.905,3.36)
SIRA06DP-T1-GE_POWERPAKSO-8-5
  oval 0.61x1.27 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0)
  custom 1.105x1.105 smd: 5(1.905,3.715)
SIS412DN-T1-GE3_POWERPAK8-5
  oval 0.406x0.991 smd: 1(0,0) 2(0.66,0) 3(1.32,0) 4(1.98,0)
  custom 0.559x0.559 smd: 5(0.99,2.247)
SIS472DN-T1_POWERPAK1212-8-5
  oval 0.406x0.991 smd: 1(0,0) 2(0.66,0) 3(1.32,0) 4(1.98,0)
  custom 0.559x0.559 smd: 5(0.99,2.248)
SRV05-4PTCT_SOT23-6
  oval 0.61x1.092 smd: 1(0,0) 2(0.95,0) 3(1.9,0) 4(1.9,2.5) 5(0.95,2.5) 6(0,2.5)
SW_EVQPLHA15_4P
  rect 1.016x0.61 smd: 1(-2.2,1.85) 2(2.2,1.85) 3(-2.2,-1.85) 4(2.2,-1.85)
  rect 1.016x0.457 smd: 5(0,2.525) 6(0,-2.525)
SWLD_OCF2012181YZF_4P
  rect 0.889x0.406 smd: 1(0,0) 2(1.7,0) 3(1.7,0.8) 4(0,0.8)
SYN470DBC_DFN10_3X3
  oval 0.254x0.889 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2,3.1) 7(1.5,3.1) 8(1,3.1) 9(0.5,3.1) 10(0,3.1)
  rect 2.388x1.575 smd: 11(1,1.55)
TAI-T_TMPC0624H-R68MG-D_2P
  rect 2.946x3.505 smd: 1(0,0) 2(5.45,0)
TAIYO_CBC2012T4R7M_2P
  rect 0.711x1.448 smd: 1(0,0) 2(1.5,0)
TAIYO_FBMJ4516HS720NT_2P
  rect 1.549x1.854 smd: 1(0,0) 2(3.95,0)
TAIYO_NRS4018T1R0NDGJ_2P
  rect 1.194x3.708 smd: 1(0,0) 2(2.8,0)
TC7SH08FU_SSOP5
  oval 0.406x0.787 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.9) 5(0,1.9)
TOKO_FDSD0630-H-1R0M-P3_2P
  rect 2.159x3.505 smd: 1(0,0) 2(5.85,0)
TOKO_FDUE0640J-H-R22M-P3_4P
  custom 0.686x0.686 smd: 1(0,0) 4(8.509,0)
  rect 2.362x0.508 smd: 2(1.448,0) 3(7.061,0)
TPC12
  round 0.305 smd: 1(0,0)
TPS22966DPUR_SON14_2X3
  oval 0.203x0.762 smd: 1(0,0) 2(0.4,0) 3(0.8,0) 4(1.2,0) 5(1.6,0) 6(2,0) 7(2.4,0) 8(2.4,2.05) 9(2,2.05) 10(1.6,2.05) 11(1.2,2.05) 12(0.8,2.05) 13(0.4,2.05) 14(0,2.05)
  rect 2.489x0.889 smd: 15(1.2,1.025)
TPS51225CRUKR_QFN20_3X3
  oval 0.203x0.889 smd: 1(0,0) 2(0.4,0) 3(0.8,0) 4(1.2,0) 5(1.6,0) 11(1.6,3.1) 12(1.2,3.1) 13(0.8,3.1) 14(0.4,3.1) 15(0,3.1)
  oval 0.889x0.203 smd: 6(2.35,0.75) 7(2.35,1.15) 8(2.35,1.55) 9(2.35,1.95) 10(2.35,2.35) 16(-0.75,2.35) 17(-0.75,1.95) 18(-0.75,1.55) 19(-0.75,1.15) 20(-0.75,0.75)
  rect 1.702x1.702 smd: 21(0.8,1.55)
TPS51362RVER_QFN28_4P5X3P5
  oval 0.203x1.041 smd: 1(0,0) 2(0.4,0) 3(0.8,0) 4(1.2,0) 5(1.6,0) 6(2,0) 7(2.4,0) 8(2.8,0) 9(3.2,0) 15(3.2,3.45) 16(2.8,3.45) 17(2.4,3.45) 18(2,3.45) 19(1.6,3.45) 20(1.2,3.45) 21(0.8,3.45) 22(0.4,3.45) 23(0,3.45)
  oval 1.041x0.203 smd: 10(3.825,0.925) 11(3.825,1.325) 12(3.825,1.725) 13(3.825,2.125) 14(3.825,2.525) 24(-0.625,2.525) 25(-0.625,2.125) 26(-0.625,1.725) 27(-0.625,1.325) 28(-0.625,0.925)
  rect 3.099x2.108 smd: 29(1.6,1.725)
TPS51622RSM_QFN32_4X4
  oval 0.203x0.914 smd: 1(0,0) 2(0.4,0) 3(0.8,0) 4(1.2,0) 5(1.6,0) 6(2,0) 7(2.4,0) 8(2.8,0) 17(2.8,4.077) 18(2.4,4.077) 19(2,4.077) 20(1.6,4.077) 21(1.2,4.077) 22(0.8,4.077) 23(0.4,4.077) 24(0,4.077)
  oval 0.914x0.203 smd: 9(3.438,0.639) 10(3.438,1.039) 11(3.438,1.438) 12(3.438,1.838) 13(3.438,2.239) 14(3.438,2.639) 15(3.438,3.039) 16(3.438,3.438) 25(-0.639,3.438) 26(-0.639,3.039) 27(-0.639,2.639) 28(-0.639,2.239) 29(-0.639,1.838) 30(-0.639,1.438) 31(-0.639,1.039) 32(-0.639,0.639)
  rect 2.794x2.794 smd: 33(1.4,2.039)
TS5A63157DCKR_SC70-6
  oval 0.406x0.889 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,2.2) 5(0.65,2.2) 6(0,2.2)
TVNST52302AB0_SOT523-3
  oval 0.508x0.559 smd: 1(0,0) 2(-0.5,-1.4) 3(0.5,-1.4)
TYCO_1-2041070-0_10P
  oval 0.305x1.295 smd: 1(0,0) 2(-0.5,0) 3(-1,0) 4(-1.5,0) 5(-2,0) 6(-2.5,0) 7(-3,0) 8(-3.5,0) 9(-4,0) 10(-4.5,0)
  rect 2.489x1.905 smd: 11(-6.65,3.3) 12(2.15,3.3)
USX2064-AEZG-TR_QFN36_6X6
  oval 0.254x1.245 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0) 9(4,0) 19(4,5.75) 20(3.5,5.75) 21(3,5.75) 22(2.5,5.75) 23(2,5.75) 24(1.5,5.75) 25(1,5.75) 26(0.5,5.75) 27(0,5.75)
  oval 1.245x0.254 smd: 10(4.875,0.875) 11(4.875,1.375) 12(4.875,1.875) 13(4.875,2.375) 14(4.875,2.875) 15(4.875,3.375) 16(4.875,3.875) 17(4.875,4.375) 18(4.875,4.875) 28(-0.875,4.875) 29(-0.875,4.375) 30(-0.875,3.875) 31(-0.875,3.375) 32(-0.875,2.875) 33(-0.875,2.375) 34(-0.875,1.875) 35(-0.875,1.375) 36(-0.875,0.875)
  rect 3.708x3.708 smd: 37(2,2.875)
W25Q32FVSSIQ_SO8
  oval 0.635x1.676 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0) 5(3.81,7.25) 6(2.54,7.25) 7(1.27,7.25) 8(0,7.25)
W25Q64FVSSIQ_SO8
  oval 0.635x1.676 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0) 5(3.81,7.25) 6(2.54,7.25) 7(1.27,7.25) 8(0,7.25)
W25X10BVSNIG_SO8
  oval 0.635x1.854 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0) 5(3.81,5.165) 6(2.54,5.165) 7(1.27,5.165) 8(0,5.165)
WGI218LM-QQ89-B0_QFN48_6X6
  oval 0.203x1.041 smd: 1(0,0) 2(0.4,0) 3(0.8,0) 4(1.2,0) 5(1.6,0) 6(2,0) 7(2.4,0) 8(2.8,0) 9(3.2,0) 10(3.6,0) 11(4,0) 12(4.4,0) 25(4.4,5.95) 26(4,5.95) 27(3.6,5.95) 28(3.2,5.95) 29(2.8,5.95) 30(2.4,5.95) 31(2,5.95) 32(1.6,5.95) 33(1.2,5.95) 34(0.8,5.95) 35(0.4,5.95) 36(0,5.95)
  oval 1.041x0.203 smd: 13(5.175,0.775) 14(5.175,1.175) 15(5.175,1.575) 16(5.175,1.975) 17(5.175,2.375) 18(5.175,2.775) 19(5.175,3.175) 20(5.175,3.575) 21(5.175,3.975) 22(5.175,4.375) 23(5.175,4.775) 24(5.175,5.175) 37(-0.775,5.175) 38(-0.775,4.775) 39(-0.775,4.375) 40(-0.775,3.975) 41(-0.775,3.575) 42(-0.775,3.175) 43(-0.775,2.775) 44(-0.775,2.375) 45(-0.775,1.975) 46(-0.775,1.575) 47(-0.775,1.175) 48(-0.775,0.775)
  rect 2.997x2.997 smd: 49(2.2,2.975)
Y_7V25000034_4P
  rect 1.397x1.194 smd: 1(0,0) 2(2.2,0) 3(2.2,1.8) 4(0,1.8)
Y_Q13FC1350000_2P
  rect 0.991x1.803 smd: 1(0,0) 2(2.5,0)
Y_X1E000021042600_4P
  rect 1.397x1.143 smd: 1(0,0) 2(2.2,0) 3(2.2,1.6) 4(0,1.6)
Y_X3G024000DC1H_4P
  rect 1.397x1.194 smd: 1(0,0) 2(2.2,0) 3(2.2,1.7) 4(0,1.7)
Y_X3G025000DI1H-H_4P
  rect 1.397x1.194 smd: 1(0,0) 2(2.2,0) 3(2.2,1.7) 4(0,1.7)

## Nets
0.675V_DDR_VTT_ON: PR110.1 QD1.2 R28.2 R32.2 U5.4
1.05V_A_PWRGD: PR156.2 PU150.1 U38.B28
1.05V_MODPHY_EN: C207.1 Q142.3 Q143.3 R109.2
1.5V_PWRGD: PR709.2 PU700.1 R165.1
1.5VRUN_FB: PC202.2 PR202.2 PR204.1 PU200.6
1.5VRUN_LX: PL200.1 PR201.1 PU200.2 PU200.3
1.5VRUN_VIN: PC200.1 PC201.1 PJP200.2 PU200.8 PU200.9 PU200.10
1.35V_B+: PC100.1 PC101.1 PC102.1 PC103.1 PJP100.2 PQ100.5 PQ100.6 PQ100.7 PQ100.8 PR106.1
1.35V_FB: PC113.1 PR105.1 PR109.1 PU100.6
1.35V_SUS_PWRGD: PR104.2 PU100.10 U38.B9
3.3V_CAM_EN#: R2602.2 RC198.1 UC1.AM4
3.3V_HDD_EN: RP10.5 U34.4 UC1.K2
3.3V_RUN_GFX_ON: U37.A55
3.3V_TS_EN: Q140.2 RC282.2 UC1.N7
3.3V_TS_EN#: Q137.2 Q138.2 Q140.6 R2605.1
3.3VS_GFX_ON#: QV2806.6 QZ5.2 QZ5.5 QZ21.2 QZ21.5 RV2805.2
3V3AUX: UV1.F11
+0.9V_LAN: C177.1 C180.1 C183.1 C184.1 C185.1 C186.1 L26.2 U21.8 U21.11 U21.16 U21.22 U21.37 U21.40 U21.43 U21.46 U21.47
+0.675V_DDR_VTT: CD26.1 CD27.1 CD28.1 CD29.1 CD30.1 CD31.1 CD54.1 CD55.1 CD56.1 CD57.1 CD58.1 CD59.1 JDIMM1.203 JDIMM1.204 JDIMM2.203 JDIMM2.204 PJP104.2
+0.675V_P: PC105.1 PC106.1 PJP104.1 PU100.2 PU100.20
+1.2V_LDO: C217.2 C218.2 C223.2 L36.1 U27.10 U27.41
+1.2V_LDO_AIN: C230.2 C231.2 C232.2 C233.2 C234.2 L36.2 U27.1 U27.28 U27.31 U27.36
+1.05V_GPU: C154.1 CV86.1 CV88.1 CV89.1 CV90.1 CV91.1 CV94.1 CV95.1 CV96.1 CV3047.1 CV3048.1 CV3049.1 CV3050.1 CV3051.1 CV3052.1 LV74.2 LV76.2 LV80.1 RZ11.1 U19.8 U19.9 UV1.AA10 UV1.AA12 UV1.AA13 UV1.AA16 UV1.AA18 UV1.AA19 UV1.AA20 UV1.AA21 UV1.AA22 UV1.AB22 UV1.AB23 UV1.AC23 UV1.AC24 UV1.AD24 UV1.AD25 UV1.AE25 UV1.AE26 UV1.AE27 UV1.AF26 UV1.AF27
+1.5V_GPU: CV100.1 CV101.1 CV102.1 CV231.1 CV232.1 CV2918.1 CV2919.1 CV2920.1 CV2921.1 CV2926.1 CV2927.1 CV2928.1 CV2929.1 CV2930.1 CV2931.1 CV2932.1 CV2933.1 CV2934.1 CV2935.1 CV2936.1 CV2937.1 CV2938.1 CV2939.1 CV2940.1 CV2945.1 CV2946.1 CV2947.1 CV2948.1 CV2949.1 CV2950.1 CV2951.1 CV2952.1 CV2953.1 CV2954.1 CV2955.1 CV2956.1 CV2957.1 CV2958.1 CV2959.1 CV2960.1 CV2961.1 CV2962.1 CV2963.1 CV2964.1 CV2965.1 CV2966.1 CV2967.1 CV2968.1 CV2969.1 CV3058.1 CV3059.1 CV3060.1 PJP701.2 PJP702.2 RV2704.2 RV2705.2 RV2709.1 RV2711.1 RV2713.1 RV2716.1 RV2720.2 RZ10.1 UV1.B26 UV1.C25 UV1.E23 UV1.E26 UV1.F14 UV1.F21 UV1.G13 UV1.G14 UV1.G15 UV1.G16 UV1.G18 UV1.G19 UV1.G20 UV1.G21 UV1.H24 UV1.H26 UV1.J21 UV1.K21 UV1.L22 UV1.L24 UV1.L26 UV1.M21 UV1.N21 UV1.R21 UV1.T21 UV1.V21 UV1.W21 UV4.A1 UV4.A8 UV4.B2 UV4.C1 UV4.C9 UV4.D2 UV4.D9 UV4.E9 UV4.F1 UV4.G7 UV4.H2 UV4.H9 UV4.K2 UV4.K8 UV4.N1 UV4.N9 UV4.R1 UV4.R9 UV5.A1 UV5.A8 UV5.B2 UV5.C1 UV5.C9 UV5.D2 UV5.D9 UV5.E9 UV5.F1 UV5.G7 UV5.H2 UV5.H9 UV5.K2 UV5.K8 UV5.N1 UV5.N9 UV5.R1 UV5.R9 UV6.A1 UV6.A8 UV6.B2 UV6.C1 UV6.C9 UV6.D2 UV6.D9 UV6.E9 UV6.F1 UV6.G7 UV6.H2 UV6.H9 UV6.K2 UV6.K8 UV6.N1 UV6.N9 UV6.R1 UV6.R9 UV7.A1 UV7.A8 UV7.B2 UV7.C1 UV7.C9 UV7.D2 UV7.D9 UV7.E9 UV7.F1 UV7.G7 UV7.H2 UV7.H9 UV7.K2 UV7.K8 UV7.N1 UV7.N9 UV7.R1 UV7.R9
+1.05V_M: C30.1 CC46.1 CC47.1 CC73.1 LC4.1 PJP151.2 Q142.1 Q142.2 Q142.5 Q142.6 RC16.1 RC272.1 RC276.1 U43.6 U43.7 U94.1 U94.2 U94.9 UC1.AE9 UC1.AF9 UC1.AG8 UC1.AG13 UC1.AG14
+1.05V_M_JTAG: RC10.2 RC16.2 RC17.2 RC18.2 RC20.2
+1.05V_MODPHY: C3.1 C75.1 LC1.1 LC2.1 Q142.4 RC262.1 U94.6 U94.7 U94.8
+1.05V_MODPHY_PCH: CC27.1 CC29.1 CC74.1 RC262.2 UC1.K9 UC1.L10 UC1.M9
+1.05V_MP: PC158.2 PC159.2 PC163.2 PJP151.1 PJP152.1 PL150.2 PU150.22
+1.5V_RUN: C635.1 C636.1 JEXP1.1 JEXP1.3 JEXP1.5 JEXP1.7 PJP201.2 RC254.1 U91.9 U91.11 U91.13 U91.19 U91.26 U91.28
+1.05V_RUN: C393.1 CC10.1 CC11.1 CC31.1 CC33.1 CC34.1 CC37.1 CC60.1 CC63.1 CC64.1 CC71.1 JXDP1.43 JXDP1.44 L1.1 L4.1 LC3.1 LC5.1 LC6.1 PJP11.1 R335.1 R374.2 R403.1 RC118.1 RC119.1 RC120.1 RC122.1 RC242.2 RC253.1 RC280.1 U43.8 U43.9 UC1.AE8 UC1.AF22 UC1.AG16 UC1.AG17 UC1.H11 UC1.H15 UC1.J11 UC1.J17 UC1.N8 UC1.P9 UC1.R21 UC1.T21
+1.5V_RUNP: PC202.1 PC203.1 PC204.1 PC205.1 PJP201.1 PL200.2 PR202.1
+1.5V_THERMAL: RC254.2 UC1.J15
+1.05V_VCCST: CC26.1 CC50.1 PC319.1 PJP11.2 PR330.1 PR331.1 R24.1 RC113.1 RC114.1 RC243.2 RC244.1 RC249.1 RC255.1 UC1.AC22 UC1.AE22 UC1.AE23
+1.05V_VMM_VDD: C8.1 C9.1 C10.1 C11.1 C12.1 C17.1 C18.1 C25.1 L1.2 U6.C8 U6.C9 U6.E3 U6.E5 U6.E6 U6.E7 U6.E8 U6.E9 U6.F12 U6.G3 U6.G12 U6.H6 U6.H7 U6.H8 U6.H9
+1.05V_VMM_VDDTX: C21.1 C22.1 C23.1 C24.1 L4.2 U6.C6 U6.C7 U6.D3 U6.D12 U6.E10 U6.E12 U6.F3 U6.H3 U6.H11 U6.J2 U6.J3 U6.J10 U6.K8 U6.K9 U6.K10
+1.8V_RUN_CARD: C228.1 C229.1 C246.1 C247.1 JSD1.14 U27.24
+1.35V_MEM: CC12.1 CC13.1 CC16.1 CC17.1 CC18.1 CC19.1 CC20.1 CC21.1 CC52.1 CC81.1 CD4.1 CD5.1 CD6.1 CD7.1 CD8.1 CD9.1 CD10.1 CD11.1 CD14.1 CD15.1 CD16.1 CD17.1 CD18.1 CD19.1 CD20.1 CD21.1 CD22.1 CD23.1 CD35.1 CD36.1 CD37.1 CD38.1 CD39.1 CD40.1 CD41.1 CD42.1 CD45.1 CD46.1 CD47.1 CD48.1 CD49.1 CD50.1 CD51.1 CD52.1 CD53.1 JDIMM1.75 JDIMM1.76 JDIMM1.81 JDIMM1.82 JDIMM1.87 JDIMM1.88 JDIMM1.93 JDIMM1.94 JDIMM1.99 JDIMM1.100 JDIMM1.105 JDIMM1.106 JDIMM1.111 JDIMM1.112 JDIMM1.117 JDIMM1.118 JDIMM1.123 JDIMM1.124 JDIMM2.75 JDIMM2.76 JDIMM2.81 JDIMM2.82 JDIMM2.87 JDIMM2.88 JDIMM2.93 JDIMM2.94 JDIMM2.99 JDIMM2.100 JDIMM2.105 JDIMM2.106 JDIMM2.111 JDIMM2.112 JDIMM2.117 JDIMM2.118 JDIMM2.123 JDIMM2.124 PJP102.2 PJP103.2 QD1.1 RC67.1 RC130.1 RC217.1 RD3.1 U5.5 UC1.AH26 UC1.AJ31 UC1.AJ33 UC1.AJ37 UC1.AN33 UC1.AP43 UC1.AR48 UC1.AY35 UC1.AY40 UC1.AY44 UC1.AY50
+1.35V_MEN_P: PC113.2 PC114.1 PC116.1 PJP101.2 PJP102.1 PJP103.1 PL100.1 PR105.2 PU100.5
+3.3V_ALW: C328.1 C348.1 C375.1 C386.1 C404.1 C452.1 C458.2 C459.2 C461.1 C462.1 CC24.1 CV87.1 JKB1.7 JUDB1.7 PC433.1 PC500.2 PC502.2 PJP6.1 PJP7.1 PJP53.2 PJP200.1 PR2.1 PR8.1 PR58.1 PR104.1 PR156.1 PR449.1 PR500.2 PR504.1 PR506.1 PR553.2 PR567.2 PU403.8 PU405.5 PU500.5 PU502.5 R36.1 R228.2 R272.2 R282.1 R283.1 R284.1 R285.1 R286.1 R288.1 R289.1 R291.1 R292.1 R293.1 R295.1 R296.1 R298.1 R302.1 R317.2 R322.1 R340.1 R343.1 R363.1 R380.1 R386.1 R388.1 R389.1 R391.1 R392.1 R393.1 R395.1 R396.1 R397.1 R398.1 R402.1 R428.1 R432.1 R440.1 R476.2 R477.2 R478.2 R479.2 R481.2 R490.2 R491.1 R492.1 RC264.1 RC267.1 RP2.5 RP2.6 RP2.7 RP2.8 RP7.5 RP7.6 RP7.7 RP7.8 RP15.7 RP15.8 RP16.2 RP16.3 RP16.4 RP17.7 RP17.8 RP18.1 RV2805.1 U18.1 U18.2 U22.2 U33.2 U34.2 U42.5 U43.1 U43.2 U45.1 U45.2 U45.6 U45.7 U46.6 U46.7 U47.5 U51.1 U51.2 U51.6 U51.7 U86.5 U87.5 UC4.5 UV14.5
+3.3V_ALW2: CC82.1 PC51.2 PC507.1 PC508.1 PC510.1 PC515.1 PR440.1 PR446.1 PR505.1 PR508.1 PR518.2 PR521.1 PR522.1 PR526.2 PR532.1 PR538.1 PR539.2 PR550.1 PR557.1 PR568.2 PU51.3 PU503.5 PU504.5 PU505.5 PU506.5 R108.1 R367.2 RTCD1.3 UC7.5
+3.3V_ALW_5048: C329.1 C330.1 C331.1 C332.1 C334.1 PJP6.2 U37.A17 U37.A43 U37.A54 U37.B5 U37.B30
+3.3V_ALW_5075: C349.1 C350.1 C351.1 C354.1 C355.1 C356.1 PJP7.2 R336.1 R461.1 U38.A11 U38.A26 U38.A41 U38.A52 U38.B3 U38.B35
+3.3V_ALW_PCH: C389.1 CC28.1 CC44.1 JAPS1.1 RC3.1 RC27.1 RC28.1 RC30.1 RC36.2 RC37.2 RC70.1 RC74.1 RC98.1 RC102.2 RC175.2 RC186.2 RC190.1 RC192.2 RC230.1 RC261.1 RC265.1 RP3.8 RP12.1 RP12.2 RP12.3 RP12.4 RP13.5 RP13.6 RP13.7 RP13.8 RP14.2 RP14.3 RP14.4 U43.13 U43.14 UC1.AA9 UC1.AC9 UC1.AE20 UC1.AE21 UC1.AH14
+3.3V_ALW_PCH_U41: C387.1 R411.2 U41.1
+3.3V_ALWP: PC71.1 PJP53.1 PL52.1 PR51.1
+3.3V_AVCC: C443.1 C444.1 L50.2 U52.5
+3.3V_CAM: C451.1 JLVDS1.1 PJP10.1
+3.3V_CAM_Q: PJP10.2 Q126.1
+3.3V_DVCC: C441.1 C442.1 L49.2 R2582.2 R2584.2 R2590.2 R2591.2 U52.18 U52.22
+3.3V_GPU: C153.1 CV226.1 CV3053.1 CV3054.1 QC6.5 QC8.2 QC8.5 QC9.2 QC9.5 QC11.2 QC11.5 R347.2 RV34.2 RV35.2 RV48.2 RV49.1 RV50.1 RV94.2 RV2404.2 RV2433.1 RV2446.2 RV2647.1 RV2649.1 RV2651.1 RV2653.1 RZ41.1 U19.13 U19.14 UV1.AA8 UV1.AA9 UV1.AB8
+3.3V_HDD: C431.1 PJP9.1 R124.1 U34.3
+3.3V_HDD_C: C113.1 C114.1 JSATA1.8 JSATA1.9 PJP9.2
+3.3V_LAN: C188.1 C192.1 C193.1 C194.1 C198.1 C206.1 C482.1 JIO1.13 PJP806.2 R171.1 R172.1 R176.2 R178.1 R181.1 U23.1 U23.4 U23.8 U23.14 U23.21 U23.30 U23.39 U24.5
+3.3V_LAN_OUT: C182.1 R181.2 U21.4 U21.5 U21.15 U21.19 U21.29
+3.3V_LANP: C426.1 PJP806.1 U22.3
+3.3V_M: C5.1 C6.1 C396.1 CC40.1 JTAA1.2 JTAA1.4 R1.1 R2.1 U1.8 U2.8 U45.13 U45.14 UC1.Y8
+3.3V_PCIE_WWAN: C248.1 C249.1 C250.1 C251.1 C252.1 C253.1 JMINI2.2 JMINI2.24 JMINI2.39 JMINI2.41 JMINI2.52 PJP805.2 Q30.5 R216.1 R217.1 R226.2 R480.2
+3.3V_PCIE_WWANP: C425.1 PJP805.1 U51.8 U51.9
+3.3V_RUN: C34.1 C93.1 C97.1 C210.1 C211.1 C212.1 C219.2 C224.2 C225.2 C226.2 C268.1 C338.1 C403.1 C406.2 C414.1 C440.1 C456.1 C634.1 C1189.1 C2962.1 C2963.1 C2964.1 C2965.1 C2972.1 C2987.1 C2988.1 C2989.1 C2990.1 C2991.1 C3022.1 CC8.1 CC9.1 CC41.1 CC43.1 CC45.1 CC59.1 CD24.1 CD25.1 CD60.1 CD61.1 JBIO1.1 JDIMM1.199 JDIMM2.199 JEXP1.2 JEXP1.4 JEXP1.6 JIO1.15 JLVDS1.38 JPWR1.3 L2.2 L5.1 L35.1 L49.1 L50.1 PJP2.1 PJP5.1 PJP8.1 PJP12.1 PR319.2 PR320.2 PR600.1 PR603.1 PR626.1 PR628.2 PU300.20 PU300.21 Q122.2 Q122.5 Q126.3 Q138.3 QC1.2 QC1.5 QZ22.2 R35.1 R40.2 R42.2 R44.2 R46.2 R49.2 R54.2 R55.2 R64.1 R65.1 R69.2 R91.2 R122.1 R123.1 R126.1 R150.1 R161.2 R164.2 R168.1 R170.1 R212.1 R232.2 R304.1 R331.2 R358.1 R360.1 R362.1 R376.1 R408.1 R419.1 R459.1 R460.1 R473.1 R475.2 R484.1 R556.1 R2627.1 R2628.1 R2629.1 R2630.1 R2631.1 R2633.1 R2635.1 R2636.1 R2637.1 RC11.2 RC12.2 RC38.2 RC55.1 RC80.1 RC81.1 RC116.1 RC137.1 RC138.1 RC140.1 RC146.1 RC147.1 RC148.1 RC149.1 RC166.1 RC170.2 RC183.1 RC185.1 RC193.1 RC199.2 RC218.1 RC222.1 RC259.1 RC282.1 RC283.1 RC284.1 RC285.1 RC286.1 RC289.1 RC290.1 RC291.1 RC315.2 RD10.2 RP1.1 RP1.2 RP1.3 RP1.4 RP5.5 RP5.6 RP5.7 RP5.8 RP6.5 RP6.6 RP6.7 RP6.8 RP8.1 RP8.2 RP8.3 RP8.4 RP9.1 RP9.2 RP9.3 RP9.4 RP10.1 RP10.2 RP10.3 RP10.4 RP11.1 RP11.2 RP11.3 RP11.4 U7.8 U11.14 U13.14 U19.1 U19.2 U20.5 U27.11 U27.13 U27.23 U27.42 U30.5 U39.4 U39.23 U39.29 U39.32 U46.8 U46.9 U83.1 U83.13 U93.5 UC1.K14 UC1.K16 UC1.T9 UC1.U8 UC1.V8 UC1.W9 UC2.5 UC3.5 UC6.14
+3.3V_RUN_AIN: C213.1 C214.1 C215.1 L35.2 U27.9 U27.27
+3.3V_RUN_AUDIO: C118.1 C119.1 C120.1 C405.1 L37.2 PJP807.2 U17.3 U17.9
+3.3V_RUN_AUDIOP: C145.1 PJP807.1 U18.13 U18.14
+3.3V_RUN_CARD: C227.1 C239.1 C240.1 JSD1.4 U27.22
+3.3V_RUN_FFS: C101.1 C102.1 PJP2.2 U15.1 U15.7 U15.8 U15.14
+3.3V_RUN_TPM: C200.1 C201.1 C202.1 C203.1 C204.1 C384.1 PJP5.2 U25.5 U25.10 U25.19 U25.24
+3.3V_RUN_VDDA: C13.1 C14.1 C15.1 C16.1 L2.1 U6.C10 U6.H5 U6.H12 U6.K6 U6.K7
+3.3V_RUN_VDDIO: C26.1 C27.1 C28.1 C29.1 L5.2 U6.C3 U6.C4 U6.C11 U6.C12 U6.J4 U6.K3 U6.K4 U6.K11 U6.K12
+3.3V_SUS: C399.1 C633.1 C3002.1 C3003.1 JEXP1.19 JEXP1.21 JEXP1.23 R3000.1 RP15.5 RP15.6 U45.8 U45.9
+3.3V_TP: C374.1 JTP1.4 PJP8.2 R404.1 R405.1
+3.3V_USBHUB: C3023.1 C3024.1 C3025.1 C3026.1 C3027.1 C3028.1 C3029.1 C3030.2 PJP12.2 QC4.2 QC4.5 R2691.2 R2692.2 R2693.2 R2700.2 R2701.2 U90.5 U90.10 U90.15 U90.23 U90.29 U90.36
+3.3V_VTR: C346.1 C352.1 R336.2 U38.A22
+3.3V_VTR_ADC: C347.1 C353.1 R461.2 U38.A58
+3.3V_WLAN: C257.1 C258.1 C259.1 C260.2 C261.2 C262.1 JMINI1.2 JMINI1.39 JMINI1.41 JMINI1.52 PJP804.2 Q22.2 Q30.2 R227.2 R229.2 R233.2
+3.3V_WLANP: C422.1 PJP804.1 U51.13 U51.14
+5V_ALW: C73.1 C288.1 C289.1 C460.1 C1185.1 C1186.1 C1187.1 C1188.1 JIO1.2 JIO1.4 JIO1.5 JIO1.6 JIO1.7 JIO1.8 JIO1.9 JIO1.11 JLED1.1 JLED1.2 JPWR1.1 JUDB1.1 JUDB1.2 JUDB1.3 JUDB1.4 JUDB1.5 JUDB1.6 PC107.2 PC151.2 PC428.1 PC429.1 PD5.3 PJP52.2 PR11.1 PR102.1 PR150.1 PR327.1 PR435.1 PR536.2 PR617.2 PR711.2 PU1.5 PU100.12 PU150.18 PU404.8 Q16.3 R28.1 R109.1 R411.1 U18.4 U18.6 U18.7 U19.4 U22.5 U29.2 U29.5 U33.5 U34.5 U43.4 U45.4 U46.1 U46.2 U46.4 U51.4 U94.3 US1.2 US1.3
+5V_ALW2: PC69.1 PU51.13
+5V_ALWP: PC67.1 PC72.1 PJP52.1 PL53.2 PR52.2 PU51.14
+5V_HDD: C111.1 C112.1 JSATA1.14 JSATA1.15 JSATA1.16 PJP3.2 R125.1
+5V_HDMI_DDC: D65.1 R470.2 R471.2 R472.2
+5V_MOD: C432.1 C3004.1 C3005.1 PJP802.1 PJP803.1 U29.3
+5V_RUN: C7.1 C333.1 C376.1 C400.1 C454.1 C645.1 C1001.1 C2992.1 D1.1 D65.2 HDMIU1.1 JEXP1.11 JEXP1.13 JEXP1.15 JFAN1.1 JIO1.10 JKB1.6 PC303.1 PJP3.1 PJP802.2 PR314.1 PR630.2 PR710.2 PU301.2 Q137.3 R74.1 R472.1 R2605.2 RP4.1 RP4.2 RP4.3 RP4.4 U39.16 U46.13 U46.14
+5V_RUN_AUDIO: L21.2 PJP808.2 R130.1
+5V_RUN_AUDIOP: C149.1 PJP808.1 U18.8 U18.9
+5V_TSP: C455.1 JTS1.1 PJP13.1
+5V_TSP_Q: PJP13.2 Q137.1 Q138.1
+5V_USB_CHG_PWR: C290.1 C291.1 C809.1 JUSB1.1 US1.6 US1.7 US1.8
+DVDD_CORE: C121.1 U17.1
+P1.05V_PEX_VDD: PJP152.2 U19.6 U19.7
+V1.05S_APLLOPI: CC55.1 CC56.1 LC5.2 UC1.AA21 UC1.W21
+V1.05SP_B+: PC152.1 PC153.1 PC154.1 PC155.1 PJP150.1 PU150.15 PU150.16 PU150.17
+VCC_CORE: PC360.1 PC361.1 PC362.1 PC363.1 PC364.1 PC365.1 PC366.1 PC367.1 PC368.1 PC369.1 PC370.1 PC371.1 PC372.1 PC373.1 PC374.1 PC375.1 PC376.1 PC377.1 PC378.1 PC379.1 PC380.1 PC381.1 PC382.1 PC383.1 PC384.1 PC385.1 PC386.1 PC387.1 PC388.1 PC389.1 PL300.4 RC250.1 UC1.AB57 UC1.AD57 UC1.AG57 UC1.C24 UC1.C28 UC1.C32 UC1.C36 UC1.C40 UC1.C44 UC1.C48 UC1.C52 UC1.C56 UC1.E23 UC1.E25 UC1.E27 UC1.E29 UC1.E31 UC1.E33 UC1.E35 UC1.E37 UC1.E39 UC1.E41 UC1.E43 UC1.E45 UC1.E47 UC1.E49 UC1.E51 UC1.E53 UC1.E55 UC1.E57 UC1.F24 UC1.F28 UC1.F32 UC1.F36 UC1.F40 UC1.F44 UC1.F48 UC1.F52 UC1.F56 UC1.F59 UC1.G23 UC1.G25 UC1.G27 UC1.G29 UC1.G31 UC1.G33 UC1.G35 UC1.G37 UC1.G39 UC1.G41 UC1.G43 UC1.G45 UC1.G47 UC1.G49 UC1.G51 UC1.G53 UC1.G55 UC1.G57 UC1.H23 UC1.J23 UC1.K23 UC1.K57 UC1.L22 UC1.M23 UC1.M57 UC1.P57 UC1.U57 UC1.W57
+VCC_PWR_SRC: PC302.2 PC311.1 PC312.1 PC313.1 PC314.1 PC315.1 PC316.1 PJP300.2 PR311.1 PU301.5
+VCCIO_OUT: RC242.1 UC1.A59
+VCCIOA_OUT: RC134.1 UC1.E20
+VDDA_AVDD1: C115.1 C117.1 L21.1 U17.27
+VDDA_AVDD2: C116.1 C150.1 JIO1.66 L37.1 R158.1 R159.1 U17.38
+VDDA_PVDD: C122.1 C123.1 C128.1 C129.1 R130.2 U17.39 U17.45
+VDDRP: PC709.1 PJP701.1 PJP702.1 PL700.2 PR707.2
+VDDRP_B+: PC700.1 PC701.1 PC702.1 PC703.1 PJP700.1 PQ700.5
