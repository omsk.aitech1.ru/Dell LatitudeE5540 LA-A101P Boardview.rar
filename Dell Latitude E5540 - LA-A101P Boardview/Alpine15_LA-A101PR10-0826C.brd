# Allegro board Alpine15_LA-A101PR10-0826C.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DPB_DOCK_HPD: length 35.5
  TOP w0.102: v3(182.01,164.65) 181.93,164.58 181.93,164.2 181.63,163.89 181.63,163.53 U6.K14 ; C311.1 R271.1 v1(176.67,182.92) 176.67,182.38 v2(176.39,182.1)
  IN1 w0.097: v3(182.01,164.65) 182.01,164.2 181.63,163.82 180.64,163.82 180.14,164.31 180.14,169.04 179.85,169.33 179.85,170.22 180.28,170.66 180.28,172.53 181.07,173.32 181.07,175.31 183.42,177.65 183.42,180.95 183,181.37 180.64,181.37 180.23,181.77 176.72,181.77 v2(176.39,182.1)
  BOTTOM w0.102: v2(176.39,182.1) 176.5,182.21 176.5,184.55 JDOCK1.40
DPB_DOCK_LANE_N0: length 12
  TOP w0.089: v2(169.49,182.88) 169.42,182.8 169.42,182.65 169.88,182.19 169.88,179.68 168.91,178.71 168.91,177.25 168.86,177.2 v1(168.86,174.94) 168.86,173.65 R261.1
  BOTTOM w0.089: v2(169.49,182.88) 169.4,182.97 169.4,183.6 169.45,183.65 JDOCK1.12
DPB_DOCK_LANE_N1: length 11.5
  TOP w0.089: R256.1 170.85,173.63 v1(170.85,176.55) 170.85,179.4 170.7,179.55 170.7,181.95 170.88,182.13 170.88,182.95 v2(170.96,183.03)
  BOTTOM w0.089: v2(170.96,183.03) 170.9,183.09 170.9,183.65 170.95,183.7 JDOCK1.18
DPB_DOCK_LANE_N2: length 12.6
  TOP w0.089: v2(172.55,183.1) 172.43,182.98 172.43,182.59 172.79,182.23 173.7,181.32 v1(173.7,180.11) 173.7,178.94 172.47,177.71 172.47,174.98 172.74,174.71 172.74,173.68 R264.1
  BOTTOM w0.089: v2(172.55,183.1) 172.44,183.21 172.44,183.66 172.45,183.68 JDOCK1.24
DPB_DOCK_LANE_N3: length 15.3
  TOP w0.089: v2(174.16,185.99) 173.92,185.76 v1(173.92,184.24) 173.92,182.36 174.69,181.6 174.69,178.57 173.86,177.74 173.86,175.03 174.74,174.15 174.74,173.57 R267.1
  BOTTOM w0.089: v2(174.16,185.99) 173.95,185.78 JDOCK1.30
DPB_DOCK_LANE_P0: length 12.1
  TOP w0.089: v2(168.91,182.88) 169.02,182.76 169.02,182.49 169.48,182.03 169.48,179.84 168.52,178.88 168.52,177.42 168.47,177.37 168.47,173.62 R260.1
  BOTTOM w0.089: JDOCK1.10 168.95,183.65 169,183.6 169,182.97 v2(168.91,182.88)
DPB_DOCK_LANE_P1: length 11.6
  TOP w0.089: v2(170.37,183.06) 170.48,182.95 170.48,182.29 170.31,182.11 170.31,179.39 170.46,179.23 170.46,173.68 R254.1
  BOTTOM w0.089: v2(170.37,183.06) 170.5,183.19 170.5,183.6 170.45,183.65 JDOCK1.16
DPB_DOCK_LANE_P2: length 12.5
  TOP w0.089: R262.1 172.34,173.6 172.34,174.55 172.07,174.82 172.07,177.87 173.31,179.11 173.31,181.15 172.04,182.42 172.04,183 v2(171.97,183.07)
  BOTTOM w0.089: v2(171.97,183.07) 172.02,183.12 172.02,183.58 171.95,183.65 JDOCK1.22
DPB_DOCK_LANE_P3: length 15.3
  TOP w0.089: v2(173.35,185.99) 173.53,185.81 173.53,182.2 174.3,181.43 174.3,178.73 173.47,177.9 173.47,174.87 174.35,173.99 174.35,173.67 R258.1
  BOTTOM w0.089: v2(173.35,185.99) 173.45,185.89 JDOCK1.28
DPB_HPD: length 130.6
  TOP w0.076: v2(164.76,87.74) 164.94,87.74 165.37,88.18 169.56,88.18 170.45,89.06 170.45,89.24
  TOP w0.102: RC156.2 170.45,93.05 v1(170.45,90.46) 170.45,89.24 ; v3(183.23,153.58) 182.41,154.39 181.6,154.39 181.05,154.94 U6.J1
  BOTTOM w0.076: 165.27,89.2 164.79,88.71 164.69,88.71 164.48,88.5 164.48,88.02 v2(164.76,87.74) 163.92,86.91 163.92,86.12 164.05,85.99 164.05,85 163.88,84.83 163.88,84.3 163.6,84.02 UC1.C8
  BOTTOM w0.102: v3(183.23,153.58) 180.84,151.19 177.64,151.19 175.81,149.36 169.59,149.36 168.73,150.22 164.06,150.22 161.1,147.26 161.1,145.16 160.3,144.36 160.3,141.58 146.27,127.55 146.27,125.73 146.27,125.73 146.27,125.55 146.27,125.55 146.27,120.21 146.7,119.78 146.7,112.71 146.83,112.58 147.03,112.38 147.03,109.2 145.23,107.4 145.23,103.71 146.45,102.49 151.4,102.49 151.68,102.21 156.93,102.21 159.45,99.69 163.01,96.13 165.65,96.13 166.21,96.68 167.09,96.68 167.62,96.16 167.62,93.81 166.28,92.47 166.28,90.21 165.27,89.2
DPB_LANE_N0: length 13.8
  TOP w0.089: U6.E14 178.24,163.89 178.12,164 177.87,164.25 177.61,164.52 177.28,164.52 176.18,164.51 175.91,164.78 173.85,164.78 v1(171.29,167.34) 169.15,169.48 168.75,169.48 168.69,169.54 168.69,170.29 168.81,170.42 169.06,170.42 169.14,170.34 C296.1
DPB_LANE_N0_C: length 1.6
  TOP w0.089: R261.2 168.88,172.2 168.88,171.35 C296.2
DPB_LANE_N1: length 12.9
  TOP w0.089: C303.1 171.11,170.27 170.93,170.45 170.78,170.45 170.62,170.28 170.62,169.52 v1(171.22,168.92) 172.93,167.21 173.23,166.9 174.32,165.81 177.56,165.81 178.83,164.54 178.83,163.45 U6.F14
DPB_LANE_N1_C: length 1.6
  TOP w0.089: R256.2 170.83,172.19 170.83,171.36 C303.2
DPB_LANE_N2: length 12.1
  TOP w0.089: U6.G14 179.54,164.98 177.71,166.8 v1(175.54,166.8) 175.14,166.8 174.06,167.88 173.1,168.84 172.58,169.35 172.58,170.39 172.69,170.5 172.91,170.5 173.04,170.37 C307.1
DPB_LANE_N2_C: length 1.5
  TOP w0.089: C307.2 172.79,171.4 172.79,172.21 R264.2
DPB_LANE_N3: length 11.1
  TOP w0.089: C309.1 174.94,170.32 174.82,170.45 174.59,170.45 174.49,170.34 174.49,169.48 175.02,168.95 176.18,167.79 178.03,167.79 v1(179.21,166.62) 180.27,165.55 180.27,164.01 180.19,163.93 U6.H14
DPB_LANE_N3_C: length 1.5
  TOP w0.089: C309.2 174.69,171.4 174.69,172.21 R267.2
DPB_LANE_P0: length 13.9
  TOP w0.076: U6.E13 178.24,163.02 177.85,163.4 177.85,163.71 177.73,163.84
  TOP w0.089: 177.73,163.84 177.59,163.98 177.45,164.12 176.01,164.12 175.75,164.39 173.69,164.39 171.02,167.06 v1(169.47,168.61) 168.99,169.09 168.58,169.09 168.29,169.38 168.29,170.11 C294.1
DPB_LANE_P0_C: length 1.6
  TOP w0.089: R260.2 168.48,172.2 168.48,171.35 C294.2
DPB_LANE_P1: length 12.9
  TOP w0.089: U6.F13 178.89,162.99 178.55,163.33 178.55,163.93 178.43,164.04 178.43,164.38 177.39,165.42 174.16,165.42 v1(172.95,166.62) 172.53,167.04 172.53,167.04 170.22,169.35 170.22,170.1 C298.1
DPB_LANE_P1_C: length 1.6
  TOP w0.089: C298.2 170.44,171.37 170.44,172.18 R254.2
DPB_LANE_P2: length 12.1
  TOP w0.089: U6.G13 179.18,163.1 179.18,163.99 179.14,164.03 179.14,164.81 177.55,166.41 174.97,166.41 v1(173.02,168.36) 172.19,169.19 172.19,170.17 C305.1
DPB_LANE_P2_C: length 1.5
  TOP w0.089: R262.2 172.39,172.19 172.39,171.42 C305.2
DPB_LANE_P3: length 11.1
  TOP w0.089: C308.1 174.09,170.2 174.09,169.32 176.01,167.4 v1(177.12,167.4) 177.87,167.4 178.93,166.34 179.87,165.39 179.87,163.06 U6.H13
DPB_LANE_P3_C: length 1.5
  TOP w0.089: R258.2 174.3,172.21 174.3,171.4 C308.2
DPC_CA_DET: length 36.7
  TOP w0.102: v3(165.55,159.21) 165.05,158.72 U13.1 ; Q135.2 165.95,167.45 v3(166.89,167.45) 167.3,167.85 168.49,167.85 v1(170.67,165.68) 172.96,163.39 U6.A14 ; v3(166.89,159.3) 167,159.19 U13.4
  IN1 w0.097: v3(165.55,159.21) 165.32,159.44 165.32,165.87 v3(166.89,167.45)
  BOTTOM w0.102: v3(166.89,167.45) 165.78,168.57 165.78,172.27 R121.2 165.12,172.93 165.12,173.8 166.11,174.79 166.87,174.79 167.95,175.87 JDOCK1.5 ; v3(165.55,159.21) 166.81,159.21 v3(166.89,159.3)
DPC_CA_DET#: length 8.2
  TOP w0.089: R164.1 168.88,166.53 Q135.1 ; U13.10 167.65,164.88 167.96,165.19 v1(167.96,165.52) 167.96,165.87 167.59,166.24 167.59,166.24 Q135.1 ; Q135.1 167.2,166.53 166.89,166.23 166.67,166.23 166.34,165.9 166.34,165.67 165.7,165.04 U13.13
DPC_DOCK_AUX: length 30.5
  TOP w0.089: U13.11 167,163.14 167.29,162.85 167.5,162.85 167.68,162.67 167.68,161.97 167.55,161.85 167.11,161.85 166.75,161.48 166.75,161.17 v3(166.5,160.93) 166.75,160.69 166.75,159.98 166.66,159.9 166.23,159.9 166.16,159.82 166.16,159.02 166.35,158.82 U13.3
  IN1 w0.089: v2(174.91,178.06) 175.05,177.92 175.05,177.68 173.45,176.08 173.45,175.23 167.58,169.36 167.58,167.06 167.35,166.83 167.35,165.74 165.93,164.32 165.93,161.95 166.67,161.22 166.67,161.09 v3(166.5,160.93)
  BOTTOM w0.089: v2(174.91,178.06) 175,177.97 175,177.74 174.95,177.69 JDOCK1.33
DPC_DOCK_AUX#: length 30.5
  TOP w0.089: U13.8 168.95,162.05 168.36,161.45 167.28,161.45 167.14,161.32 v3(167.14,160.92) 167.14,159.94 168.3,158.77 U13.6
  IN1 w0.089: v2(175.49,178.06) 175.38,177.95 175.38,177.55 173.78,175.95 173.78,175.09 167.91,169.23 167.91,166.93 167.68,166.7 167.68,165.6 166.26,164.18 166.26,162.09 167,161.35 167,161.06 v3(167.14,160.92)
  BOTTOM w0.089: v2(175.49,178.06) 175.4,177.97 175.4,177.74 175.45,177.69 JDOCK1.35
DPC_DOCK_HPD: length 28.4
  TOP w0.102: v3(173.88,159.32) v1(173.88,158.48) 174.31,158.05 175.5,158.05 U6.A6
  IN1 w0.097: v3(179.72,172.53) 179.72,172.3 177.73,170.31 177.73,170 175.96,168.24 175.96,166.86 173.35,164.25 173.35,160.36 173.88,159.83 v3(173.88,159.32)
  BOTTOM w0.102: JDOCK1.39 176.45,175.55 176.5,175.51 176.5,173.9 176.04,173.44 C310.1 R268.1 175.48,172.99 176.27,172.99 176.32,173.04 179.21,173.04 v3(179.72,172.53)
DPC_DOCK_LANE_N0: length 4.5
  BOTTOM w0.089: R252.2 167.38,173.64 167.38,173.89 168.17,174.68 168.76,174.68 169.4,175.31 169.4,175.65 169.45,175.71 JDOCK1.11
DPC_DOCK_LANE_N1: length 4
  BOTTOM w0.089: R255.2 169.36,173.62 169.36,173.84 170.88,175.36 170.88,175.65 170.95,175.72 JDOCK1.17
DPC_DOCK_LANE_N2: length 3.8
  BOTTOM w0.089: R263.2 171.26,173.65 171.26,173.86 172.41,175.01 172.41,175.47 172.45,175.52 JDOCK1.23
DPC_DOCK_LANE_N3: length 3.7
  BOTTOM w0.089: JDOCK1.29 173.95,175.52 173.9,175.47 173.9,174.98 173.19,174.28 173.19,173.65 R266.2
DPC_DOCK_LANE_P0: length 4.5
  BOTTOM w0.089: R259.2 166.98,173.63 166.98,174.05 v1(167.3,174.37) 168,175.07 168.6,175.07 169,175.47 169,175.65 168.95,175.71 JDOCK1.9
DPC_DOCK_LANE_P1: length 4
  BOTTOM w0.089: JDOCK1.15 170.45,175.78 170.49,175.74 170.49,175.53 v1(169.32,174.36) 168.96,174 168.96,173.68 R253.2
DPC_DOCK_LANE_P2: length 3.8
  BOTTOM w0.089: R257.2 170.87,173.62 170.87,174.03 v1(171.22,174.38) 172.01,175.17 172.01,175.46 171.95,175.52 JDOCK1.21
DPC_DOCK_LANE_P3: length 3.6
  BOTTOM w0.089: JDOCK1.27 173.45,175.52 173.5,175.47 173.5,175.14 172.8,174.44 v1(172.8,174.29) 172.8,173.62 R265.2
DPC_LANE_N0: length 20.5
  TOP w0.089: U6.A7 175.62,158.86 175.4,158.86 175.31,158.78 v5(175.31,158.52)
  BOTTOM w0.089: C295.2 167.64,170.57 167.55,170.65 167.33,170.65 167.17,170.5 167.17,168.61 168.7,167.09 v1(168.7,165.75) 168.7,163.34 169.56,162.48 169.56,159.88 171.92,157.52 174.16,157.52 174.69,158.05 175.05,158.05 175.31,158.32 v5(175.31,158.52)
DPC_LANE_N0_C: length 1.6
  BOTTOM w0.089: R252.1 167.39,172.21 167.39,171.34 C295.1
DPC_LANE_N1: length 18.1
  TOP w0.089: U6.A8 175.64,159.4 175.57,159.33 175.57,159.28 175.45,159.17 175.34,159.17 v5(175.19,159.32)
  BOTTOM w0.089: v5(175.19,159.32) 175.17,159.31 174.99,159.31 174.96,159.28 174.43,159.28 173.7,158.56 172.41,158.56 170.7,160.26 v1(170.7,167.6) 170.7,167.91 169.12,169.49 169.12,170.54 169.21,170.62 169.51,170.62 169.61,170.53 C299.2
DPC_LANE_N1_C: length 1.6
  BOTTOM w0.089: R255.1 169.33,172.19 169.33,171.36 C299.1
DPC_LANE_N2: length 14.4
  TOP w0.089: U6.A9 175.64,160.09 175.48,159.93 175.29,159.93 v5(175.07,160.14)
  BOTTOM w0.089: C306.2 171.54,170.6 171.41,170.73 171.16,170.73 171.07,170.64 171.07,169.65 v1(171.47,169.25) 171.9,168.82 171.9,164.73 173.8,162.83 173.8,160.51 174.2,160.12 175.05,160.12 v5(175.07,160.14)
DPC_LANE_N2_C: length 1.5
  BOTTOM w0.089: R263.1 171.28,172.2 171.28,171.41 C306.1
DPC_LANE_N3: length 12.2
  TOP w0.089: v5(175.97,161.12) 175.64,160.79 U6.A10
  BOTTOM w0.089: v5(175.97,161.12) 175.84,161 175.15,161 174.91,161.24 174.91,163.6 172.89,165.62 v1(172.89,169.18) 172.89,169.51 173,169.62 173,170.33 173.12,170.45 173.26,170.45 C301.2
DPC_LANE_N3_C: length 1.5
  BOTTOM w0.089: C301.1 173.21,171.41 173.21,172.2 R266.1
DPC_LANE_P0: length 20.4
  TOP w0.089: U6.B7 v5(175.96,158.52)
  BOTTOM w0.089: v5(175.96,158.52) 175.96,158.41 175.21,157.66 174.86,157.66 174.32,157.12 171.76,157.12 169.17,159.72 169.17,162.32 168.3,163.18 168.3,166.93 v1(167.68,167.55) 167.24,168 166.78,168.45 166.78,170.12 C302.2
DPC_LANE_P0_C: length 1.6
  BOTTOM w0.089: C302.1 167,171.36 167,172.19 R259.1
DPC_LANE_P1: length 18.1
  TOP w0.089: U6.B8 v5(175.96,159.17)
  BOTTOM w0.089: v5(175.96,159.17) 175.71,158.91 175.15,158.91 175.13,158.89 174.59,158.89 173.87,158.16 172.24,158.16 170.31,160.1 170.31,167.74 v1(169.1,168.95) 168.73,169.32 168.73,170.1 C297.2
DPC_LANE_P1_C: length 1.6
  BOTTOM w0.089: R253.1 168.94,172.18 168.94,171.37 C297.1
DPC_LANE_P2: length 14.4
  TOP w0.089: U6.B9 v5(175.96,159.82)
  BOTTOM w0.089: v5(175.96,159.82) 175.87,159.73 174.03,159.73 173.41,160.35 173.41,162.66 171.5,164.57 v1(171.5,165.95) 171.5,168.66 171.19,168.97 170.68,169.48 170.68,170.18 C304.2
DPC_LANE_P2_C: length 1.5
  BOTTOM w0.089: C304.1 170.88,171.41 170.88,172.2 R257.1
DPC_LANE_P3: length 12.2
  TOP w0.089: U6.B10 176.29,160.79 v5(175.97,160.47)
  BOTTOM w0.089: C300.2 172.61,170.18 172.61,169.79 172.49,169.67 v1(172.49,167.4) 172.49,165.46 174.51,163.44 174.51,161.07 174.99,160.6 175.83,160.6 v5(175.97,160.47)
DPC_LANE_P3_C: length 1.5
  BOTTOM w0.089: R265.1 172.81,172.2 172.81,171.41 C300.1
DQMA0: length 27.6
  IN3 w0.114: v5(55.76,108.54) 55.76,109.34 54.34,110.77 54.34,111.42 53.55,112.21 49.77,112.21 45.27,107.71 42.24,107.71 42.11,107.83 42.11,108.41 41.99,108.54 41.75,108.54 41.63,108.41 41.63,107.83 41.51,107.71 41.26,107.71 41.14,107.83 41.14,108.41 41.02,108.54 40.77,108.54 40.65,108.41 40.65,107.83 40.53,107.71 40.29,107.71 40.16,107.83 40.16,108.41 40.04,108.54 38.06,108.54 37.73,108.21 v2(37.18,108.21)
  BOTTOM w0.102: UV4.E7 36.72,108.67 v2(37.18,108.21) ; UV1.D19 56.11,108.19 v5(55.76,108.54)
DQMA1: length 37.8
  TOP w0.102: v2(37.15,105.89) 36.75,105.5 UV5.E7
  IN1 w0.114: v2(37.15,105.89) 37.92,105.89 39.7,107.67 39.7,108.81 41.09,110.2 41.09,110.36 40.19,111.26 40.19,111.44 40.33,111.58 40.51,111.58 41.41,110.69 41.57,110.69 41.73,110.85 41.73,111.01 41.46,111.29 41.46,111.47 41.6,111.61 41.78,111.61 42.06,111.33 42.22,111.33 42.43,111.54 42.64,111.54 42.76,111.66 42.76,111.84 42.88,111.96 43.09,111.96 43.22,111.84 43.22,111.66 43.33,111.54 43.56,111.54 43.67,111.66 43.67,112.47 43.8,112.6 44.03,112.6 44.15,112.47 44.15,111.74 44.28,111.61 44.49,111.61 44.61,111.74 44.61,112.47 44.74,112.6 44.94,112.6 45.07,112.47 45.07,111.74 45.2,111.61 45.4,111.61 45.53,111.74 45.53,112.47 45.65,112.6 54.75,112.6 57.68,109.67 57.68,109.29 58.03,108.94 58.32,108.94 58.56,108.7 58.56,108.41 59.23,107.73 v5(59.82,107.73)
  BOTTOM w0.122: v5(59.82,107.73) UV1.D14
DQMA2: length 34.8
  TOP w0.102: 58.66,111.12 59.37,110.4 59.37,110.01 59.11,109.74 58.55,109.74 v5(58.16,109.35)
  TOP w0.122: UV5.D3 37.74,108.48 37.74,107.37 37.93,107.18 39.58,107.18 39.7,107.3 40,107.6 40.9,108.49 42.36,108.49 44.01,110.14 v1(44.01,111.52) 44.01,112.06 47.02,115.08 56.14,115.08 56.63,114.58 56.8,114.58 57.09,114.87 57.26,114.87 57.43,114.7 57.43,114.53 57.15,114.24 57.15,114.07 57.32,113.89 57.49,113.89 57.78,114.18 57.95,114.18 58.12,114.01 58.12,113.84 57.84,113.55 57.84,113.38 58.66,112.56 58.66,111.12
  BOTTOM w0.122: v5(58.16,109.35) UV1.C17
DQMA3: length 22.7
  BOTTOM w0.122: UV1.C22 53.2,109.37 53.2,109.9 53,110.1 53,111.22 51.26,112.96 46.31,112.96 v1(44.45,111.09) 40.62,107.27 37.82,107.27 37.54,106.98 37.54,105.52 UV4.D3
DQMA4: length 26.9
  IN1 w0.114: v2(37.2,92.46) 37.84,92.46 38.33,92.94 41.12,92.94 41.24,92.83 41.24,92.18 41.36,92.05 41.57,92.05 41.69,92.18 41.69,92.83 41.81,92.94 42.04,92.94 42.15,92.83 42.15,92.18 42.28,92.05 42.48,92.05 42.61,92.18 42.61,92.83 42.72,92.94 42.95,92.94 43.06,92.83 43.06,92.18 43.19,92.05 43.39,92.05 43.52,92.18 43.52,92.74 43.65,92.87 44.29,92.87 44.45,93.03 48.33,96.91 48.33,97.58 49.07,98.32 49.23,98.32 49.6,97.96 49.76,97.96 49.92,98.12 49.92,98.28 49.56,98.64 49.56,98.8 49.72,98.97 49.88,98.97 50.24,98.6 50.4,98.6 50.57,98.77 50.57,98.93 50.2,99.29 50.2,99.45 50.59,99.84 UV1.P24 v5(52.33,99.44)
  BOTTOM w0.102: v2(37.2,92.46) 36.73,92.92 UV6.E7
  BOTTOM w0.122: v5(52.33,99.44) UV1.P24
DQMA5: length 19.7
  TOP w0.122: v5(51.53,96.12) 51.53,96.11 51.08,95.65 47,95.65 44.5,93.16 44.5,92.99 v1(44.63,92.86) 44.78,92.71 44.78,92.53 44.62,92.36 44.44,92.36 44.16,92.64 43.99,92.64 43.81,92.47 43.81,92.3 44.09,92.02 44.09,91.84 43.93,91.67 43.75,91.67 43.57,91.85 43.01,91.85 42.41,91.25 38.32,91.25 37.86,91.71 37.86,92.63 UV7.D3
  BOTTOM w0.122: v5(51.53,96.12) 51.93,95.72 UV1.W24
DQMA6: length 19.8
  TOP w0.102: v2(37.16,90.14) 36.76,89.75 UV7.E7
  IN3 w0.114: v2(50.73,93.65) 50.3,93.22 50.3,92.57 50.18,92.45 49.34,92.45 49.02,92.77 44.78,92.77 44.23,92.23 44.03,92.23 43.47,92.79 43.29,92.79 43.07,92.56 43.07,92.38 43.47,91.98 43.47,91.8 43.3,91.64 43.12,91.64 42.77,91.98 42.6,91.98 42.43,91.81 42.43,91.64 42.79,91.27 42.79,91.09 42.63,90.93 42.45,90.93 42.08,91.29 41.91,91.29 41.39,90.77 37.78,90.77 v2(37.16,90.14)
  BOTTOM w0.122: UV1.AA25 51.12,94.04 v2(50.73,93.65)
DQMA7: length 19
  BOTTOM w0.122: UV6.D3 37.67,89.88 37.67,90.23 38.64,91.2 41.16,91.2 41.27,91.09 v1(42.81,91.09) 44.6,91.09 46.29,92.79 46.29,95.81 47.65,97.17 48.21,97.17 48.44,96.94 50.71,96.94 UV1.U25
DSCHRG_MOSFET_GC: length 2.4
  TOP w0.254: PR559.1 125.67,155.69 125.81,155.55 v1(126.56,155.55) 127.21,156.2 PU701.29
DSWODVREN: length 31
  TOP w0.102: RC78.2 RC73.1 188.53,57.62 v3(188.53,57.34)
  BOTTOM w0.076: 170.78,58.38 165.88,58.38 164.4,59.85 164.4,61.02 164.35,61.07 164.35,61.39 164.32,61.42 164.32,62.28 UC1.AW7
  BOTTOM w0.102: 170.78,58.38 v1(171.47,58.38) 171.98,57.87 172.38,57.87 173.07,57.19 179.37,57.19 180.66,55.89 187.09,55.89 v3(188.53,57.34)
DYN_TUR_CURRNT_SET#: length 79.7
  TOP w0.102: v3(169.76,143.14) 169.69,143.06 v1(165.52,143.06) 165.42,142.96 163.51,142.96 162.34,141.79 161.43,141.79 160.4,140.77 159.2,140.77 146.89,128.45 135.37,128.45 132.77,131.05 122.5,131.05 121.81,131.75 121.38,131.75 121.11,132.02 116.58,132.02 115.86,132.73 115.86,134.43 PQ410.2 ; v3(169.56,134.02) 168.66,133.12 168.66,132.31 R363.2 169.48,131.48 169.48,129.81 168.94,129.26 U38.A35
  IN1 w0.102: v3(169.76,143.14) 169.63,143.01 169.63,136.19 169.94,135.88 169.94,134.4 v3(169.56,134.02)
EC5048_TX: length 58.4
  TOP w0.102: R406.2 R397.2 224.88,101.41 v1(224.88,104.32) 224.88,112.53 223.97,113.45 208.7,113.45 206.97,115.18 v3(203.21,115.18) ; U37.B2 195.59,127.95 v2(196.02,127.52)
  IN2 w0.102: v2(196.02,127.52) 196.02,127.84 197.78,129.6 200.42,129.6 200.73,129.3 202.02,129.3 203.6,127.72 203.6,115.56 v3(203.21,115.18)
EC_32KHZ_ECE5048: length 47.5
  TOP w0.102: v3(154.3,125.08) 154.63,125.41 v1(155.74,125.41) 155.95,125.41 156.3,125.77 R379.1 ; U37.B35 188.08,118.81 188,118.73 186.93,118.73 v2(186.91,118.71)
  IN1 w0.097: v3(154.3,125.08) 154.3,124.32 154.2,124.22 154.2,123.66 154.3,123.56 154.3,122.01 154.3,122.01 154.3,121.46 154.3,121.46 154.3,120.15 155.16,119.29 155.43,119.29 156.81,117.91 156.81,116.25 158.34,114.72 164.76,114.72 165.27,114.21 168.24,114.21 168.49,114.46 175.2,114.46 177.33,116.6 178.2,116.6 180.73,119.13 186.5,119.13 v2(186.91,118.71)
EC_32KHZ_ECE5048_R: length 11
  TOP w0.102: R379.2 158.23,125.77 v3(158.51,125.49) ; U38.B62 163.31,122.64 163.49,122.82 163.49,123.72 163.51,123.73 163.51,124.76 v2(163.03,125.23)
  IN3 w0.102: v2(163.03,125.23) 162.65,125.61 161.81,125.61 161.59,125.39 158.61,125.39 v3(158.51,125.49)
  BOTTOM w0.102: v3(158.51,125.49) v1(158.51,126.11)
EC_WAKE#: length 149.6
  TOP w0.102: v3(199.66,62.06) 199.3,61.71 199.3,60.13 198.68,59.51 198.68,56.49 194.15,51.95 178.86,51.95 176.22,54.6 176.22,56.93 RC206.1 ; v3(187.55,112.02) 185.03,112.02 182.97,114.08 v1(177.22,114.08) 175.99,114.08 175.83,114.24 175.05,114.24 RC211.2 ; v2(170.12,122.21) 170.18,122.14 U38.B23
  TOP w0.109: v2(165.67,66.15) 166.3,65.51 167.12,65.51 168.24,64.4 168.24,63.26 169.54,61.95 172.11,61.95 RC206.1
  IN2 w0.102: v3(199.66,62.06) 199.43,61.84 198.5,61.84 198.26,62.07 198.26,63.51 199.3,64.55 199.3,67.83 200.02,68.54 200.02,73.47 203.32,76.78 203.32,79.92 200.64,82.6 200.64,83.21 199.15,84.7 199.15,85.22 198.48,85.89 198.48,88.82 198.19,89.11 198.19,95.38 194.68,98.89 194.68,101.76 188.56,107.89 188.56,109.16 187.8,109.92 187.8,111.77 v3(187.55,112.02) 187.55,114.39 182.74,119.2 182.74,121.29 182.19,121.84 177.84,121.84 177.73,121.73 175.43,121.73 174.95,122.21 v2(170.12,122.21)
  BOTTOM w0.089: v2(165.67,66.15) 165.34,66.48 UC1.AN5
EDID_CLK: length 42.4
  TOP w0.102: v4(109.44,141.5) 109.59,141.65 109.59,142.23 108.72,143.1 102.82,143.1 R2600.2 ; R2582.1 113.17,122.56 v3(113.2,122.59) 113.45,122.85 113.78,122.85 114.07,122.56 U52.46
  IN1 w0.097: v3(109.85,121.78) 110.35,121.27 110.94,121.27 111.06,121.14 111.06,120.82 111.33,120.56 112.72,120.56 113.12,120.97 113.12,121.96 112.51,122.57 112.51,122.74 112.61,122.85 112.94,122.85 v3(113.2,122.59)
  IN3 w0.102: v4(109.44,141.5) 109.64,141.29 109.64,140.8 109.35,140.5 108.42,140.5 107.74,139.81 107.74,138.85 108.35,138.24 109.17,138.24 110.15,137.25 110.15,126.19 110.07,126.12 110.07,124.24 111.06,123.25 111.06,122.34 110.89,122.16 110.23,122.16 v3(109.85,121.78)
EDID_CLK_LCD: length 2.8
  TOP w0.102: R2600.1 101.26,143.12 101.01,143.12 100.86,143.27 100.35,143.27 100.14,143.06 99.93,143.06 99.81,142.95 JLVDS1.36
EDID_DATA: length 42
  TOP w0.102: U52.45 114.62,122.96 114.48,122.82 114.13,122.82 113.88,123.07 113.38,123.07 v3(113.2,123.25) 113,123.45 R2584.1 ; R2599.2 102.8,143.33 v3(106.42,143.33) 108.81,143.33 109.82,142.32 109.82,141.75 v3(110.07,141.5)
  IN1 w0.097: v3(112.28,121.68) 111.98,121.68 111.58,121.27 111.42,121.27 111.29,121.14 111.29,120.92 111.42,120.78 112.62,120.78 112.9,121.06 112.9,121.86 112.28,122.48 112.28,122.84 112.52,123.07 113.02,123.07 v3(113.2,123.25)
  IN3 w0.102: v3(110.07,141.5) 109.87,141.29 109.87,140.7 109.44,140.27 108.52,140.27 107.97,139.72 107.97,138.95 108.45,138.47 109.26,138.47 110.38,137.35 110.38,126.1 110.3,126.02 110.3,124.34 111.29,123.35 111.29,122.41 111.5,122.21 111.75,122.21 v3(112.28,121.68)
EDID_DATA_LCD: length 2.8
  TOP w0.102: JLVDS1.35 99.74,143.45 99.9,143.29 100.05,143.29 100.25,143.5 v3(100.5,143.5) 100.96,143.5 101.11,143.34 101.26,143.34 R2599.1
EDP_BIA_PWM: length 16.1
  TOP w0.076: v2(163.85,87.74) 164.35,88.25 164.35,88.56 164.61,88.81 168.88,88.81 v1(169.09,89.03) 169.31,89.24
  TOP w0.102: 169.31,89.24 169.5,89.43 169.5,91.39 168.04,92.85 RC33.2 R2577.2
  BOTTOM w0.076: v2(163.85,87.74) 163.55,87.45 163.55,85.9 163.67,85.79 163.67,85.15 163.31,84.8 163.31,83.97 UC1.B8
EDP_BIA_PWM_R: length 75.8
  TOP w0.102: v3(149.53,127.49) v1(137.25,127.49) 133.14,127.49 132.78,127.14 127.6,127.14 125.72,125.26 122.24,125.26 121.94,124.96 U52.21 ; RC33.1 168.04,95 167.85,95.19 167.85,95.59 168.06,95.8 168.06,97.5 167.4,98.16 v3(167.4,99.25)
  BOTTOM w0.102: v3(149.53,127.49) 149.53,125.2 150.26,124.47 150.26,119.29 151.07,118.48 151.07,116.78 151.3,116.55 151.3,115.7 151.22,115.63 151.22,110.95 151.22,110.55 151.22,108.65 150.89,108.32 150.89,106.98 153.23,104.63 157.17,104.63 162.23,99.58 163.8,99.58 164.13,99.25 v3(167.4,99.25)
EDP_COMP: length 3
  TOP w0.508: v2(156.53,82.28) v1(155.9,82.28) 155.54,82.28 155.24,81.98 RC134.2
  BOTTOM w0.254: v2(156.53,82.28) 157.02,82.77 UC1.D20
EDP_CPU_AUX: length 65.4
  TOP w0.102: v3(142.79,114.9) 142.46,114.57 142.08,114.57 141.28,113.77 v3(120.86,113.77) 117.68,113.77 117.19,114.26 117.19,117 116.68,117.51 116.68,118.1 116.75,118.17 117.01,118.17 C449.2
  BOTTOM w0.076: 139.55,87.79 139.55,87.72 139.5,87.67 139.5,87.12 140.86,85.76 140.86,85.31 141.2,84.97 141.32,84.85 arc(141.38,84.77) 141.4,84.68 arc(141.41,84.55) 141.37,84.42 141.28,84.28 arc(141.18,84.18) 141.04,84.15 140.97,84.15 arc(140.91,84.12) 140.89,84.07 UC1.B45
  BOTTOM w0.102: 139.55,87.79 139.55,92.12 140.96,93.53 140.96,105.52 142.52,107.09 142.52,111.99 143.84,113.31 143.84,114.3 143.45,114.69 142.99,114.69 v3(142.79,114.9)
EDP_CPU_AUX#: length 65.4
  TOP w0.102: v4(142.79,114.03) 142.79,114.13 142.57,114.35 142.17,114.35 141.37,113.55 121.14,113.55 121.12,113.54 120.58,113.54 120.56,113.55 117.59,113.55 116.97,114.17 116.97,116.92 116.46,117.42 116.46,117.83 C450.2
  BOTTOM w0.076: 139.34,87.79 139.34,87.05 140.69,85.7 140.69,85.24 141.14,84.8 141.2,84.73 arc(141.23,84.69) 141.24,84.64 arc(141.25,84.58) 141.23,84.51 141.14,84.37 arc(141.1,84.33) 141.04,84.31 140.97,84.31 arc(140.91,84.33) 140.89,84.39 UC1.A45
  BOTTOM w0.102: v4(142.79,114.03) 142.59,114.24 142.59,114.39 142.68,114.48 143.36,114.48 143.63,114.21 143.63,113.4 142.31,112.08 142.31,107.18 140.74,105.61 140.74,93.62 139.34,92.21 139.34,87.79
EDP_CPU_AUX#_C: length 2.3
  TOP w0.102: C450.1 116.54,119.3 116.54,119.89 116.96,120.31 U52.3
EDP_CPU_AUX_C: length 2.4
  TOP w0.102: C449.1 116.75,119.34 116.75,119.8 117.36,120.41 U52.4
EDP_CPU_HPD: length 101.1
  TOP w0.102: RC158.1 172.48,92.82 v3(172.3,92.65) ; v3(149.5,113.07) 149.16,112.74 147.77,112.74 146.46,114.04 144.35,114.04 143.37,113.07 139.89,113.07 139.63,112.8 117.61,112.8 116.91,112.1 113.6,112.1 112.92,112.79 v1(112.92,118.26) 112.92,118.71 115.2,120.98 U52.1
  IN1 w0.097: v3(167.73,107.15) 166.97,107.91 164.19,107.91 163.93,108.16 154.52,108.16 149.62,113.07 v3(149.5,113.07)
  IN2 w0.102: v3(167.73,107.15) 167.73,107.07 174.21,100.59 174.21,95.64 172.3,93.74 v3(172.3,92.65)
  BOTTOM w0.076: UC1.D6 165.07,83.07 165.47,83.07 165.75,83.34 165.75,84.2 165.92,84.36 165.92,84.67 167.15,85.9 167.15,87.49 168.29,88.63
  BOTTOM w0.102: 168.29,88.63 v3(172.3,92.65)
EDP_CPU_LANE_N0: length 59
  TOP w0.102: C446.2 118.57,116.24 118.35,116.24 118.25,116.14 118.25,115.49 118.8,114.93 134.78,114.93 134.79,114.95 135.32,114.95 135.33,114.93 141.09,114.93 v4(141.31,115.15)
  BOTTOM w0.076: UC1.C45 140.62,83.52 140.62,83.76 140.41,83.97 140.41,85.45 138.8,87.06 138.8,87.71 138.85,87.76 138.85,87.79
  BOTTOM w0.102: 138.85,87.79 138.85,92.82 140.24,94.21 140.24,106.15 141.58,107.49 141.58,112.72 142.02,113.16 142.02,114.44 141.31,115.15 v4(141.31,115.15)
EDP_CPU_LANE_N0_C: length 4.3
  TOP w0.102: C446.1 118.37,117.36 118.37,117.77 118.68,118.08 118.68,119.31 118.85,119.48 118.85,120.37 118.96,120.48 U52.8
EDP_CPU_LANE_N1: length 57.9
  TOP w0.102: C448.2 119.64,117.68 119.64,115.93 119.9,115.66 129.25,115.66 130.08,116.48 v3(131.87,116.48) 140.03,116.48 140.31,116.2 140.31,115.98 v3(140.55,115.73)
  BOTTOM w0.076: 138.15,87.79 138.15,87.78 138.12,87.75 138.12,87.72 138.1,87.71 138.1,87.04 139.28,85.86 139.28,84.7 139.39,84.59 arc(139.45,84.51) 139.49,84.42 arc(139.53,84.34) 139.61,84.31 139.69,84.31 arc(139.74,84.33) 139.76,84.39 UC1.A47
  BOTTOM w0.102: 138.15,87.79 138.15,95.08 137.99,95.25 137.99,96.44 138.15,96.61 138.15,105.26 140.35,107.45 140.35,114.74 140.14,114.96 140.14,115.31 v3(140.55,115.73)
EDP_CPU_LANE_N1_C: length 2.2
  TOP w0.102: C448.1 119.66,119.35 119.66,120.33 119.76,120.43 U52.10
EDP_CPU_LANE_P0: length 58.9
  TOP w0.102: v3(141.34,114.52) 141.14,114.72 v3(135.06,114.72) 118.71,114.72 118.03,115.4 118.03,115.9 C445.2
  BOTTOM w0.076: 138.64,87.79 138.64,86.99 140.24,85.38 140.24,83.97 139.92,83.65 139.92,83.49 140.14,83.27 140.33,83.27 140.4,83.35 140.4,83.5 UC1.B46
  BOTTOM w0.102: v3(141.34,114.52) 141.64,114.52 141.81,114.35 141.81,113.25 141.37,112.81 141.37,107.58 140.02,106.24 140.02,94.3 138.64,92.91 138.64,87.79
EDP_CPU_LANE_P0_C: length 4.3
  TOP w0.102: U52.7 118.56,120.5 118.63,120.43 118.63,119.57 118.47,119.4 118.47,118.17 118.15,117.86 118.15,117.41 C445.1
EDP_CPU_LANE_P1: length 57.9
  TOP w0.102: C447.2 119.42,117.79 119.42,115.84 119.82,115.44 129.34,115.44 130.17,116.27 131.58,116.27 131.59,116.25 132.15,116.25 132.16,116.27 139.94,116.27 140.1,116.12 140.1,115.91 v4(139.92,115.73)
  BOTTOM w0.076: UC1.B47 139.76,84.07 arc(139.74,84.12) 139.69,84.15 139.61,84.15 arc(139.42,84.21) 139.32,84.39 arc(139.31,84.43) 139.28,84.47 139.28,84.47 arc(139.27,84.47) 139.27,84.47 139.12,84.63 139.12,85.8 137.94,86.98 137.94,87.79
  BOTTOM w0.102: 137.94,87.79 137.94,94.99 137.77,95.16 137.77,96.53 137.94,96.7 137.94,105.35 140.14,107.54 140.14,114.65 139.92,114.87 v4(139.92,115.73)
EDP_CPU_LANE_P1_C: length 2.2
  TOP w0.102: U52.9 119.36,120.48 119.45,120.39 119.45,119.29 C447.1
EN: length 11.1
  TOP w0.102: v1(211.57,162.42) 211.08,161.93 PR65.2
  TOP w0.203: v3(211.83,154.31) 212.37,154.31 212.49,154.44 PU51.6 ; v2(211.9,158.63) 212.18,158.63 212.49,158.31 PU51.20
  TOP w0.254: PR65.2 211.08,160.36 PC70.1 211.07,159.69 211.42,159.35 211.42,158.76 211.55,158.63 v2(211.9,158.63)
  IN2 w0.254: v2(211.9,158.63) 211.83,158.57 v3(211.83,154.31)
EN_1.5VRUN: length 3
  BOTTOM w0.254: PU200.5 229.6,90.85 229.46,90.99 229.46,91.81 v1(229.78,92.14) 230.94,92.14 PR206.2
EN_+V1.05SP: length 4.3
  BOTTOM w0.203: PR153.2 PR154.2 PC157.1 81.19,71.19 v1(81.19,70.34) PU150.28
EN_+VDDRP: length 6.1
  BOTTOM w0.102: PR704.2 36.11,25.94 36.11,25.16 36.06,25.1 v1(36.06,24.5)
  BOTTOM w0.254: PU700.3 34.83,27.76 35.66,26.93 PR704.2 PR703.2 PC708.1
EN_DK_PWRBAR: length 3.1
  TOP w0.254: PR556.1 PR552.1 135.51,156.2 v1(134.79,156.2) PU701.17
EN_DOCK_PWR_BAR: length 99.5
  TOP w0.102: v2(189.58,120.32) 189.16,119.91 189.16,119.45 189.08,119.37 U37.B37 ; v3(138.5,137.12) 138.5,136.07 v1(138.97,135.6)
  TOP w0.254: PR552.2 136.96,156.03 v2(137.33,156.4)
  IN1 w0.097: v2(189.58,120.32) 189.43,120.46 186.76,120.46 186.29,119.99 185.65,119.99 185.49,119.83 181.75,119.83 180.49,121.08 177.98,121.08 176.83,119.93 176.19,119.93 175.71,119.44 175.71,119.09 173.98,117.36 173.98,116.12 173.07,115.2 168.21,115.2 167.93,114.91 165.66,114.91 165.15,115.42 158.63,115.42 157.51,116.55 157.51,117.91 157.51,119.27 156.54,120.25 156.54,121.11 156.54,122.48 155.88,123.15 155.88,124.78 154.67,125.99 154.67,125.99 154.37,126.29 154.37,132.17 147.78,138.76 143.2,138.76 141.39,136.94 138.67,136.94 v3(138.5,137.12)
  BOTTOM w0.102: v2(137.33,156.4) 137.13,156.4 136.26,155.54 136.26,150.05 134.74,148.53 134.74,146.37 135.86,145.25 135.86,140.8 138.5,138.16 v3(138.5,137.12)
EN_I2S_NB_CODEC#: length 172.9
  TOP w0.102: v2(188.69,119.85) 188.69,119.87 188.59,119.77 U37.B36
  BOTTOM w0.102: v2(188.69,119.85) 188.69,119.97 189.8,121.08 189.8,121.96 191.98,124.14 193.34,124.14 193.84,124.64 196.64,124.64 197.73,123.56 198.64,123.56 200.22,121.98 200.93,121.98 201.78,121.13 201.78,118.97 213.55,107.2 213.55,105.13 215.9,102.78 222.88,102.78 223.06,102.6 225.13,102.6 225.13,102.6 226.02,102.6 227.32,103.9 227.32,105.6 226.36,106.56 226.36,111.9 228.24,113.77 228.41,113.95 228.41,121.67 231.74,124.99 233.97,124.99 234.39,125.41 243.76,125.41 248.42,130.07 250,130.07 250.99,131.07 250.99,134.99 252.72,136.71 264.5,136.71 274.41,146.62 290.41,146.62 297.17,153.38 297.17,153.54 297.17,156.57 297.78,157.18 298.46,157.18 298.72,157.44 298.72,158.69 298.97,158.94 v1(299.63,158.94) 301.63,158.94 301.9,158.67 301.9,157.66 302.38,157.18 302.52,157.18 303.2,156.5 304.74,156.5 305.37,155.87 305.24,155.73 U17.48
EN_INVPWR: length 185.1
  TOP w0.102: U38.A25 172.77,123.89 173.8,124.93 173.8,125.99 173.52,126.27 173.52,126.61 173.75,126.83 174.64,126.83 R371.2 175.17,126.3 176.04,126.3 176.83,127.09 v1(176.83,128.32) v3(176.83,129.58)
  IN1 w0.097: v3(176.83,129.58) 180.99,129.58 181.45,129.12 194.01,129.12 194.52,128.61 196.36,128.61 197.5,127.47 197.5,126.83 199.27,125.05 199.27,123.2 198.64,122.57 198.62,122.57 197.25,121.2 197.25,118.62 196.88,118.26 194.71,118.26 194.07,117.61 194.07,116.58 193.39,115.9 193.26,115.9 193.26,115.9 192.96,115.9 192.56,115.9 192.37,115.9 191.72,115.25 190.26,115.25 189.79,114.78 183.36,114.78 177.86,109.29 171.11,109.29 170.63,108.81 164.56,108.81 164.29,109.08 154.87,109.08 150.72,113.23 150.72,113.39 150.72,114.14 139.64,125.22 139.64,131.77 138.25,133.16 133.01,133.16 132.09,134.08 129.5,134.08 126.87,136.71 118.2,136.71 112.97,141.95 112.97,145.02 110.38,147.61 v3(109.24,147.61)
  IN3 w0.102: v3(109.24,147.61) 105.05,143.42 99.38,143.42 98.31,144.49 95.11,144.49 94.91,144.69 89.92,144.69 87.81,146.8 86.5,146.8 v3(86.08,147.22)
  BOTTOM w0.102: Q125.5 v3(86.08,147.22)
EN_LCDPWR: length 5.1
  BOTTOM w0.102: U33.4 97.44,140.31 R2678.1 96.87,140.88 95.95,140.88 v1(95.6,141.23) 95.18,141.66 D76.1
ENVDD_PCH: length 233
  TOP w0.076: v2(164.84,88.35) 164.91,88.43 169.05,88.43 169.82,89.19 169.82,89.24
  TOP w0.102: U37.B38 189.59,119.68 v2(189.61,119.71) ; RC152.2 169.82,89.24
  IN1 w0.097: v3(101.26,156.88) 104.05,156.88 104.38,156.55 104.94,156.55 109.44,152.06 110.48,152.06 111.5,151.04 111.5,149.67 119.75,141.41 119.83,141.41 119.86,141.38 128.83,141.38 130.5,139.71 133.87,139.71 134.28,139.31 134.28,138.64 136.31,136.61 141.37,136.61 143.29,138.53 147.17,138.53 152.52,133.18 v3(152.72,133.18) 154.14,131.76 154.14,126.2 154.58,125.76 155.44,124.9 155.44,120.92 157.29,119.07 157.29,116.45 158.31,115.43 158.31,115.43 158.54,115.2 165.05,115.2 165.57,114.69 168.04,114.69 168.33,114.97 173.63,114.97 174.51,115.86 174.51,117.5 175.69,118.68 176.37,118.68 176.79,119.09 176.8,119.09 177.03,119.31 177.03,119.62 177.03,119.63 177.03,119.76 177.03,119.77 178.13,120.86 180.4,120.86 181.66,119.6 185.58,119.6 185.74,119.77 186.38,119.77 186.85,120.24 189.08,120.24 v2(189.61,119.71)
  BOTTOM w0.076: 165.44,89.03 164.84,88.43 v2(164.84,88.35) 165.24,87.95 165.24,85.23 164.91,84.9 164.91,84.22 164.72,84.03 164.72,83.72 UC1.C6
  BOTTOM w0.102: 165.44,89.03 166.51,90.11 166.51,92.38 167.85,93.71 167.85,96.25 167.19,96.91 166.03,96.91 165.5,96.38 163.08,96.38 157.03,102.44 151.77,102.44 151.5,102.72 146.55,102.72 145.46,103.8 145.46,107.3 147.26,109.1 147.26,112.48 146.93,112.81 146.93,119.87 146.5,120.31 146.5,126.99 152.7,133.18 v3(152.72,133.18) ; v3(101.26,156.88) v1(100.73,156.36) 100.37,155.99 100.37,152.64 101.21,151.8 102.58,151.8 103.98,150.41 103.98,145.27 102.33,143.62 97.9,143.62 96.93,144.59 92.08,144.59 91.51,144.02 U86.2
ERC1: length 5.9
  TOP w0.102: v1(131.46,146.95) 131.41,147 131.41,148.74 PC512.1
  TOP w0.254: PU701.3 129.65,151.14 129.44,150.94 129.44,150.49 130.48,149.45 PC512.1
ERC2: length 2.5
  TOP w0.254: PC514.1 135.34,153.58 135.09,153.58 v1(134.79,153.88) 134.48,154.2 PU701.13
ERC3: length 4.2
  TOP w0.102: v1(135.88,150.89) 135.44,151.32 PC513.1
  TOP w0.254: PC513.1 135.19,152.34 135.19,152.82 134.32,153.7 PU701.12
EXP_PRX_EXPTX_N6: length 32.5
  TOP w0.102: v3(187.82,84.11) 187.8,84.11 187.51,84.4 187.51,84.71 R2659.2
  IN1 w0.076: v2(165.17,81.62) 165.36,81.81 165.62,81.81 165.92,82.11 165.92,82.71 166.35,83.14 166.38,83.14 166.54,83.3
  IN1 w0.097: 166.54,83.3 166.92,83.68 168.86,83.68 174.31,89.13 178.26,89.13 185.03,82.36 186.5,82.36 187.68,83.54 187.68,83.97 v3(187.82,84.11)
  BOTTOM w0.076: UC1.F5 165.51,81.29 v2(165.17,81.62)
  BOTTOM w0.102: v3(187.82,84.11) 187.48,84.45 187.48,84.68 R2659.2
EXP_PRX_EXPTX_N6_CL: length 84.8
  TOP w0.102: v2(204.35,90.46) 204.35,90.6 204.28,90.66 204.14,90.66 204.05,90.75 198.61,90.75 197.56,89.71 v3(195.74,89.71) 193.12,89.71 193.09,89.69 192.15,89.69 192.13,89.71 184.77,89.71 184.29,89.23 184.29,88.89 186.2,86.98 186.93,86.98 187.29,86.63 187.29,85.99 187.44,85.84 R2659.1
  IN1 w0.097: v3(223.05,133.59) 222.95,133.49 222.95,133.11 222.39,132.55 222.39,130.92 222.49,130.83 222.49,119.54 220.21,117.26 220.21,116.78 217.6,114.17 217.6,114.17 216.92,113.49 213.8,113.49 202.41,102.1 202.41,96.16 205.4,93.16 205.4,90.83 205.18,90.61 204.49,90.61 v2(204.35,90.46)
  BOTTOM w0.102: v3(223.05,133.59) 223.03,133.59 222.84,133.4 222.84,133.25 222.94,133.15 223.32,133.15 223.66,132.8 224.51,132.8 224.63,132.92 R2663.2
EXP_PRX_EXPTX_N6_M: length 11
  TOP w0.102: v4(189.53,91.89) 189.32,92.1 189.32,93.13 189.33,93.14 189.33,93.67 189.32,93.69 189.32,93.89 189.09,94.12 188.46,94.75 188.46,94.93 188.6,95.07 U91.7
  BOTTOM w0.102: v4(189.53,91.89) 189.31,91.67 189.31,88.57 187.42,86.68 187.42,86.14 R60.1
EXP_PRX_EXPTX_P6: length 32.4
  TOP w0.102: v3(187.19,84.11) 187.29,84.21 187.29,84.47 R2658.2
  IN1 w0.076: v2(165.21,82.32) 165.21,82.09 165.32,81.98 165.55,81.98 165.75,82.18 165.75,82.78 166.23,83.26 166.23,83.29 166.24,83.3
  IN1 w0.097: 166.24,83.3 166.83,83.89 168.77,83.89 174.22,89.34 178.35,89.34 185.12,82.57 186.41,82.57 187.47,83.63 187.47,83.91 187.26,84.11 v3(187.19,84.11)
  BOTTOM w0.076: v2(165.21,82.32) 165.54,81.99 UC1.E5
  BOTTOM w0.102: R2658.2 187.26,84.49 187.26,84.19 v3(187.19,84.11)
EXP_PRX_EXPTX_P6_CL: length 84.8
  TOP w0.102: v2(204.32,91.1) 204.19,90.97 198.52,90.97 197.48,89.93 196.03,89.93 196.02,89.94 195.47,89.94 195.46,89.93 v3(192.59,89.93) 184.68,89.93 184.08,89.32 184.08,88.8 186.11,86.77 186.84,86.77 187.07,86.54 187.07,86.08 R2658.1
  IN1 w0.097: v2(204.32,91.1) 204.32,90.98 204.43,90.86 204.51,90.86 204.56,90.82 205.1,90.82 205.19,90.91 205.19,93.08 202.2,96.07 202.2,102.19 213.71,113.7 216.83,113.7 217.39,114.26 220,116.87 220,117.35 222.28,119.63 222.28,130.74 222.18,130.84 222.18,132.64 222.74,133.2 222.74,133.33 222.65,133.42 222.65,133.51 222.57,133.59 v3(222.42,133.59)
  BOTTOM w0.102: v3(222.42,133.59) 222.62,133.39 222.62,133.16 222.85,132.93 223.23,132.93 223.57,132.59 224.39,132.59 R2662.2
EXP_PRX_EXPTX_P6_M: length 11
  TOP w0.102: U91.6 188.1,94.96 188.24,94.82 188.24,94.66 189.11,93.8 v3(189.11,93.41) 189.11,92.13 v3(188.9,91.92)
  BOTTOM w0.102: R56.1 187.2,86.21 187.2,86.77 189.09,88.66 189.09,91.72 v3(188.9,91.92)
EXP_PTX_EXPRX_N6: length 54.9
  TOP w0.102: R2661.2 185.66,84.64 185.66,84.44 v3(185.89,84.21)
  IN1 w0.076: 163.33,83.3 163.33,83.28 163.35,83.26 163.35,83.16 162.68,82.49 162.68,81.95 162.63,81.9 162.63,79.34 162.36,79.07 161.83,79.07 161.74,79.16 160.11,79.16 160,79.27 159.58,79.27 159.58,79.27 159.28,79.27 159.28,79.27 159.22,79.27 159.07,79.42 159.07,82.66 157.06,84.67 157.06,86.35 157.38,86.66 158.07,86.66 v3(158.33,86.4)
  IN1 w0.097: v3(185.89,84.21) 185.64,84.47 185.64,87.55 182.88,90.31 179.32,90.31 178.92,90.72 173.65,90.72 168.24,85.3 164.61,85.3 163.33,84.03 163.33,83.3
  BOTTOM w0.076: v3(158.33,86.4) 158.33,86.48 158.57,86.71 158.75,86.71 158.96,86.51 158.96,84.97 158.73,84.74 158.73,84.4 158.41,84.09 158.41,83.81 157.98,83.39 157.98,83.24 158.09,83.14 158.23,83.14 UC1.C17
  BOTTOM w0.102: v3(185.89,84.21) 185.64,84.47 185.64,84.62 R2661.2
EXP_PTX_EXPRX_N6_CL: length 83.8
  TOP w0.102: v3(203.54,91.71) 203.6,91.77 203.6,92.01 203.46,92.15 203.44,92.15 203.42,92.18 200.78,92.18 200.75,92.15 200.22,92.15 200.19,92.18 v3(198.12,92.18) 195.53,92.18 193.77,90.41 184.48,90.41 183.59,89.52 183.59,88.35 185.59,86.36 185.59,86.19 R2661.1
  IN1 w0.097: v3(203.54,91.71) 203.73,91.9 203.91,91.9 204.49,92.49 204.49,92.9 201.62,95.77 201.62,102.29 213.59,114.25 216.7,114.25 219.52,117.07 219.52,117.54 221.78,119.8 221.78,128.77 221.28,129.27 221.28,133.08 v3(221.73,133.54)
  BOTTOM w0.102: R2664.2 223.74,134.43 223.62,134.54 223.22,134.54 222.7,134.02 221.48,134.02 221.39,133.93 221.39,133.75 221.6,133.54 v3(221.73,133.54)
EXP_PTX_EXPRX_N6_M: length 11.9
  TOP w0.102: U91.5 187.6,94.91 187.47,94.78 187.47,94.55 187.61,94.41 187.61,93.84 187.74,93.71 187.99,93.46 187.99,92.08 v4(188.18,91.89)
  BOTTOM w0.102: v4(188.18,91.89) 187.98,91.68 187.98,91.27 188.52,90.73 188.52,88.77 186.62,86.87 185.98,86.87 185.56,86.45 185.56,86.22 R51.1
EXP_PTX_EXPRX_P6: length 55
  TOP w0.102: v3(185.26,84.21) 185.45,84.4 185.45,84.53 R2660.2
  IN1 w0.076: v2(158.33,87.01) 158.16,86.83 157.31,86.83 156.9,86.42 156.9,84.6 158.9,82.6 158.9,79.35 159.15,79.11 159.21,79.11 159.21,79.1 159.64,79.1 159.65,79.11 159.93,79.11 160.04,78.99 161.67,78.99 161.76,78.9 162.43,78.9 162.79,79.27 162.79,81.83 162.84,81.88 162.84,82.42 163.52,83.1 163.52,83.26 163.54,83.28 163.54,83.3
  IN1 w0.097: v3(185.26,84.21) 185.43,84.38 185.43,87.47 182.79,90.1 179.23,90.1 178.83,90.51 173.74,90.51 168.33,85.09 164.69,85.09 163.54,83.94 163.54,83.3
  BOTTOM w0.076: UC1.D17 158.74,82.85 158.74,83.5 158.58,83.67 158.58,84.02 158.89,84.33 158.89,84.67 159.12,84.9 159.12,86.58 158.82,86.88 158.46,86.88 v2(158.33,87.01)
  BOTTOM w0.102: R2660.2 185.42,84.56 185.42,84.38 185.42,84.38 v3(185.26,84.21)
EXP_PTX_EXPRX_P6_CL: length 83.8
  TOP w0.102: v2(203.57,92.62) 203.34,92.39 v3(200.49,92.39) 198.4,92.39 198.39,92.4 197.84,92.4 197.83,92.39 195.44,92.39 193.68,90.63 184.39,90.63 183.38,89.61 183.38,88.26 185.37,86.27 185.37,86.16 R2660.1
  IN1 w0.097: v2(203.57,92.62) 203.42,92.47 203.42,92.24 203.54,92.11 203.82,92.11 204.28,92.58 204.28,92.81 201.41,95.68 201.41,102.37 213.5,114.46 216.62,114.46 219.31,117.16 219.31,117.63 221.57,119.89 221.57,128.68 221.06,129.18 221.06,133.17 221.12,133.22 221.12,133.45 v3(221.05,133.51)
  BOTTOM w0.102: v3(221.05,133.51) 221.17,133.64 221.17,134.02 221.39,134.24 222.61,134.24 223.13,134.76 223.49,134.76 R2665.2
EXP_PTX_EXPRX_P6_M: length 11.9
  TOP w0.102: v3(187.54,91.86) 187.77,92.09 187.77,93.37 187.39,93.75 v3(187.39,94.02) 187.39,94.32 187.25,94.46 187.25,94.74 187.1,94.89 U91.4
  BOTTOM w0.102: R50.1 185.35,86.13 185.35,86.31 185.35,86.31 185.35,86.54 185.89,87.08 186.53,87.08 188.31,88.86 188.31,90.64 187.76,91.18 187.76,91.64 v3(187.54,91.86)
EXPCLK_REQ#: length 329.6
  TOP w0.102: v3(107.93,113.74) 107.93,114.35 R170.2 108.22,114.46 108.74,113.94 U93.3 109.21,113.94 109.4,113.75 R488.1 RC196.2 ; JEXP1.31 89.56,21.64 89.17,21.25 89.17,20.61 88.79,20.23 87.87,20.23 86.34,18.71 84.98,18.71 83.91,17.64 83.91,16.32 v3(83.24,15.65)
  IN2 w0.102: v3(83.24,15.65) 83.24,18.16 v3(78.5,22.9)
  IN3 w0.102: v3(107.93,113.74) 105.43,116.24 105.43,120.06 102.82,122.67 83.74,122.67 81.38,120.31 78.73,120.31 78.04,119.62 73.6,119.62 71.67,121.55 32.99,121.55 27.76,116.32 24.13,116.32 20.31,112.5 20.31,111.76 22.38,109.69 22.38,96.4 21.62,95.64 21.62,64.98 20.6,63.97 4.15,63.97 2.94,62.75 2.94,31.42 18.29,16.06 32.59,16.06 32.83,16.31 33.02,16.31 33.9,17.18 33.9,22.99 34.67,23.76 37.14,23.76 37.78,24.4 48.26,24.4 49.67,22.99 53.35,22.99 54.39,21.94 63.75,21.94 72.3,30.49 76.5,30.49 77.57,29.42 77.6,29.42 78.3,28.73 78.3,25.56 76.93,24.19 76.93,23.02 77.54,22.41 78.02,22.41 v3(78.5,22.9)
  BOTTOM w0.102: v3(78.5,22.9) 77.87,22.26 v1(76.75,22.26) 76.67,22.34 76.67,23.41 76.67,23.41 CE20.1
EXPRCRD_STBY_R#: length 18.3
  TOP w0.102: JEXP1.29 90.06,23.4 89.42,24.04 89.42,24.9 88.26,26.07 85.49,26.07 v3(83.46,28.1)
  BOTTOM w0.102: R734.1 79.21,29.63 v1(79.9,29.63) 81.68,29.63 83.2,28.1 v3(83.46,28.1)
EXPRESS_DET#: length 483.2
  TOP w0.102: v2(189.73,126.88) 189.73,126.88 189.73,126.96 189.36,127.33 189.36,127.51 189.09,127.79 189.09,128.24 U37.B15 ; v3(110.56,115.84) 110.83,115.56 U93.6 ; v2(188.34,130.44) 187.77,131.01 R419.2 ; v3(186.2,91.07) 186.2,91.32 185.29,92.24 R37.2 ; v3(79.68,23.65) 82.26,26.22 82.26,27.55 83.28,28.56 84.14,28.56 86.25,26.45 89.45,26.45 90.69,25.21 90.69,24.29 90.56,24.16 JEXP1.27
  IN1 w0.097: v2(188.34,130.44) 187.62,129.72 186.87,129.72 184.52,132.07 v2(179.2,132.07) ; v3(231.77,43.85) 231.77,31.25 232.4,30.62 232.4,18.42 225.75,11.78 152.77,11.78 150.91,9.92 139.79,9.92 137.93,11.78 116.83,11.78 115.85,11.78 113.88,13.75 100.04,13.75 99.1,12.81 96.1,12.81 95.32,12.03 93.92,12.03 93.46,12.48 88.73,12.48 87.2,14 80.69,14 77.46,17.23 77.46,19.56 79.68,21.78 v3(79.68,23.65)
  IN2 w0.102: v2(189.73,126.88) 189.37,127.23 189.37,129.4 v2(188.34,130.44) 188.34,130.99 189.12,131.77 189.12,133.4 189.97,134.25 191.15,134.25 191.89,134.99 192.26,134.99 192.41,134.83 195.26,134.83 196.58,133.51 198.77,133.51 199.63,132.65 203.96,132.65 205.63,130.98 205.63,130.52 208.52,127.63 208.52,127.62 208.88,127.27 208.88,105.42 v3(210.96,103.34) 211.47,102.83 211.47,92.39 212.31,91.56 212.31,86.39 218.08,80.62 218.08,70.6 231.77,56.9 v3(231.77,43.85)
  IN3 w0.102: v3(186.2,91.07) 186.27,90.99 195.67,90.99 195.67,90.99 196.17,90.99 203.79,98.61 208.98,98.61 209.64,99.27 209.64,102.02 v3(210.96,103.34) ; v3(162.54,138.91) 158.1,138.91 154.79,135.6 154.79,134.12 152.52,131.85 151.2,131.85 148.57,129.21 148.57,123.33 145.14,119.9 128.57,119.9 126.62,117.96 126.62,117.69 124.59,115.66 110.73,115.66 v3(110.56,115.84)
  BOTTOM w0.102: CE22.1 77.71,25.03 77.71,23.81 v1(77.92,23.6) 78.22,23.3 79.34,23.3 v3(79.68,23.65) ; v3(162.54,138.91) 162.75,138.91 167.69,143.85 171.3,143.85 174.47,140.68 174.47,140.43 180.13,134.77 180.13,132.99 v2(179.2,132.07)
EXPRESS_DET#_M: length 3.7
  TOP w0.102: v1(184.01,93.13) 184.62,93.74 185.24,93.74 R37.1 186.02,94.52 186.15,94.52 186.6,94.97 U91.3
F-IMAX: length 5.1
  BOTTOM w0.203: PR308.1 81.17,94.37 81.27,94.37 v1(81.52,94.12) 82.21,93.44 82.75,93.44 83.28,92.91 PU300.10
  BOTTOM w0.254: PR308.1 PR303.2
FAN1_PWM: length 237.7
  TOP w0.102: v3(20.89,115.12) 20.89,114.59 19.57,113.27 JFAN1.3 ; U38.A24 172.6,123.39 v2(173.07,122.92) 173.07,123.63 173.75,124.32 174.13,124.32 R408.2
  IN1 w0.097: v2(173.07,122.92) 174.67,121.32 174.67,119.16 173.45,117.94 168.85,117.94 168.64,117.73 168.64,116.26 167.73,115.36 165.91,115.36 165.4,115.87 161,115.87 158.06,118.82 158.06,118.86 158.05,118.86 158.05,119.37 156.99,120.43 156.99,122.48 156.99,122.67 156.51,123.15 156.51,126.45 156.86,126.8 156.86,132 149.6,139.27 143.4,139.27 141.66,137.53 136.05,137.53 134.51,139.07 134.51,139.43 133.92,140.02 130.51,140.02 128.92,141.61 119.96,141.61 112.28,149.28 112.28,150.91 107.46,155.73 106.62,155.73 104.87,157.49 100.3,157.49 98.41,155.6 92.05,155.6 90.65,157 89.65,157 87.02,159.63 84.56,159.63 84.36,159.42 84.36,159.08 89.22,154.22 89.22,148.93 84.03,143.74 84.03,139.23 82.44,137.64 82.44,134.9 80.93,133.39 73.42,133.39 64.15,124.12 35.32,124.12 32.27,121.07 24.73,121.07 20.89,117.23 v3(20.89,115.12)
  BOTTOM w0.102: v3(20.89,115.12) v1(21.68,115.12)
FAN1_TACH: length 238
  TOP w0.102: R376.2 173.93,117.51 173.22,118.22 v2(173.22,118.66) ; v2(20.23,115.15) 20.23,114.69 18.32,112.78 JFAN1.2 ; v2(169.4,120.99) 169.4,121.18 169.86,121.64 U38.B22
  IN1 w0.097: v2(169.4,120.99) 169.4,120.99 169.82,121.42 170.87,121.42 172.27,120.02 172.27,120.02 172.27,120.01 172.59,120.01 172.59,120.02 172.92,120.02 173.35,119.59 173.35,118.78 v2(173.22,118.66) 173.22,118.4 172.99,118.17 168.76,118.17 168.41,117.82 168.41,116.35 167.64,115.58 166.01,115.58 165.49,116.09 161.18,116.09 159.07,118.2 159.07,118.99 157.21,120.84 157.21,122.39 157.21,122.57 157.21,122.76 156.75,123.22 156.75,126.38 157.08,126.71 157.08,132.1 149.69,139.49 149.65,139.49 143.23,139.49 141.49,137.75 136.14,137.75 134.74,139.16 134.74,139.56 133.24,141.06 129.78,141.06 129.01,141.83 120.05,141.83 112.51,149.37 112.51,151.01 107.56,155.96 106.76,155.96 104.97,157.75 100.17,157.75 98.25,155.83 92.14,155.83 90.74,157.23 89.74,157.23 87.12,159.85 84.47,159.85 84.13,159.52 84.13,158.99 88.99,154.13 88.99,149.02 83.8,143.83 83.8,139.33 82.21,137.74 82.21,134.99 80.83,133.61 73.08,133.61 63.81,124.34 35.23,124.34 32.19,121.3 24.6,121.3 20.23,116.93 v2(20.23,115.15)
  BOTTOM w0.102: v2(20.23,115.15) v1(19.22,115.15)
FB_+VDDRP: length 6.9
  BOTTOM w0.102: v1(32.22,24.18) 31.88,24.18 31.55,24.51 31.55,26.2 31.75,26.4 PR707.1
  BOTTOM w0.254: PR707.1 PR708.1 32.99,26.88 33.12,27.01 33.85,27.01 34.33,27.49 PU700.4
FB_VREF: length 25.4
  TOP w0.102: T171.1 v3(62.75,115.73)
  IN1 w0.097: 62.83,111.48 61.97,112.34 61.97,114.95 v3(62.75,115.73)
  IN1 w0.102: 62.83,111.48 63.1,111.21 63.1,111.21 63.23,111.09 63.23,110.22 62.74,109.73 62.74,107.67 60.39,105.32 58.94,105.32 58.48,104.85 56.42,104.85 55.26,106.01 55.26,108.57 54.92,108.92 52.76,108.92 v5(52.35,108.52)
  BOTTOM w0.134: v5(52.35,108.52) 52.73,108.14 UV1.D23
FBA_CLK0_C: length 2
  BOTTOM w0.102: RV2707.1 RV2708.1 33.86,115.95 CV2901.1
FBA_CLK1_C: length 1.8
  TOP w0.102: RV2719.1 RV2718.1 36.41,83.5 CV2944.1
FBA_CMD0: length 39.6
  TOP w0.102: v2(31.82,106.82) 32.21,107.2 32.21,107.77 31.57,108.41 31.57,108.98 31.92,109.33 UV5.L2
  IN3 w0.091: v2(31.73,102.52) 31.73,102.58 31.38,102.94 31.38,106.23 31.82,106.67 v2(31.82,106.82)
  BOTTOM w0.102: UV4.L2 31.92,104.82 31.51,105.23 31.51,106.5 v2(31.82,106.82) ; 48.46,108.03 49.2,108.76 49.35,108.76 UV1.C27
  BOTTOM w0.122: 48.46,108.03 48.45,108.02 v1(46.24,108.02) 46,108.02 40.98,102.99 27.84,102.99 27.71,102.86 27.71,102.16 27.84,102.04 31.25,102.04 v2(31.73,102.52)
FBA_CMD2: length 46.3
  TOP w0.102: 32.39,111.9 32.39,110.63 UV5.K1 32.4,109.98 32.4,109.37 32.59,109.18 32.89,109.18 33.11,108.96 33.11,108.55 33.84,107.81 33.84,107.42 v2(33.44,107.01)
  TOP w0.122: 32.39,111.9 v2(32.39,112.47)
  IN1 w0.114: v2(33.23,102.15) 33.94,101.44 39.83,101.44 42.32,103.93 42.32,104.09 42.07,104.34 42.07,104.5 42.24,104.66 42.4,104.66 42.65,104.41 42.81,104.41 42.97,104.57 42.97,104.74 42.16,105.54 42.16,105.72 42.31,105.86 42.49,105.86 43.29,105.06 43.45,105.06 43.62,105.22 43.62,105.38 42.88,106.12 42.88,106.29 43.03,106.44 43.2,106.44 43.94,105.71 44.1,105.71 44.26,105.87 44.26,106.03 43.54,106.75 43.54,106.93 43.68,107.07 43.86,107.07 44.59,106.35 44.75,106.35 45.28,106.89 v5(51.53,106.89)
  IN3 w0.091: v2(33.44,107.01) 33.44,106.62 32.27,105.45 32.27,104.29 33.11,103.45 33.11,102.31 33.23,102.18 v2(33.23,102.15)
  BOTTOM w0.102: UV4.K1 32.4,104.22 32.4,105.63 33.44,106.68 v2(33.44,107.01)
  BOTTOM w0.122: v2(32.39,112.47) 31.89,112.98 RV2440.1 ; UV1.E24 51.93,107.29 v5(51.53,106.89)
FBA_CMD3: length 44
  TOP w0.102: UV5.K9 32.66,103.96 32.66,104.31 32.4,104.57 32.4,106.15 32.58,106.34 33.28,106.34 33.58,106.64 33.63,106.64 33.84,106.86 v2(34.28,106.86)
  IN1 w0.114: v5(52.33,106.86) 52.17,106.86 51.76,107.27 49.86,107.27 49.45,107.67 42.79,107.67 41.82,106.7 41.82,105.7 41.69,105.58 41.03,105.58 40.91,105.45 40.91,105.2 41.03,105.07 41.59,105.07 41.72,104.94 41.72,104.74 41.59,104.61 40.97,104.61 40.9,104.54 40.9,104.28 41.02,104.16 41.61,104.16 41.73,104.03 41.73,103.83 41.61,103.7 41.02,103.7 40.9,103.57 40.9,102.99 39.69,101.78 34.53,101.78 v2(34.13,102.18)
  IN3 w0.091: v2(34.13,102.18) 34.13,102.68 33.54,103.27 33.54,104.5 33.58,104.54 33.58,106.15 34.27,106.85 34.27,106.86 v2(34.28,106.86)
  BOTTOM w0.102: v2(34.28,106.86) 34.28,107.04 33.87,107.44 33.87,107.78 33.61,108.04 32.92,108.04 32.4,108.57 32.4,109.98 UV4.K9
  BOTTOM w0.122: UV1.F24 51.93,106.46 52.33,106.86 v5(52.33,106.86) ; UV4.K9 32.72,112.09 32.91,112.28 32.91,113.09 RV2438.1
FBA_CMD4: length 55.2
  TOP w0.102: UV5.T7 27.3,106.12 26.3,106.12 25.93,106.49 25.93,107.05 26.31,107.43 v2(26.31,107.49) ; v2(26.32,91.74) 26.32,91.68 25.94,91.3 25.94,90.74 26.31,90.37 27.31,90.37 UV7.T7
  IN3 w0.091: v2(26.31,107.49) 25.91,107.09 25.91,106.3 25.64,106.03 25.64,102 26.12,101.51 26.12,100.75 25.73,100.36 v2(25.73,100.27) 25.64,100.18 25.64,99.19 26.02,98.81 26.02,92.39 26.32,92.09 v2(26.32,91.74)
  BOTTOM w0.102: v2(26.31,107.49) 27.52,108.7 UV4.T7 ; UV6.T7 27.53,92.95 v2(26.32,91.74)
  BOTTOM w0.122: UV1.D27 49.1,107.71 48.78,107.71 48.3,107.24 46.29,107.24 v1(44.21,105.16) 41.3,102.25 34.8,102.25 34.2,101.66 32.26,101.66 31.8,101.2 26.55,101.2 25.73,100.38 v2(25.73,100.27)
