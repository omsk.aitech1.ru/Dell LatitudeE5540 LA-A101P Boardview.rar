# Allegro board Alpine15_LA-A101PR10-0826C.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
BBS_BIT: length 28.8
  TOP w0.102: v1(174.18,98.77) 173.75,98.34 v3(173.75,98.31) 173.55,98.51 RC287.1 ; v2(171.07,95.63) 171.63,95.63 171.8,95.8 171.8,96.43 RC218.2
  IN2 w0.102: v3(173.75,98.31) 171.8,96.35 171.8,95.9 171.52,95.63 v2(171.07,95.63) 170.68,95.23 170.68,90.44 168.96,88.73 168.96,82.74 167.08,80.86 166.59,80.86 165.8,80.07 165.8,79.51 165.36,79.07 164.33,79.07 v2(163.92,78.66)
  BOTTOM w0.076: v2(163.92,78.66) 163.55,78.3 UC1.L8
BC_CLK_ECE1117: length 60.8
  TOP w0.102: v4(181.37,103.85) 181.6,104.08 181.6,105.41 182.14,105.95 183.3,105.95 183.3,105.96 183.89,105.96 183.89,105.95 201.51,105.95 203.98,108.42 205.22,108.42 208.47,108.42 210.07,106.82 210.07,106.29 210.2,106.16 210.96,106.16 211.64,105.48 JKB1.2 ; U38.A20 172.45,121.39 v2(172.47,121.37)
  BOTTOM w0.102: v2(172.47,121.37) 172.42,121.42 171.79,121.42 171.37,121 171.37,120.49 171.86,120.01 172.73,120.01 173.29,119.45 174.13,118.6 174.13,115.98 175.66,114.46 175.66,110.07 180.03,105.7 180.03,104.22 180.96,103.29 181.37,103.29 181.6,103.52 181.6,103.62 v4(181.37,103.85)
BC_CLK_ECE5048: length 29.7
  TOP w0.102: v3(185.88,120.84) 185.93,120.89 U37.A30 ; v2(164.94,129.78) U38.A43
  IN1 w0.097: v3(185.88,120.84) 186.23,120.84 186.36,120.97 186.36,121.43 186.13,121.66 185.06,121.66 184.55,122.17 181.07,122.17 180.67,122.58 178.5,122.58 177.95,123.13 177.22,123.13 177.14,123.2 174.44,123.2 173.73,123.91 173.63,123.91 173.63,123.91 171.22,123.91 171.02,123.71 169.12,123.71 168.17,124.66 166.36,124.66 165.85,125.17 165.85,126 165.51,126.34 165.48,126.36 165.48,126.54 165.27,126.76 165.27,127.58 165.27,127.58 165.27,129.22 164.94,129.55 v2(164.94,129.78)
BC_DAT_ECE1117: length 61.6
  TOP w0.102: U38.B21 170.08,121.14 v2(169.98,121.04) ; JKB1.4 209.64,105.27 209.85,105.47 209.85,106.72 208.38,108.19 205.12,108.19 205.12,108.19 204.07,108.19 201.61,105.73 v3(183.59,105.73) 182.24,105.73 181.83,105.32 181.83,104.05 v3(182.03,103.85) ; v2(172.91,119.21) 173.37,119.21 173.92,118.67 RP18.8
  BOTTOM w0.102: v2(172.91,119.21) 172.92,119.22 ; 172.92,119.22 172.92,119.5 172.63,119.78 171.76,119.78 170.51,121.04 v2(169.98,121.04) ; 172.92,119.22 173.2,119.22 173.9,118.51 173.9,115.89 175.43,114.36 175.43,109.98 179.8,105.61 179.8,104.13 180.86,103.06 181.46,103.06 181.83,103.43 181.83,103.64 182.03,103.85 v3(182.03,103.85)
BC_DAT_ECE5048: length 34
  TOP w0.102: U38.B45 165.19,127.81 165.17,127.79 165.17,127.38 165.45,127.1 165.49,127.1 165.65,126.94 v2(165.73,126.94) ; R343.2 165.12,131.15 v3(164.97,131) ; U37.B31 187.95,121.14 v3(188.15,120.94)
  IN1 w0.097: v3(188.15,120.94) 186.76,120.94 186.58,121.12 186.58,121.53 186.22,121.88 185.16,121.88 184.64,122.39 181.17,122.39 180.76,122.8 178.6,122.8 178.04,123.35 177.31,123.35 177.24,123.42 174.53,123.42 173.82,124.14 173.54,124.14 171.13,124.14 170.93,123.93 169.21,123.93 168.26,124.88 166.46,124.88 166.08,125.26 166.08,126.09 166.01,126.15 165.73,126.43 v2(165.73,126.94) 165.73,127.02 166.06,127.35 166.06,127.77 165.52,128.31 165.52,129.69 165.4,129.81 165.4,130.46 165.09,130.77 165.09,130.87 v3(164.97,131)
BC_INT#_ECE1117: length 59.8
  TOP w0.102: JKB1.5 208.64,107.24 208.17,107.71 207.94,107.71 207.84,107.61 207.84,105.73 207.66,105.55 207.41,105.55 207.23,105.73 207.23,107.61 207.13,107.71 206.72,107.71 206.62,107.61 206.62,105.73 206.44,105.55 206.19,105.55 206.01,105.73 206.01,107.61 205.91,107.71 204.27,107.71 201.81,105.24 v6(193.56,105.24) 182.67,105.24 v3(182.52,105.09) ; v2(173.04,120.45) 172.6,120.89 U38.A19
  BOTTOM w0.102: v3(182.52,105.09) 182.46,105.09 182.46,105.14 181.22,106.39 180.13,106.39 176.14,110.37 176.14,110.79 176.14,114.78 174.62,116.31 174.62,119.28 173.95,119.95 173.54,119.95 v2(173.04,120.45)
BC_INT#_ECE5048: length 32.2
  TOP w0.102: U37.A29 185.45,121.39 185.24,121.18 v2(185.24,120.85) ; v2(164.94,130.39) 165.44,129.89 U38.A42
  IN1 w0.097: v2(164.94,130.39) 164.56,130.01 164.56,128.99 165.01,128.54 165.01,126.16 165.34,125.83 165.34,123.71 166.21,122.85 170.98,122.85 171.56,123.43 173.41,123.43 173.91,122.92 174.11,122.72 174.33,122.72 176.29,122.72 176.73,122.28 176.73,121.98 176.95,121.76 177.26,121.76 177.29,121.78 178.76,121.78 180.78,121.78 181.42,121.14 184.95,121.14 v2(185.24,120.85)
BEEP: length 180.8
  TOP w0.254: U38.B19 170.56,120.14 170.22,119.79 v2(170.11,119.79)
  IN3 w0.254: v2(170.11,119.79) 170.42,119.79 171.54,120.91 172.66,120.91 172.72,120.97 173.47,120.97 174.03,121.53 174.03,124.01 177.54,127.52 177.54,138.37 v3(179.04,139.86)
  BOTTOM w0.254: R353.2 309.41,162.06 308.73,162.06 308.07,162.72 307.1,162.72 306.6,162.22 v6(305.93,162.22) 296.54,162.22 294.35,160.03 294.35,154.07 293.07,152.79 292.03,151.75 289.42,151.75 289.09,151.42 284.39,151.42 281.92,148.94 273.51,148.94 263.97,139.41 244.52,139.41 240.59,135.47 240.17,135.47 234.69,135.47 233.87,134.66 232.98,134.66 231.66,135.98 231.66,138.08 230.96,138.78 215.47,138.78 212.19,135.51 210.28,135.51 209.57,134.8 197.01,134.8 194.71,132.5 193.19,132.5 185.41,140.27 179.44,140.27 v3(179.04,139.86)
BIA_PWM_CVT: length 7.6
  TOP w0.102: v1(127.73,126.2) 127.33,125.8 D79.2 127.33,125.14 126.42,125.14 126.08,124.8 122.46,124.8 121.82,124.16 U52.19
BIA_PWM_EC: length 63.2
  TOP w0.102: U38.B25 170.52,123.14 170.19,122.82 169.52,122.82 v2(169.11,123.23) ; D79.3 128.14,123.85 128.46,124.17 128.46,124.83 130.55,126.91 150.03,126.91 153.14,130.02 153.14,133.82 157.08,137.76 158.69,137.76 159.22,137.22 v1(159.22,136.44) 159.22,135.06 158.59,134.43 158.59,133.74 159.48,132.85 160.09,132.85 v3(160.14,132.9)
  BOTTOM w0.102: v2(169.11,123.23) 167.78,123.23 164.05,126.96 164.05,127.98 162.78,129.25 162.78,131.74 162.02,132.5 162.04,132.5 161.64,132.9 v3(160.14,132.9)
BIA_PWM_OUT: length 4.9
  TOP w0.102: v1(130.38,124.73) 130.38,123.76 LE2.1 129.14,123.32 R2585.1 128.67,123.99 D79.1
BLUE_CRT: length 161.4
  IN1 w0.097: v3(337.89,168.95) 337.89,169.05 337.07,169.86 331.01,169.86 329.96,168.81 317.76,168.81 317.52,169.05 308.72,169.05 308.27,169.49 284.45,169.49 283.65,168.69 278.24,168.69 278.02,168.47 278.02,168.47 277.66,168.12 263.21,168.12 262.25,169.07 259.18,169.07 258.46,169.79 226.3,169.79 223.33,172.76 215.15,172.76 211.92,169.52 196.54,169.52 194.76,171.29 192.14,171.29 190.98,172.45 187.52,172.45 186.73,171.66 v2(186.12,171.66)
  BOTTOM w0.102: v2(186.12,171.66) 186.33,171.46 U39.22 ; v3(337.89,168.95) 337.96,169.02 338.9,169.02 338.98,168.95 JIO1.38
BLUE_DOCK: length 14.8
  IN3 w0.102: v2(178.32,175.32) 178.43,175.42 181.37,175.42 181.88,175.93 185.31,175.93 v3(186.02,175.22)
  BOTTOM w0.102: v3(186.02,175.22) 185.97,175.17 185.97,172.66 185.69,172.38 185.69,171.15 185.68,171.14 185.92,170.9 U39.21 ; v2(178.32,175.32) 178.07,175.07 178.07,174.08 L71.1
BLUE_DOCK_PI: length 3.1
  BOTTOM w0.102: JDOCK1.45 177.95,175.81 177.36,175.22 177.28,175.14 177.28,174.2 L71.2
BOARD_ID: length 8.9
  TOP w0.102: v2(167.17,120.29) 166.95,120.29 166.69,120.03 U38.B10 ; C368.1 R392.2 165.88,115.68 165.88,115.84 v1(165.45,116.27) 165.45,116.93 v3(165.01,117.36)
  IN3 w0.102: v2(167.17,120.29) 166.65,119.76 166.65,119.5 165.01,117.87 v3(165.01,117.36)
BOOT_1.35V: length 2.9
  BOTTOM w0.102: v1(45.41,14.46) 45.08,14.79 42.61,14.79
BPM#0: length 9.6
  BOTTOM w0.076: UC1.J60 131.17,79.29 130.69,79.29 130.65,79.33 129.87,79.33 129.7,79.16 129.2,79.16 127.52,79.16 127.46,79.11 127.09,79.11
  BOTTOM w0.102: 127.09,79.11 v1(125.49,79.11) 122.14,79.11 RC194.1
BPM#1: length 18
  TOP w0.076: 127.75,80.06 128.23,80.06 128.69,80.52 130.64,80.52 v2(131.16,80)
  TOP w0.102: 127.75,80.06 126.38,80.06 126.01,79.69 122.01,79.69 v6(121.56,79.23) 121.16,79.63 120.17,79.63 119.87,79.32 117.61,79.32 116.94,78.66 116.37,78.66 116.26,78.55 115.85,78.55 115.57,78.27 RC204.1
  BOTTOM w0.076: v2(131.16,80) 131.46,80.3 UC1.H60
BQ24715_3.3V: length 18.8
  TOP w0.254: v3(113.33,166.18) 113.05,166.46 v1(113.05,166.79) 113.2,166.94 PR427.2 PR428.1 114.09,165.16 PR425.2 ; v2(119.12,158.62) 119.23,158.73 PU402.5
  BOTTOM w0.254: v3(113.33,166.18) 111.98,164.83 111.98,160.23 113.59,158.62 119.11,158.62 v2(119.12,158.62)
BQ24715_REGN: length 56.1
  TOP w0.254: v2(110.2,138.87) v1(110.2,137.71) 110.34,137.57 111.22,137.57 PR448.1 ; PU402.16 116.08,162.23 114.95,163.36 PC410.1 115,163.79 PR425.1 114.47,164.63 113.23,164.63 PD401.2 111.14,165.96 v3(110.81,165.63) ; PR431.1 123.51,163.11 v3(123.59,163.18)
  BOTTOM w0.254: 111.9,156.55 113.02,157.67 119.98,157.67 122.52,160.21 122.52,162.72 122.98,163.18 v3(123.59,163.18) ; 111.9,156.55 111.9,140.58 v2(110.2,138.87) ; 111.9,156.55 110.81,157.64 v3(110.81,165.63)
BREATH_LED#: length 112.4
  TOP w0.102: Q28.1 210.06,143.56 R436.1 210.2,144.46 v1(209.96,144.7) 209.3,144.7 v2(209.16,144.56) ; U37.B39 190.08,119.36 190.25,119.52 190.25,120.02 v2(190.7,120.47)
  IN3 w0.102: v3(190.52,179.39) 190.41,179.28 190.41,174.94 191.05,174.31 191.05,171.95 191.41,171.59 191.41,170.75 188.41,167.75 188.41,166.25 186.81,164.65 186.81,162.47 185.36,161.02 185.36,155.38 184.09,154.11 184.09,150.53 185.82,148.8 v3(185.82,146.42) 184.19,144.79 184.19,140.45 182.97,139.23 182.97,134.33 183.54,133.76 183.54,123.57 185.04,122.07 185.84,122.07 187.46,120.46 188.56,120.46 188.92,120.82 190.34,120.82 v2(190.7,120.47)
  BOTTOM w0.102: JDOCK1.98 192.95,182.33 192.75,182.13 191.43,182.13 190.31,181.01 190.31,179.59 v3(190.52,179.39) ; v2(209.16,144.56) 209.16,144.23 206.8,141.87 206.8,139.71 206.01,138.92 198.06,138.92 193.36,143.63 193.36,143.69 193.12,143.92 193.06,143.92 190.62,146.37 185.87,146.37 v3(185.82,146.42)
BREATH_LED#_Q: length 130
  TOP w0.102: v3(210.46,140.37) 209.87,140.96 209.87,141.92 209.72,142.07 209.16,142.07 209.07,141.99 Q28.6 ; JPWR1.4 313.25,170.52 313.02,170.75 v6(305.71,170.75) 304.71,171.74 293.36,171.74 290.47,168.85 285.79,168.85 281.14,164.2 281.14,162.86 255.41,137.12 235.1,137.12 234.39,137.83 213.5,137.83 v3(210.68,135.01)
  IN1 w0.097: v3(210.68,135.01) 211.14,135.47 211.14,139.69 v3(210.46,140.37)
BREATH_WHITE_LED#: length 134.5
  TOP w0.102: R436.2 210.2,141.24 v3(210.43,141.01) ; JLED1.8 218.86,32.3 218.56,31.99 215.73,31.99 213.55,34.16 213.55,38.57 218.99,44 v3(218.99,44.44)
  IN1 w0.097: v3(210.43,141.01) 211.57,141.01 212.08,140.5 212.08,133.18 211.27,132.37 211.27,128.46 212.06,127.67 212.06,121.55 v3(211.55,121.04)
  IN2 w0.102: v3(211.55,121.04) 210.82,121.04 210.51,120.73 210.51,109.49 217.69,102.3 218.91,102.3 221.35,99.86 221.35,89.04 219.98,87.67 v3(219.98,87.03)
  BOTTOM w0.102: v3(218.99,44.44) 218.99,46.24 221.48,48.73 221.48,52.78 225.16,56.46 225.16,57.34 225.81,58 225.81,59.16 225.27,59.69 225.27,62.95 225.61,63.28 v1(225.61,69.28) 225.61,70.05 227.3,71.74 227.3,76.11 226.08,77.33 225.82,77.33 220.34,82.81 220.34,86.68 v3(219.98,87.03)
BST_3V:
  vias: v1(213.92,153.69)
BST_5V:
  vias: v1(214.01,159.07)
BST_+V1.05SP: length 6.4
  IN2 w0.508: v3(81.8,63.79) 83.2,65.19 v2(83.2,67.32)
  BOTTOM w0.203: PU150.5 82.93,66.87 83.2,67.14 v2(83.2,67.32)
  BOTTOM w0.508: PC165.1 82.06,63.54 v3(81.8,63.79)
BST_+VDDRP: length 1.2
  BOTTOM w0.102: PR701.1 37.52,30.56 v1(37.52,29.51)
BT_LED#: length 102.2
  TOP w0.102: v3(323.12,178.36) 323.12,167.47 v1(321.99,166.33) 320.97,165.31 v3(320.97,165.26)
  IN3 w0.102: v3(281.93,154.6) 281.93,155.15 282.24,155.46 290.39,155.46 293.26,158.33 297.26,158.33 297.86,158.94 302.11,158.94 302.18,158.86 305.96,158.86 305.96,158.86 306.33,158.86 306.74,159.27 311.57,159.27 313.17,160.87 314.09,161.78 317.67,161.78 320.97,165.09 v3(320.97,165.26)
  BOTTOM w0.102: JMINI1.46 323.1,178.39 v3(323.12,178.36) ; Q30.1 251.22,164.11 251.35,164.23 R229.1 251.78,164.88 253.3,166.41 262.02,166.41 267.61,160.83 267.61,154.6 269.31,152.89 280.23,152.89 v3(281.93,154.6)
BT_RADIO_DIS#: length 162.5
  TOP w0.102: v3(319.68,175.93) v1(318.69,174.95) 317.44,173.7 306.27,173.7 304.93,172.36 293.24,172.36 290.18,169.3 285.6,169.3 280.69,164.39 280.69,163.05 255.51,137.87 235.59,137.87 235.09,138.37 212.75,138.37 210.59,136.21 207.28,136.21 206.42,135.34 192.28,135.34 191.15,134.22 191.15,131.79 R298.2 190.62,130.8 v2(190.25,130.42) 189.84,130.01 U37.A13
  BOTTOM w0.102: D14.1 328.44,176.12 328.32,176.24 R225.1 326.99,175.42 320.18,175.42 v3(319.68,175.93)
BT_RADIO_DIS#_R: length 14.4
  BOTTOM w0.102: JMINI1.51 325.1,187.24 328.98,183.35 v1(328.98,178.56) 328.98,178.33 R225.2 328.58,177.15 D14.2
CAM_MIC_CBL_DET#: length 151.6
  TOP w0.102: v3(93.53,146.75) 92.81,146.04 91.96,146.04 91.46,146.54 91.46,153.83 95.16,157.54 98.03,157.54 98.63,156.95 JLVDS1.8 ; RC193.2 171.21,96.3 v2(171.42,96.1) ; v3(148.25,113.32) 147.92,113.32 v1(147.7,113.54)
  IN1 w0.097: v3(93.53,146.75) 93.53,145.21 93.16,144.84 93.16,143.7 97.99,138.87 97.99,133.63 107.74,123.89 114.52,123.89 116.93,121.47 124.32,121.47 125.35,120.45 126.33,120.45 127.7,119.09 127.77,119.09 142.48,119.09 v3(148.25,113.32)
  IN2 w0.102: v2(171.42,96.1) 171,96.1 170.45,95.55 170.45,90.55 168.77,88.88 168.77,88.83 168.77,83.74 v2(166.49,81.45)
  BOTTOM w0.076: UC1.F4 166.19,81.16 v2(166.49,81.45)
  BOTTOM w0.102: v3(148.25,113.32) 149.8,111.77 149.8,109.96 149.8,109.33 146.64,106.17 146.64,104.29 147.04,103.9 152.64,103.9 152.92,104.18 156.98,104.18 162.04,99.12 163.39,99.12 163.72,98.79 166.83,98.79 167.01,98.61 167.2,98.61 169.12,98.61 170.53,97.21 170.53,96.94 171.36,96.1 171.36,96.1 v2(171.42,96.1)
CARD_SMBCLK: length 338.3
  TOP w0.102: RP15.3 158.26,127.92 158.39,128.05 158.84,128.05 159.01,128.23 159.86,128.23 v3(159.93,128.15) 160.14,128.36 160.23,128.36 160.5,128.08 160.5,127.63 U38.A49 ; JEXP1.34 89.06,17.2 88.94,17.08 88.94,16.52 v3(89.04,16.42)
  IN1 w0.097: v4(159.88,138.21) 159.68,138.01 159.37,138.01 159.12,137.76 159.12,135.39 159.67,134.85 159.67,133.48 159.5,133.32 159.5,128.59 v3(159.93,128.15)
  IN3 w0.102: v3(89.04,16.42) 89.04,16.81 89.26,17.03 92.61,17.03 95.1,14.54 113.68,14.54 116.09,12.13 138.33,12.13 139.72,10.73 145.86,10.73 147.16,12.03 226.3,12.03 231.11,16.83 231.11,17.47 232.12,18.48 232.12,32.33 230.37,34.08 230.37,36.77 229.53,37.6 228.48,37.6 227.61,38.48 227.61,45.42 223.82,49.21 218.18,49.21 215.51,51.88 214.73,51.88 213.38,53.23 213.38,53.71 213.38,56.11 208.63,60.86 208.63,75.63 206.87,77.38 206.87,83.37 206.81,83.43 206.81,95.6 205.38,97.04 v3(204.97,97.45)
  BOTTOM w0.102: v4(159.88,138.21) 160.04,138.06 162.58,138.06 166.97,142.45 171.64,142.45 172.2,141.9 178.2,135.9 178.2,132.31 180.61,129.9 180.61,123.97 180.81,123.77 180.81,115.25 186.27,109.79 187.42,109.79 188.28,108.93 191,108.93 193.01,106.92 195.06,106.92 199.71,102.27 199.71,100.4 203.04,97.07 204.59,97.07 v3(204.97,97.45)
CARD_SMBDAT: length 337.5
  TOP w0.102: RP15.4 158.26,128.42 158.4,128.28 158.74,128.28 158.92,128.46 159.6,128.46 v3(159.93,128.79) 160.14,128.58 160.32,128.58 161.26,127.64 U38.B52 ; JEXP1.36 88.56,17.23 88.71,17.08 88.71,16.67 88.5,16.46 v3(88.37,16.46)
  IN1 w0.097: v3(159.88,137.58) 159.68,137.78 159.47,137.78 159.35,137.66 159.35,135.49 159.89,134.94 159.89,133.39 159.72,133.22 159.72,129 v3(159.93,128.79)
  IN3 w0.102: v2(205.01,96.81) 205.28,96.81 206.59,95.51 206.59,83.33 206.65,83.27 206.65,77.29 208.4,75.53 208.4,60.77 213.15,56.02 213.15,53.8 213.15,53.8 213.15,53.14 214.64,51.65 215.41,51.65 218.08,48.98 223.72,48.98 227.38,45.33 227.38,38.39 228.39,37.38 229.44,37.38 230.14,36.67 230.14,33.99 231.89,32.24 231.89,18.58 230.88,17.56 230.88,16.93 226.21,12.26 147.06,12.26 145.76,10.96 139.82,10.96 138.42,12.36 116.19,12.36 113.78,14.77 95.19,14.77 92.7,17.26 89.17,17.26 v3(88.37,16.46)
  BOTTOM w0.102: v3(159.88,137.58) 160.14,137.83 162.67,137.83 167.07,142.23 171.55,142.23 172.11,141.67 177.97,135.81 177.97,132.22 180.38,129.81 180.38,123.88 180.58,123.68 180.58,115.16 186.18,109.56 187.32,109.56 188.19,108.7 190.9,108.7 192.91,106.69 194.96,106.69 199.48,102.17 199.48,100.3 202.98,96.81 v2(205.01,96.81)
CCD_OFF: length 154.3
  TOP w0.102: U37.B43 192.08,120 v2(192.5,120.41) ; v3(109.24,148.63) v1(108.45,148.63)
  IN1 w0.097: v2(192.5,120.41) 192.51,120.41 192.93,119.99 192.93,117.87 192.04,116.98 192.04,116.83 191.35,116.14 189.88,116.14 189.42,115.68 182.32,115.68 179.64,113.01 178.2,113.01 175.38,110.18 170.73,110.18 170.25,109.7 164.93,109.7 164.45,110.18 163.84,110.18 163.09,110.93 162.88,110.93 161.44,110.93 161.35,110.84 157.49,110.84 156.82,110.18 155.71,110.18 155.04,110.18 151.61,113.6 151.61,114.51 149.08,117.04 149.08,132.43 145.87,135.64 143.31,135.64 141.61,133.95 133.95,133.95 132.17,135.72 130.19,135.72 129.2,136.71 127.75,136.71 125.72,138.75 116.97,138.75 116.35,139.37 116.35,142.79 110.51,148.63 v3(109.24,148.63)
  IN3 w0.102: v3(109.24,148.63) 104.26,143.65 99.53,143.65 98.42,144.77 95.42,144.77 95.27,144.92 90.34,144.92 v3(88.18,147.08)
  BOTTOM w0.102: R2601.2 87.01,153.12 87.01,150.14 87.89,149.26 87.89,147.37 v3(88.18,147.08)
CD3301_DCIN:
  vias: v1(127.91,150.57)
CD3301_SDC_IN: length 2.9
  TOP w0.254: PU701.6 131.15,150.64 v1(131.23,150.56) 131.97,149.82 PR542.2
CD_PBATT_OFF: length 2.6
  TOP w0.254: PU701.26 129.15,158.37 128.14,159.38 PR543.1
CFD_PWRBTN#_XDP: length 6.6
  TOP w0.102: RC107.2 v1(100,45.7) 98.99,45.7 97.33,47.36 JXDP1.41
CFG0: length 67.4
  TOP w0.102: JXDP1.9 93.93,39.36 93.82,39.25 92.65,39.25 v2(91.76,38.37) ; v2(122.41,71.23) 122.41,71.35 v1(122.83,71.77)
  IN1 w0.097: v2(91.76,38.37) 91,38.37 90.4,38.96 90.4,46.14 91.46,47.2 98.54,47.2 111.35,60.01 112.41,60.01 112.69,60.29 113.12,60.29 115.86,63.03 115.86,64.25 122.41,70.8 v2(122.41,71.23)
  BOTTOM w0.076: 126.84,71.58 126.85,71.58 126.86,71.59 128.29,71.59 128.61,71.91 129.09,71.91 129.32,71.67 129.7,71.67 129.87,71.84 130.65,71.84 130.69,71.8 131.17,71.8 UC1.AC60
  BOTTOM w0.102: v2(122.41,71.23) 122.41,71.54 RC232.1 122.64,71.87 122.92,71.58 126.84,71.58
CFG1: length 76.4
  TOP w0.102: JXDP1.11 93.87,39.86 v2(93.69,39.69) ; v1(120.73,72.4) 120.6,72.27 v2(120.17,72.27)
  IN1 w0.097: v2(120.17,72.27) 120.17,72.09 120.1,72.02 120.1,70.39 114.52,64.81 114.52,63.6 112.55,61.63 112.13,61.63 111.85,61.35 110.67,61.35 101.67,52.35 100.43,52.35 96.63,48.54 90.14,48.54 88.64,47.03 88.64,43.62 87.85,42.84 86.56,42.84 85.92,42.2 85.92,40.35 86.35,39.92 87.98,39.92 90.14,37.75 92.02,37.75 92.48,38.22 92.48,39.22 92.95,39.69 v2(93.69,39.69)
  BOTTOM w0.076: 126.84,71.81 128.27,71.81 128.53,72.07 129.15,72.07 129.39,71.84 129.63,71.84 129.93,72.13 UC1.AC62
  BOTTOM w0.102: RC233.1 119.73,72.65 120.05,72.33 120.11,72.33 v2(120.17,72.27) 120.25,72.35 122.51,72.35 122.75,72.59 123.86,72.59 124.63,71.81 126.84,71.81
CFG2: length 68
  TOP w0.102: v1(123.02,73.8) 123.52,73.29 v2(123.52,73.25) ; JXDP1.15 93.79,40.86 v2(93.69,40.96)
  IN1 w0.097: v2(123.52,73.25) 123.52,73.16 122.01,71.65 122.01,70.72 115.64,64.35 115.64,63.13 113.03,60.51 112.6,60.51 112.32,60.24 111.26,60.24 101.32,50.29 100.08,50.29 97.21,47.42 91.37,47.42 90.18,46.23 90.18,46.05 90.18,40.48 90.18,40.47 90.18,38.79 91,37.97 91.92,37.97 92.26,38.31 92.26,39.52 93.69,40.96 93.69,40.96 v2(93.69,40.96)
  BOTTOM w0.076: 126.84,72.05 128.26,72.05 128.45,72.24 129.4,72.24 UC1.AC63
  BOTTOM w0.102: 126.84,72.05 124.72,72.05 v2(123.52,73.25)
CFG3: length 84.5
  TOP w0.102: v3(91.72,41.76) 92.12,41.36 JXDP1.17 ; v3(104.82,57.42) 104.54,57.7 v1(103.6,57.7) RC99.2
  IN1 w0.097: v3(91.72,41.76) 91.08,42.41 91.08,45.38 91.42,45.72 98.18,45.72 111.8,59.34 112.69,59.34 112.97,59.62 113.4,59.62 116.53,62.76 116.53,63.98 123.28,70.73 123.28,71.19 124.68,72.58 125.14,72.58 125.43,72.87 125.73,72.87 v2(126.12,73.26)
  BOTTOM w0.076: UC1.AA63 129.38,72.88 129.24,72.73 128.17,72.73 128.16,72.73 126.84,72.73
  BOTTOM w0.102: v3(104.82,57.42) 104.82,52.44 94.99,42.61 92.22,42.61 91.72,42.11 v3(91.72,41.76) ; v2(126.12,73.26) 126.12,73.02 126.41,72.73 126.84,72.73
CFG3_R: length 14.1
  TOP w0.102: RC99.1 99.76,56.3 v1(98.58,56.3) 97.3,56.3 95.11,54.11 93.74,54.11 91.49,51.86 JXDP1.60
CFG4: length 57.4
  TOP w0.076: v1(132.21,72.22) 131.98,72.45 v2(131.77,72.45) 132.02,72.71 RC238.1
  TOP w0.102: v2(92.95,43.37) 93.45,43.86 JXDP1.27
  IN1 w0.097: v2(131.77,72.45) 131.23,72.99 130.93,72.99 129.89,71.94 125.82,71.94 125.49,71.61 124.98,71.61 124.3,70.94 124.3,70.43 119.22,65.35 119.22,63.11 117.49,61.38 117.15,61.38 115.25,59.48 114.52,59.48 113.77,58.73 113.34,58.73 113.06,58.45 112.17,58.45 97.52,43.8 93.39,43.8 v2(92.95,43.37)
  BOTTOM w0.076: UC1.AA60 131.46,72.8 131.77,72.5 v2(131.77,72.45)
CFG5: length 57
  TOP w0.076: v1(128.34,73.82) 128.07,73.56 v2(128.07,73.26)
  TOP w0.102: JXDP1.29 93.31,44.36 92.95,44 v2(91.84,44)
  IN1 w0.097: v2(128.07,73.26) 127.24,72.43 125.67,72.43 125.34,72.1 124.83,72.1 123.79,71.06 123.79,70.55 118.77,65.53 118.77,63.29 117.31,61.83 116.24,61.83 113.58,59.17 113.15,59.17 112.87,58.89 111.98,58.89 98.36,45.27 92.37,45.27 91.84,44.74 v2(91.84,44)
  BOTTOM w0.076: UC1.Y62 129.93,73.63 129.63,73.34 129.32,73.34 129.05,73.06 128.2,73.06 128.07,73.19 v2(128.07,73.26)
CFG6: length 55.4
  TOP w0.076: v2(130.51,74) 130.38,74 v1(130.06,74.32)
  TOP w0.102: JXDP1.33 93.35,45.36 v2(92.85,44.87)
  IN1 w0.097: v2(92.85,44.87) 93.28,44.44 97.84,44.44 112.07,58.67 112.97,58.67 113.24,58.95 113.68,58.95 116.33,61.6 117.4,61.6 118.99,63.2 118.99,65.44 124.04,70.49 124.04,71 124.89,71.84 125.4,71.84 125.75,72.2 128.82,72.2 130.51,73.89 v2(130.51,74)
  BOTTOM w0.076: v2(130.51,74) 130.81,73.7 UC1.Y61
CFG7: length 58.2
  TOP w0.102: v2(91.63,45.33) 92.17,45.86 JXDP1.35 ; v1(126.97,73.8) 127.42,73.34 v2(127.42,73.26)
  IN1 w0.097: v2(91.63,45.33) 91.81,45.5 98.27,45.5 111.89,59.12 112.78,59.12 113.06,59.4 113.49,59.4 116.14,62.05 117.21,62.05 118.55,63.38 118.55,65.44 118.55,65.62 123.54,70.61 123.54,71.12 124.74,72.33 125.25,72.33 125.57,72.65 127.06,72.65 127.42,73.01 v2(127.42,73.26)
  BOTTOM w0.076: UC1.Y60 131.17,73.3 130.69,73.3 130.65,73.34 129.87,73.34 129.7,73.17 129.39,73.17 129.12,72.9 127.71,72.9 127.42,73.19 v2(127.42,73.26)
CFG8: length 66.3
  TOP w0.102: v2(120.54,73.85) 120.8,73.85 v1(121.09,74.13) ; JXDP1.10 v2(90.97,39.36)
  IN3 w0.102: v2(90.97,39.36) 91.08,39.25 94.02,39.25 95.39,40.63 95.39,42.07 96.87,43.55 100.27,43.55 106.95,50.23 106.95,53.68 106.95,53.68 106.95,54.14 106.95,54.33 106.95,54.71 114.7,62.46 114.7,71.79 116.58,73.67 119.68,73.67 119.85,73.85 v2(120.54,73.85)
  BOTTOM w0.076: UC1.V62 129.71,73.92 129.39,73.92 129.33,73.85 126.96,73.85
  BOTTOM w0.102: 126.96,73.85 126.83,73.72 123.86,73.72 123.55,74.02 122.89,74.02 122.38,73.52 120.87,73.52 v2(120.54,73.85) 120.36,74.02 RC241.1
CFG9: length 74.2
  TOP w0.102: JXDP1.12 87.47,39.86 v3(87.09,39.48)
  IN1 w0.097: v2(122.72,74.79) 122.69,74.79 121.31,73.41 120.08,73.41 119.47,72.8 119.23,72.8 118.61,72.19 118.61,71.83 116.12,69.34 115.2,69.34 109,69.34 106.58,66.92 106.58,58.01 101.82,53.25 100.02,53.25 96.84,50.08 90.39,50.08 88.19,47.88 88.19,44.68 87.39,43.88 87.15,43.88 85.58,42.3 85.58,40.39 85.58,40.31 86.4,39.48 v3(87.09,39.48)
  BOTTOM w0.076: 127.16,74.1 127.23,74.03 129.09,74.03 129.14,74.08 129.61,74.08 129.81,74.28 129.81,74.41 130.05,74.65 130.58,74.65 UC1.V61
  BOTTOM w0.102: RC240.1 122.24,74.19 122.24,74.31 v2(122.72,74.79) 123.23,74.28 123.65,74.28 123.83,74.1 v1(124.98,74.1) 127.16,74.1
CFG10: length 65.9
  TOP w0.102: v2(87.09,40.42) v1(87.53,40.86) JXDP1.16
  IN1 w0.097: v2(131.16,74) 130.79,74.38 130.09,74.38 129.62,73.91 126.08,73.91 125.85,73.67 123.41,73.67 122.94,73.2 v2(122.94,73.19) 121.84,72.09 121.66,71.91 121.66,70.68 115.41,64.44 115.41,63.22 112.93,60.74 112.5,60.74 112.22,60.46 111.17,60.46 101.22,50.52 99.99,50.52 97.12,47.65 91.16,47.65 89.53,46.02 89.53,42.38 88.08,40.93 87.6,40.93 v2(87.09,40.42)
  BOTTOM w0.076: v2(131.16,74) 131.46,74.3 UC1.V60
  BOTTOM w0.102: v2(122.94,73.19) 122.69,72.94 RC239.1
CFG11: length 68.3
  TOP w0.102: JXDP1.18 86.78,41.36 v2(86.43,41.01) ; v1(126.28,75.28) 126,75.01 v2(126,74.78)
  IN1 w0.097: v2(86.43,41.01) 86.17,41.26 86.17,42.14 86.62,42.58 87.95,42.58 88.86,43.49 88.86,46.94 90.24,48.32 96.72,48.32 99.97,51.57 101.26,51.57 110.82,61.13 111.95,61.13 112.22,61.41 112.66,61.41 114.74,63.5 114.74,64.72 120.33,70.3 120.33,71.77 120.51,71.95 121.24,72.69 122.74,74.19 122.97,74.19 123.15,74.37 125.59,74.37 v2(126,74.78)
  BOTTOM w0.076: UC1.U60 131.17,74.8 130.69,74.8 130.65,74.83 129.87,74.83 129.7,74.67 129.32,74.67 129.11,74.88 128.79,74.88 128.11,74.2 127.32,74.2 127.16,74.35
  BOTTOM w0.102: 127.16,74.35 126.43,74.35 v2(126,74.78)
CFG12: length 65.9
  TOP w0.102: v2(87.19,43.34) 87.71,43.86 JXDP1.28 ; v1(123.31,75.26) 123.59,74.98 v2(123.59,74.82)
  IN1 w0.097: v2(87.19,43.34) 88.41,44.57 88.41,47.13 90.05,48.76 95.85,48.76 96.39,49.3 96.39,49.48 96.62,49.72 96.8,49.72 100.03,52.95 101.88,52.95 106.8,57.88 106.8,66.83 109.07,69.1 116.2,69.1 118.84,71.74 118.84,72.09 119.32,72.57 119.57,72.57 120.18,73.19 121.4,73.19 122.62,74.41 122.88,74.41 123.06,74.59 123.36,74.59 v2(123.59,74.82)
  BOTTOM w0.076: UC1.T63 126.88,75.88 126.84,75.83
  BOTTOM w0.102: v2(123.59,74.82) 124.55,75.78 126.78,75.78 126.84,75.83
CFG13: length 65.8
  TOP w0.102: v1(125,75.27) 125.42,74.85 v2(125.42,74.78) ; JXDP1.30 87.39,44.36 v2(87.32,44.44)
  IN1 w0.097: v2(87.32,44.44) 87.11,44.64 87.11,45.76 87.7,46.34 87.7,48.54 89.71,50.55 96.34,50.55 106.12,60.33 106.12,67.09 108.81,69.79 115.93,69.79 118.17,72.02 118.17,72.38 119.12,73.33 119.12,73.33 120.24,74.45 120.83,74.45 121.81,75.42 124.77,75.42 v2(125.42,74.78)
  BOTTOM w0.076: UC1.T62 129.72,75.43 129.71,75.43 129.7,75.42 128.62,75.42 128.42,75.22 126.84,75.22
  BOTTOM w0.102: 126.84,75.22 125.86,75.22 v2(125.42,74.78)
CFG14: length 65.3
  TOP w0.102: JXDP1.34 87.68,45.36 v2(87.54,45.5)
  IN1 w0.097: v2(124.19,74.81) 123.8,75.2 121.9,75.2 120.93,74.22 120.33,74.22 118.39,72.28 118.39,71.92 116.03,69.56 115.67,69.56 108.9,69.56 106.35,67.01 106.35,58.27 101.96,53.87 99.98,53.87 96.43,50.33 89.81,50.33 87.93,48.45 87.93,45.88 v2(87.54,45.5)
  BOTTOM w0.076: UC1.T61 130.56,76.17 130.04,76.17 129.81,75.93 129.81,75.75 129.63,75.58 127.45,75.58 v1(127.37,75.51) 126.95,75.51 126.89,75.45 126.84,75.45
  BOTTOM w0.102: v2(124.19,74.81) 124.84,75.45 126.84,75.45
CFG15: length 68.8
  TOP w0.102: v2(86.41,44.74) 86.41,44.74 86.44,44.77 v1(86.44,45.41) 86.44,45.62 87.23,46.4 87.85,46.4 88.39,45.86 JXDP1.36
  IN1 w0.097: v2(131.16,75.5) 130.79,75.12 128.5,75.12 128.36,75.26 125.95,75.26 125.56,75.64 121.71,75.64 120.74,74.67 120.14,74.67 117.94,72.47 117.94,72.11 115.84,70.01 108.72,70.01 105.86,67.15 105.86,60.39 96.25,50.78 89.62,50.78 87.42,48.57 87.42,46.47 86.41,45.46 v2(86.41,44.74)
  BOTTOM w0.076: UC1.T60 131.46,75.8 v2(131.16,75.5)
CFG16: length 62.8
  TOP w0.102: v1(124.34,73.81) 124.82,73.33 v2(124.82,73.25) ; JXDP1.6 90.51,38.36 91.54,39.39 v2(91.54,39.71)
  IN1 w0.097: v2(91.54,39.71) 90.63,40.63 90.63,46.05 91.56,46.98 98.63,46.98 111.45,59.79 112.5,59.79 112.78,60.07 113.21,60.07 116.09,62.94 116.09,64.16 122.83,70.9 122.83,71.36 124.71,73.25 v2(124.82,73.25)
  BOTTOM w0.076: UC1.AA62 130.11,72.82 130.1,72.82 129.69,72.4 128.35,72.4 128.22,72.27 126.84,72.27
  BOTTOM w0.102: v2(124.82,73.25) 124.82,73.06 125.61,72.27 126.84,72.27
CFG17: length 63.8
  TOP w0.102: v1(125.67,73.8) 125.47,73.6 v2(125.47,73.26) ; JXDP1.4 90.45,37.86 91.95,39.37 91.95,39.95 v2(91.6,40.31)
  IN1 w0.097: v2(91.6,40.31) 90.85,41.05 90.85,45.47 91.33,45.95 97.92,45.95 111.54,59.57 112.59,59.57 112.87,59.84 113.31,59.84 116.31,62.85 116.31,64.07 123.05,70.81 123.05,71.27 124.61,72.83 125.04,72.83 v2(125.47,73.26)
  BOTTOM w0.076: 126.84,72.5 128.17,72.5 128.24,72.57 129.62,72.57 129.87,72.82 129.87,73 130.04,73.17 130.56,73.17 UC1.AA61
  BOTTOM w0.102: 126.84,72.5 125.76,72.5 125.47,72.79 v2(125.47,73.26)
CFG18: length 64.7
  TOP w0.102: v2(86.58,41.82) v1(87.15,42.39) 87.62,42.86 JXDP1.24
  IN1 w0.097: v2(86.58,41.82) 87.19,41.21 88.04,41.21 89.31,42.48 89.31,46.76 90.42,47.87 97.03,47.87 99.9,50.74 101.13,50.74 111.07,60.68 112.13,60.68 112.41,60.96 112.84,60.96 115.19,63.31 115.19,64.53 120.77,70.11 120.77,71.59 120.82,71.64 121.56,72.37 122.93,73.74 123.16,73.74 123.32,73.9 125.75,73.9 125.99,74.13 127.2,74.13 127.84,74.78 v2(127.93,74.78)
  BOTTOM w0.076: UC1.U63 129.43,75.21 128.66,75.21 128.22,74.78 v2(127.93,74.78)
CFG19: length 63.7
  TOP w0.102: v2(127.3,74.78) 127.3,74.96 v1(127.61,75.27) ; JXDP1.22 87.92,42.36 v2(87.4,41.84)
  IN1 w0.097: v2(127.3,74.78) 127.3,74.74 126.91,74.35 125.89,74.35 125.66,74.13 123.23,74.13 123.07,73.96 122.84,73.96 120.55,71.68 120.55,70.21 114.97,64.62 114.97,63.4 112.75,61.19 112.32,61.19 112.04,60.91 110.98,60.91 101.04,50.96 99.8,50.96 96.93,48.09 90.33,48.09 89.08,46.85 89.08,43.26 88.15,42.33 87.88,42.33 v2(87.4,41.84)
  BOTTOM w0.076: v2(127.3,74.78) 127.71,74.36 128.04,74.36 128.72,75.05 129.18,75.05 129.39,74.83 129.63,74.83 129.93,75.13 UC1.U62
CFG_RCOMP: length 2.8
  TOP w0.076: RC235.1 129.95,73.38 v3(128.92,74.41) 128.95,74.44 v1(128.95,74.97)
  BOTTOM w0.076: UC1.V63 128.95,74.38 v3(128.92,74.41)
CHAGER_SRC:
  vias: v3(103.65,171.61) v3(103.65,170.95) v3(104.28,171.61) v3(104.28,170.95) v3(104.97,171.56) v3(104.97,170.93) v3(105.6,171.56) v3(105.6,170.93) v3(106.24,171.56) v3(106.26,170.93) v3(106.87,171.56) v3(106.9,170.93) v6(106.14,172.67)
CHARGE_EN: length 2.3
  TOP w0.102: U37.A45 194.33,117.93 194.02,117.61 v1(194.02,117.05) 194.02,116.12 R313.2
CHARGER_CELL_PIN: length 50.4
  TOP w0.102: PR431.2 121.53,163.11 v3(121.33,163.31) ; v2(150.56,152.51) v1(150.56,153.06)
  TOP w0.254: PR431.2 121.58,162.7 120.51,162.7 120.04,162.23 PU402.10 ; v2(150.56,152.51) 151.19,151.88 PD504.2
  IN1 w0.097: v2(150.56,152.51) 140.99,152.51 139.11,150.63 136.62,150.63 135.8,149.82 132.84,149.82 132.42,149.4 126.42,149.4 122.7,153.12 122.7,158.81 124.88,161 124.88,163.05 124.3,163.64 121.66,163.64 v3(121.33,163.31)
CHARGER_SMBCLK: length 72.6
  TOP w0.102: v2(162.25,127.58) 162.69,128.02 U38.B50 ; v3(123.64,162.14) 123.59,162.09 PR430.1 ; RP16.6 161.7,130.82 v3(161.87,130.64)
  IN1 w0.097: v2(162.25,127.58) 162.25,130.26 v3(161.87,130.64) 161.71,130.49 161.41,130.49 161.28,130.61 161.28,132.76 160.59,133.45 160.59,135.05 160.65,135.1 160.65,135.97 161.48,136.8 161.48,138.89 160.07,140.3 156.03,140.3 153.65,142.69 151.11,142.69 149.14,144.66 148.48,144.66 146.02,147.12 137.51,147.12 135.75,148.88 125.4,148.88 121.4,152.89 121.4,156.73 121.4,156.83 121.97,157.4 121.97,158.76 124.4,161.19 124.4,161.8 124.2,162.01 123.76,162.01 v3(123.64,162.14)
CHARGER_SMBDAT: length 71.6
  TOP w0.102: RP16.5 v1(161.2,130.42) 161.75,129.86 v2(161.87,129.86) 161.99,129.73 162.67,129.73 162.94,129.47 U38.A47 ; PR429.1 123.33,161.2 v3(123.64,161.5)
  IN1 w0.097: v2(161.87,129.86) 161.87,130.06 161.67,130.26 161.31,130.26 161.06,130.52 161.06,132.67 160.37,133.36 160.37,135.14 160.42,135.2 160.42,136.06 161.26,136.9 161.26,138.8 159.98,140.08 155.94,140.08 153.55,142.47 151.02,142.47 149.04,144.44 148.39,144.44 145.93,146.9 137.42,146.9 135.66,148.66 125.31,148.66 121.17,152.79 121.17,156.64 121.17,156.92 121.75,157.49 121.75,158.85 124.18,161.29 124.18,161.71 124.1,161.79 123.92,161.79 v3(123.64,161.5)
CHG_LGATE: length 20.1
  TOP w0.102: v3(107.99,181.32) 107.99,181.07 v6(108.26,180.8)
  IN1 w1.016: 109.9,181.14 110.51,180.53 110.51,170.57 116.6,164.48 116.63,164.48
  vias: v2(116.45,163.51) v2(116.45,162.88) v3(108.63,181.32)
CHG_UGATE: length 5.6
  TOP w0.102: v2(114.57,168.57) v1(115.28,168.57)
  IN2 w1.016: 114.52,167.55 114.52,162.7
  vias: v2(114.57,167.93) v2(115.12,161.67) v2(115.5,161.23)
CHGVR_DCIN: length 3.4
  TOP w0.102: PR530.2 125.66,152.64 126.24,152.06 v1(126.24,152.06)
  TOP w0.254: PR530.2 125.67,153.03 126.95,153.03 127.12,153.2 PU701.35
CIICSCL: length 5.7
  TOP w0.102: R2598.1 v1(124.54,120.56) 123.78,121.32 122.32,121.32 121.88,121.76 U52.13
CIICSDA: length 5.5
  TOP w0.102: U52.14 121.81,122.16 122.42,121.55 v1(125.5,121.55) 126.46,121.55 R2597.1
CLK_27M_IN: length 7.5
  TOP w0.102: R107.2 187.24,152.2 R66.1 186.94,153.4 v1(185.79,153.4) 184.17,153.4 182.92,154.65 181.64,154.65 181.49,154.8 U6.K1
CLK_27M_IN_R: length 3.9
  TOP w0.102: C42.1 189.3,152.75 Y1.1 ; C42.1 189.65,151.83 v1(189.65,151.29) ; C42.1 R107.1
CLK_27M_OUT: length 8.3
  TOP w0.102: Y1.3 187.62,154.87 C43.1 R66.2 185.9,154.01 v1(184.67,155.24) 182.43,155.24 U6.L1
CLK_BIASREF: length 12.7
  TOP w0.254: v2(152.8,84.85) 153.84,84.85 154.02,84.67 v1(154.4,84.67) 154.91,84.67 155.67,85.43 155.67,86.73 156.25,87.31 156.94,87.31 157.32,87.69 157.32,90.54 156.63,91.22 RC45.1
  BOTTOM w0.089: UC1.C26 152.86,83.17 152.98,83.28 152.99,83.28 153.16,83.46 153.16,83.47 153.19,83.5 153.19,83.67 153.13,83.74 153.13,84.13 153.03,84.23
  BOTTOM w0.254: 153.03,84.23 152.8,84.46 v2(152.8,84.85)
CLK_DDC2_CRT: length 165.8
  IN1 w0.097: v2(337.05,167.64) 331.44,167.64 330.77,166.97 317.03,166.97 316.76,167.24 307.89,167.24 307.45,167.68 285.21,167.68 283.83,166.3 262.34,166.3 261.47,167.18 249.7,167.18 249.25,167.63 248.91,167.98 225.38,167.98 222.42,170.93 216.11,170.93 210.97,165.8 202.39,165.8 202.16,165.57 192.04,165.57 190.74,166.86 188.26,166.86 186.43,168.69 182.79,168.69 182.58,168.91 v3(182.18,168.91)
  BOTTOM w0.102: v2(337.05,167.64) 338.24,166.45 JIO1.48 ; v3(182.18,168.91) 182.23,168.95 183.24,168.95
CLK_DDC2_DOCK: length 21.8
  IN3 w0.102: v2(177.08,180.02) 177.01,179.95 177.01,179.42 176.77,179.18 176.77,176.2 177.03,175.95 177.03,174.94 177.94,174.03 178.69,174.03 178.94,174.28 v2(179.8,174.28)
  BOTTOM w0.102: v2(177.08,180.02) 177.08,180.13 178.36,181.41 178.36,181.81 178.45,181.9 178.88,181.9 178.98,182 178.98,182.33 178.86,182.46 178.58,182.46 178.45,182.59 JDOCK1.48 ; v2(179.8,174.28) 179.8,174 181.37,172.43 181.37,169.68 181.71,169.35 U39.15
CLK_KBD: length 69.3
  TOP w0.102: RP4.8 168.15,134.54 168.16,134.53 v3(168.16,134.12) ; U38.A38 167.44,129.48 167.8,129.83 v2(167.8,130.26)
  IN1 w0.097: v2(167.8,130.26) 167.96,130.26 168.42,130.72 168.42,132.12 168.67,132.37 168.67,133.62 v3(168.16,134.12) 168.16,135.44 169.15,136.43 169.15,147.44 169.98,148.27 169.98,149.84 169.51,150.31 169.51,154.67 168.55,155.64 168.55,157.32 168.87,157.65 168.87,158.49 169.76,159.38 169.76,163.92 170.68,164.84 170.68,168.29 176.91,174.52 176.91,175.53 178,176.62 179.08,177.69 180.25,177.69 180.44,177.51 180.93,177.51 181.11,177.7 181.11,178.19 180.79,178.51 v2(180.79,179.89)
  BOTTOM w0.102: JDOCK1.78 186.95,183.83 186.9,183.79 186.9,183.12 183.68,179.89 v2(180.79,179.89)
CLK_MSE: length 65
  TOP w0.102: RP4.7 167.65,133.9 v3(168.16,133.39) ; v2(167.78,130.91) 167.07,130.2 167.07,129.61 166.94,129.48 U38.A39
  IN1 w0.097: v2(180.64,177.99) 180.45,178.17 178.88,178.17 177.53,176.82 176.43,175.73 176.43,174.73 170.21,168.5 170.21,165.04 169.29,164.12 169.29,159.58 168.39,158.68 168.39,157.85 168.07,157.52 168.07,155.44 168.32,155.19 168.32,154.62 169.03,153.91 169.03,150.12 169.51,149.64 169.51,148.47 168.57,147.53 168.57,137.6 167.66,136.69 167.66,133.9 v3(168.16,133.39) 168.16,132.54 167.94,132.31 167.94,131.07 v2(167.78,130.91)
  BOTTOM w0.102: v2(180.64,177.99) 180.66,177.96 184.9,177.96 185.45,177.42 JDOCK1.71
CLK_PCI_5048: length 128.7
  TOP w0.102: RC61.2 RC184.2 214.42,57.68 217.06,60.32 v6(217.06,64.25) 215.89,65.42 v2(215.89,66.1) ; v3(215.33,93.97) 214,95.29 214,99.32 214.98,100.29 214.98,105.74 207.86,112.86 192.64,112.86 192.26,113.25 188.89,113.25 188.42,113.72 185.49,113.72 181.17,118.05 181.17,121.93 182.23,122.99 183.11,122.99 R324.1 184.78,122.51 185.4,121.89 U37.A28
  IN3 w0.102: v3(215.33,93.97) 214.49,93.13 214.49,88.03 214.6,87.92 215.99,87.92 216.09,87.82 216.09,87.42 215.99,87.31 214.6,87.31 214.49,87.21 214.49,86.81 214.6,86.7 215.99,86.7 216.09,86.6 216.09,86.2 215.99,86.1 214.6,86.1 214.49,85.99 214.49,85.59 214.6,85.49 215.99,85.49 216.09,85.38 216.09,84.98 215.99,84.88 214.6,84.88 214.49,84.77 214.49,84.37 214.6,84.27 215.99,84.27 216.09,84.16 216.09,83.76 215.99,83.66 214.6,83.66 214.49,83.56 214.49,83.15 214.6,83.05 215.99,83.05 216.09,82.95 216.09,82.54 215.99,82.44 214.6,82.44 214.49,82.34 214.49,81.93 214.6,81.83 215.99,81.83 216.09,81.73 216.09,81.32 215.99,81.22 214.6,81.22 214.49,81.12 214.49,80.71 214.6,80.61 215.99,80.61 216.09,80.51 216.09,80.1 215.99,80 214.6,80 214.49,79.9 214.49,79.49 214.6,79.39 215.99,79.39 216.09,79.29 216.09,78.88 215.99,78.78 214.6,78.78 214.49,78.68 214.49,78.27 214.6,78.17 215.99,78.17 216.09,78.07 216.09,77.66 215.99,77.56 214.6,77.56 214.49,77.46 214.49,67.5 v2(215.89,66.1)
CLK_PCI_DOCK: length 184.5
  TOP w0.102: v2(169.71,55.95) 169.57,56.09 RC64.2 ; R273.1 198.67,177.33 v2(198.67,178.12)
  IN1 w0.097: v2(169.71,55.95) 170.72,54.94 174.73,54.94 177.66,52.01 195.73,52.01 198.85,55.14 198.85,55.69 200.07,56.91 202.75,56.91 203.71,57.86 203.71,58.81 207.05,62.16 207.05,64.86 205.91,66 205.91,73.67 203.24,76.34 203.24,79.4 202.9,79.74 202.9,81.28 203.85,82.23 203.85,84.42 200.16,88.11 199.29,88.11 198.54,88.86 198.54,88.95 198.17,89.32 198.17,97.6 197.24,98.54 197.24,100.4 196.96,100.68 196.96,103.74 203.35,110.13 203.35,110.79 208.49,115.93 208.49,126.84 208.14,127.19 208.14,132.56 207.82,132.88 207.82,134.2 v3(204.78,137.24)
  IN3 w0.102: v3(204.78,137.24) 206.54,139 206.54,139.73 206.78,139.98 206.78,143.09 205.83,144.05 205.83,150.43 206.26,150.86 206.26,151.83 204.13,153.96 204.13,162.98 202.91,164.2 202.91,167.09 203.37,167.55 203.37,171.39 203.81,171.83 203.81,177.74 202.9,178.65 202.56,178.65 202.1,179.11 199.03,179.11 198.67,178.75 v2(198.67,178.12)
  BOTTOM w0.102: v2(198.67,178.12) 198.67,177.86 198.95,177.58 JDOCK1.121
CLK_PCI_FBIN: length 4.3
  TOP w0.102: v6(203.93,52.87) CC23.1 RC100.2 204.52,54.9 204.78,54.65 UC5.8
CLK_PCI_LPDEBUG: length 259.2
  TOP w0.102: RC66.2 168.16,52.67 v6(170.16,50.67) 173.24,47.59 207.52,47.59 209.16,49.22 209.16,50.15 210.29,51.28 211.84,51.28 212.21,51.65 214.2,51.65 215.07,52.52 v2(215.07,53.51) ; R244.1 316.68,187.36 318.71,185.33 v3(318.91,185.33)
  IN3 w0.102: v2(215.07,53.51) 214.76,53.82 214.76,58.91 216.17,60.32 216.17,65.14 214.01,67.3 214.01,94.14 214.75,94.88 218.51,94.88 221.44,97.81 221.44,99.43 225.28,103.26 225.28,113.24 225.63,113.6 225.63,116.72 226.57,117.66 226.57,121.69 228.46,123.58 228.46,124.14 238.01,133.68 240.4,133.68 242.01,135.29 248.13,135.29 258.87,146.02 259.81,146.02 260.55,146.76 263.27,146.76 263.28,146.77 263.29,146.77 269.63,153.11 272.23,153.11 279.24,160.12 290.51,160.12 292.05,161.66 293.12,161.66 295.38,163.92 295.38,165.11 303.67,173.4 308.17,173.4 318.91,184.15 v3(318.91,185.33)
CLK_PCI_MEC: length 125.9
  TOP w0.102: v3(206.23,60.36) 205.84,60.74 202.53,60.74 200.89,59.11 200.89,57.91 201.8,57.01 202.61,57.01 RC187.2 RC63.2 ; U38.A29 171.97,125.89 171.99,125.91 172,125.91 173.19,127.1 173.19,128.06 173.59,128.46 174.46,128.46 R382.1 175.2,128.18 175.91,128.18 176.14,128.41 176.14,129.86 176.54,130.26 177.19,130.26 177.51,129.94 177.51,127.09 176.77,126.35 176.77,125.67 176.98,125.47 176.98,124.36 179.47,121.87 179.47,118.27 v1(180.58,117.16) 184.99,112.75 188.02,112.75 188.52,112.25 191.89,112.25 192.32,111.82 207.53,111.82 214.01,105.34 214.01,101.08 210.43,97.5 206.95,97.5 205.48,96.03 v3(205.04,96.03)
  IN3 w0.102: v3(206.23,60.36) 206.23,60.63 206.56,60.96 206.56,67 207.28,67.73 207.28,75.3 206.16,76.41 206.16,83.07 205.86,83.38 205.86,95.39 205.22,96.03 v3(205.04,96.03)
CLK_PCI_TPM_TCM: length 141.5
  TOP w0.102: U25.21 181.35,134.63 R290.1 180.64,133.92 180.64,133.79 180.53,133.69 180.53,132.46 179.34,131.27 179.34,128.7 179.42,128.62 179.42,123.91 179.97,123.36 179.97,118.53 185.27,113.24 188.22,113.24 188.73,112.74 192.09,112.74 192.52,112.31 207.73,112.31 214.49,105.54 214.49,100.88 213.52,99.91 213.52,94.53 214.87,93.18 v3(215.28,93.18) ; v2(218.08,59.47) 217.92,59.63 v6(217.36,59.63) 217.1,59.36 217.1,58.04 215.94,56.88 215.94,56.65 215.61,56.32 215.61,55.56 214.19,54.14 RC58.2 213.93,54.13 RC182.2
  IN3 w0.102: v3(215.28,93.18) 215.28,91.15 215.38,91.05 216.59,91.05 216.72,90.92 216.72,90.56 216.59,90.44 215.38,90.44 215.28,90.33 215.28,89.93 215.38,89.83 216.61,89.83 216.74,89.7 216.74,89.34 216.61,89.22 215.38,89.22 215.28,89.11 215.28,88.71 215.41,88.58 216.6,88.58 216.73,88.45 216.73,77.01 216.63,76.91 215.08,76.91 214.98,76.8 214.98,76.4 215.08,76.3 216.63,76.3 216.73,76.19 216.73,75.79 216.63,75.69 215.08,75.69 214.98,75.58 214.98,75.18 215.08,75.08 216.63,75.08 216.73,74.98 216.73,74.57 216.63,74.47 215.08,74.47 214.98,74.37 214.98,73.96 215.08,73.86 216.63,73.86 216.73,73.76 216.73,73.35 216.63,73.25 215.08,73.25 214.98,73.15 214.98,72.74 215.08,72.64 216.63,72.64 216.73,72.54 216.73,72.13 216.63,72.03 215.08,72.03 214.98,71.93 214.98,71.52 215.08,71.42 216.63,71.42 216.73,71.32 216.73,70.95 216.6,70.83 215.12,70.83 214.99,70.7 214.99,70.33 215.12,70.2 216.6,70.2 216.73,70.08 216.73,68.87 218.08,67.52 v2(218.08,59.47)
CLK_PCIE_EXP: length 4.6
  TOP w0.102: RC200.2 92.28,15.64 92.28,16 v3(92.09,16.18) 92.26,16.35 92.26,16.64 92.5,16.89 92.98,16.89 93.18,17.09 93.18,17.16 93.06,17.28 JEXP1.18
  BOTTOM w0.102: RC200.2 92.23,15.59 92.23,16.04 v3(92.09,16.18)
CLK_PCIE_EXP#: length 4.6
  TOP w0.102: RC164.2 92.54,15.56 92.54,16 v3(92.73,16.18) 92.52,16.39 92.52,16.53 92.61,16.62 v3(92.88,16.62) 93.09,16.62 93.44,16.98 93.44,17.17 93.56,17.29 JEXP1.16
  BOTTOM w0.102: RC164.2 92.5,15.61 92.5,15.95 v3(92.73,16.18)
CLK_PCIE_FMC: length 140.8
  IN3 w0.086: v2(235.7,145.88) 235.51,145.69 234.29,145.69 232.16,143.56 232.16,142.29 231.71,141.85 228.95,141.85 226.81,139.71 218.26,139.71 216.64,138.09 210.99,138.09 205.73,132.83 205.73,121.03 198.5,113.8 192.09,113.8 192.03,113.75 187.36,113.75 187.01,113.4 181.74,113.4 177.2,108.86 175.99,108.86 174.65,108.86 169.91,104.12 165.97,104.12 165.62,104.47 151.38,104.47 150.88,103.97 147.07,103.97 143.91,100.81 143.91,100.52 143.77,100.38 143.54,100.38 v3(143.31,100.61)
  BOTTOM w0.076: UC1.C37 145.91,83.41 145.61,83.71 145.61,85.41 144.2,86.82 144.2,88.79 144.25,88.84 144.25,88.86
  BOTTOM w0.102: 144.25,88.86 144.25,91.34 143.17,92.42 143.17,98.77 144.15,99.74 144.15,100.15 143.83,100.47 143.45,100.47 v3(143.31,100.61) ; JMINI2.13 234.77,146.1 235.14,145.73 235.55,145.73 v2(235.7,145.88)
CLK_PCIE_FMC#: length 140.4
  IN3 w0.086: v3(143.32,99.96) 143.54,100.17 143.85,100.17 144.12,100.43 144.12,100.72 147.16,103.77 150.97,103.77 151.47,104.27 165.53,104.27 165.89,103.91 170,103.91 174.74,108.66 175.9,108.66 177.29,108.66 181.82,113.19 187.1,113.19 187.45,113.54 192.12,113.54 192.17,113.6 198.59,113.6 205.94,120.95 205.94,132.74 211.07,137.88 216.72,137.88 218.35,139.5 226.9,139.5 229.03,141.64 231.8,141.64 232.37,142.2 232.37,143.47 234.38,145.49 235.44,145.49 v3(235.7,145.22)
  BOTTOM w0.076: UC1.B38 145.18,83.58 145.05,83.7 145.05,83.81 145.13,83.88 145.35,83.88 145.44,83.97 145.44,85.34 144.03,86.75 144.03,88.79 143.98,88.84 143.98,88.86
  BOTTOM w0.102: 143.98,88.86 143.98,91.23 142.9,92.31 v3(142.9,94.75) 142.9,98.88 143.88,99.86 143.88,100.04 143.72,100.2 143.57,100.2 v3(143.32,99.96) ; JMINI2.11 234.94,145.3 235.11,145.46 235.46,145.46 v3(235.7,145.22)
CLK_PCIE_LAN: length 101
  TOP w0.102: v2(182.99,147.64) 183.09,147.74 183.09,148.1 183.34,148.36 v3(190.92,148.36) 195.38,148.36 195.49,148.47 U21.44 ; v2(142.34,101.87) 142.47,101.74 142.47,101.46 142.12,101.1 142.12,97.56 142.11,97.55 142.11,97.55 141.95,97.39 141.95,95.95 RC49.2
  IN3 w0.086: v2(142.34,101.87) 142.5,102.02 142.5,105.98 143.42,106.9 145.81,106.9 146.68,106.03 152.05,106.03 152.27,105.81 159.14,105.81 159.14,105.81 162.19,105.81 162.19,105.81 166.36,105.81 166.36,105.81 169.73,105.81 174.2,110.27 174.84,110.27 180.27,115.7 180.27,122.12 179.59,122.81 179.59,138.45 182.71,141.58 182.71,146.02 183.1,146.4 183.1,147.53 183,147.64 v2(182.99,147.64)
CLK_PCIE_LAN#: length 100.7
  TOP w0.102: v2(183.57,147.64) 183.51,147.64 183.35,147.79 183.35,147.99 183.45,148.09 v3(187.21,148.09) 195.46,148.09 195.49,148.07 U21.45 ; RC48.2 142.22,95.95 142.22,97.28 142.22,97.28 142.38,97.44 142.38,100.99 142.74,101.35 142.74,101.68 v2(142.93,101.87)
  IN3 w0.086: v2(142.93,101.87) 142.83,101.87 142.72,101.98 142.72,105.9 143.51,106.69 145.72,106.69 146.6,105.82 151.96,105.82 152.19,105.6 158.93,105.6 158.93,105.6 162.39,105.6 162.39,105.6 166.15,105.6 166.15,105.6 169.82,105.6 174.29,110.06 174.93,110.06 180.48,115.62 180.48,122.21 179.79,122.9 179.79,138.37 182.92,141.49 182.92,145.93 183.31,146.32 183.31,147.39 183.56,147.64 v2(183.57,147.64)
CLK_PCIE_MINI2: length 217.4
  TOP w0.102: RC60.2 144.5,92.68 144.5,93.85 143.68,94.67 143.68,98.36 144.03,98.72 144.03,100.5 144.39,100.85 148.68,100.85 149.05,101.22 149.05,101.68 v2(149.19,101.81)
  IN3 w0.086: v2(306.56,186.47) 306.42,186.32 306.42,185.47 303.38,182.43 299.49,182.43 289.29,172.23 281.27,172.23 276.57,167.52 273.29,167.52 263.46,157.69 263.1,157.69 261.3,157.69 260.42,156.81 256.81,156.81 254.8,156.81 249.19,151.2 249.19,148.26 244.42,143.49 235.46,143.49 232.18,140.21 229.57,140.21 227.6,138.25 220.08,138.25 218.16,136.33 213.02,136.33 210.28,133.59 210.28,132.21 206.75,128.69 206.75,120.8 198.8,112.85 187.76,112.85 187.29,112.38 181.97,112.38 177.57,107.98 176.31,107.98 175.35,107.02 174.66,107.02 170.85,103.21 165.29,103.21 164.94,103.56 155.88,103.56 155.14,102.83 149.69,102.83 149.01,102.15 149.01,101.99 v2(149.19,101.81)
  BOTTOM w0.102: JMINI1.13 306.7,187.24 306.47,187.01 306.47,186.58 306.46,186.57 v2(306.56,186.47)
CLK_PCIE_MINI2#: length 217.6
  TOP w0.102: v2(148.61,101.81) 148.78,101.64 148.78,101.33 148.57,101.12 144.28,101.12 143.77,100.61 143.77,98.83 143.41,98.47 143.41,94.56 144.24,93.74 144.24,92.78 RC59.2
  IN3 w0.086: v2(305.98,186.47) 306.21,186.24 306.21,185.55 303.29,182.64 299.41,182.64 289.2,172.43 281.19,172.43 276.48,167.73 273.2,167.73 263.37,157.9 261.21,157.9 260.33,157.02 256.72,157.02 254.71,157.02 248.98,151.29 248.98,148.34 244.34,143.7 235.37,143.7 232.1,140.42 229.48,140.42 227.51,138.45 219.99,138.45 218.08,136.54 212.93,136.54 210.07,133.68 210.07,132.3 206.54,128.77 206.54,120.89 198.71,113.06 187.68,113.06 187.21,112.59 181.89,112.59 177.48,108.19 176.22,108.19 175.27,107.23 174.58,107.23 170.77,103.42 165.38,103.42 165.02,103.77 155.79,103.77 155.06,103.03 149.61,103.03 148.8,102.23 148.8,102.01 v2(148.61,101.81)
  BOTTOM w0.102: v2(305.98,186.47) 306.2,186.69 306.2,186.99 305.9,187.29 JMINI1.11
CLK_PCIE_MMI: length 211.8
  TOP w0.102: RC54.2 142.2,91.09 142.2,90.65 142.64,90.21 142.64,89.09 142.37,88.82 142.17,88.82 v3(141.88,88.53)
  IN1 w0.097: v2(26.05,21.45) 25.82,21.68 25.64,21.68 23.57,19.61 23.57,19.07 22.64,18.14 16.39,18.14 10.88,23.64 10.88,45.44 31.24,65.8 34.52,65.8 37.08,68.36 54.5,68.36 56.23,66.63 65.37,66.63 71.23,60.77 74.18,60.77 75.65,59.3 77.78,59.3 80.46,56.63 95.34,56.63 97.93,59.22 97.93,61.62 102.65,66.34 102.65,68.76 102.68,68.79 102.68,68.8 107.01,73.12 107.49,73.12 107.86,73.49 112.78,73.49 116.27,76.97 117.37,76.97 118.18,77.78 121.41,77.78 122.54,78.91 126.8,78.91 128.62,80.73 131.57,80.73 133.33,82.49 133.74,82.49 133.94,82.7 137.59,82.7 140.73,85.84 141.7,85.84 142.38,86.52 142.38,88.65 142.25,88.78 142.13,88.78 v3(141.88,88.53)
  BOTTOM w0.102: v2(26.05,21.45) 26.05,21.6 25.81,21.84 25.72,21.84 25.57,21.99 25.09,21.99 24.27,22.81 24.27,23.05 24.19,23.13 U27.3
CLK_PCIE_MMI#: length 212.3
  TOP w0.102: v3(141.88,89.29) 142.08,89.09 142.26,89.09 142.37,89.2 142.37,90.1 141.93,90.53 141.93,91.09 RC53.2
  IN1 w0.097: v2(26.04,22.72) 26.04,22.2 25.78,21.94 25.54,21.94 23.31,19.72 23.31,19.18 22.53,18.4 16.49,18.4 11.15,23.75 11.15,45.33 31.35,65.54 34.62,65.54 37.19,68.1 54.39,68.1 56.13,66.37 65.26,66.37 71.12,60.51 74.08,60.51 75.54,59.04 77.67,59.04 80.35,56.37 95.45,56.37 98.19,59.11 98.19,61.51 102.91,66.23 102.91,68.65 102.94,68.69 106.7,72.45 107.12,72.86 107.6,72.86 107.97,73.22 112.89,73.22 116.38,76.71 117.48,76.71 118.29,77.52 121.52,77.52 122.65,78.65 126.9,78.65 128.72,80.47 131.68,80.47 133.44,82.23 133.85,82.23 134.05,82.43 137.48,82.43 137.7,82.43 139.56,84.29 140.84,85.58 141.81,85.58 142.64,86.41 142.64,88.76 142.35,89.04 142.13,89.04 v3(141.88,89.29)
  BOTTOM w0.102: U27.2 24.59,23.15 24.54,23.1 24.54,22.92 25.2,22.26 25.68,22.26 25.83,22.11 26.28,22.11 26.41,22.24 26.41,22.59 26.28,22.72 v2(26.04,22.72)
CLK_PEG_VGA: length 26.9
  TOP w0.102: RC179.2 59.52,78.52 59.52,78.23 59.23,77.94 58.54,77.94 57.65,78.83 57.46,78.83 57.29,78.65 v4(57.29,78.64)
  IN1 w0.097: v5(65.61,91.13) 65.74,91.27 66.04,91.27 66.3,91.53 67.53,91.53 67.77,91.29 67.77,90.77 66.56,89.56 66.56,87.34 65.68,86.45 62.5,86.45 59.68,83.63 58.51,83.63 57.65,82.76 57.65,82.51 56.53,81.39 56.53,79.14 56.81,78.87 57.06,78.87 v4(57.29,78.64)
  BOTTOM w0.1: 65.32,90.97 65.19,90.84 UV1.AE8
  BOTTOM w0.102: v5(65.61,91.13) 65.48,91.13 65.32,90.97
CLK_PEG_VGA#: length 27
  TOP w0.102: RC157.2 59.26,78.52 59.26,78.34 59.12,78.21 58.65,78.21 57.76,79.09 57.46,79.09 57.29,79.27 v4(57.29,79.28)
  IN1 w0.097: v4(57.29,79.28) 57.29,79.27 57.14,79.13 56.92,79.13 56.79,79.25 56.79,81.28 57.91,82.4 57.91,82.65 58.62,83.37 59.79,83.37 62.61,86.19 65.78,86.19 66.83,87.23 66.83,89.45 68.03,90.66 68.03,91.4 67.64,91.79 66.19,91.79 65.93,91.53 65.73,91.53 65.61,91.65 v5(65.61,91.92)
  BOTTOM w0.102: UV1.AD8 65.23,91.5 65.59,91.5 65.68,91.58 65.68,91.85 v5(65.61,91.92)
CLK_TP_SIO: length 45.2
  TOP w0.102: v2(168.93,130.43) 168.72,130.43 v1(168.44,130.14) 168.44,130 167.94,129.51 U38.A37 ; R444.1 148.53,104.68 v3(148.58,104.64)
  IN3 w0.102: v2(150,116.88) 150.16,117.03 150.16,117.71 152.31,119.87 152.31,124 154.03,125.72 154.7,125.72 155,125.41 157.29,125.41 158.23,124.47 158.85,124.47 158.93,124.55 161.64,124.55 161.94,124.85 163.36,124.85 163.74,125.23 163.74,125.72 164.05,126.02 165.67,126.02 166.41,126.76 166.41,127.92 v2(168.93,130.43)
  BOTTOM w0.102: v2(150,116.88) 150.18,116.7 150.18,115.36 150.51,115.03 150.51,111.25 150.51,111.25 150.51,110.26 150.51,108.98 149.99,108.46 149.99,106.65 148.81,105.47 148.81,104.84 148.61,104.64 v3(148.58,104.64)
CLKA0: length 47.5
  TOP w0.102: v2(35.79,106.96) 35.54,106.71 35.54,106.63 35.19,106.29 34.55,106.29 34.49,106.24 33.75,106.24 33.42,105.91 33.42,105.6 UV5.J7
  IN1 w0.097: v2(34.56,111.92) 34.56,111.91 34.36,111.7 34.36,111.02 33.86,110.52 33.2,110.52 32.74,110.06 32.74,109.27 33.29,108.72 34.06,108.72 35,107.77 35.32,107.77 35.57,107.52 35.57,107.18 v2(35.79,106.96) 35.57,106.74 35.5,106.74 35.03,106.26 33.76,106.26 32.78,105.28 32.78,103.83 33.86,102.76 37.98,102.76 38.72,103.49 38.72,104.33 42.64,108.25 44.05,108.25 44.14,108.35 44.14,108.73 44.35,108.93 44.78,108.93 44.98,108.73 44.98,108.35 45.08,108.25 45.37,108.25 45.47,108.35 45.47,108.73 45.67,108.93 46.1,108.93 46.3,108.73 46.3,108.35 46.4,108.25 46.69,108.25 46.79,108.35 46.79,108.5 47.02,108.73 47.39,108.73 47.62,108.5 47.62,108.35 47.72,108.25 51.46,108.25 51.53,108.31 v5(51.53,108.53)
  BOTTOM w0.102: UV4.J7 33.49,108.67 33.49,108.51 33.54,108.46 33.79,108.46 33.91,108.33 34.4,108.33 35.49,107.25 35.49,106.97 35.61,106.85 35.68,106.85 v2(35.79,106.96) ; v2(34.56,111.92) 34.36,112.11 34.36,112.71 RV2706.1 34.75,113.15 RV2707.2
  BOTTOM w0.122: v5(51.53,108.53) 51.55,108.51 51.55,108.51 51.92,108.14 UV1.D24
