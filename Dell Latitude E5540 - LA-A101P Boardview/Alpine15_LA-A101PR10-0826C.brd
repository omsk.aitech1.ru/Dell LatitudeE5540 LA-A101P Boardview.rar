# Allegro board Alpine15_LA-A101PR10-0826C.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_B_MA15: length 100.6
  IN3 w0.076: 133.95,54.67 133.95,55.37 137.29,58.71 137.29,59.56 137.47,59.75 137.47,63.53 138.09,64.15 139.07,64.15 139.42,64.49 139.42,65.06 v2(139.85,65.49)
  IN3 w0.152: 133.95,54.67 133.95,42.71 161.61,15.05 186.73,15.05 189.09,17.41 189.09,20.4 v2(188.58,20.92)
  BOTTOM w0.076: v2(139.85,65.49) 140.15,65.49 UC1.AP46
  BOTTOM w0.152: JDIMM2.78 187.98,20.32 v2(188.58,20.92)
DDR_B_RAS#: length 103.1
  IN3 w0.076: 147.01,58.38 147.15,58.52 147.15,64.19 147.38,64.42 147.38,66.31 v2(147.02,66.66)
  IN3 w0.152: 147.01,58.38 147.01,56.57 146.73,56.29 146.73,47.21 159.71,34.23 191.31,34.23 193.1,32.43 193.1,32.22 192.74,31.86 192.74,31.52 193.04,31.22 193.04,30.49 193.38,30.16 194.02,30.16 195.63,28.55 196.4,28.55 196.76,28.18 196.76,26.96 198.37,25.35 198.37,23.76 197.86,23.25 197.86,19.24 197.7,19.09 195.95,19.09 195.8,18.93 195.8,18.35 195.65,18.2 195.29,18.2 195.14,18.35 195.14,19.65 195.29,19.8 197.17,19.8 197.32,19.95 197.32,21.8 197.17,21.95 v2(196.88,21.95)
  BOTTOM w0.076: UC1.AM35 147.35,66.99 v2(147.02,66.66)
  BOTTOM w0.152: JDIMM2.110 197.58,21.26 v2(196.88,21.95)
DDR_B_WE#: length 101.6
  IN3 w0.076: v2(147,67.96) 147.59,67.37 147.59,64.47 148.08,63.99 148.08,60.78 147.83,60.54 147.71,60.54 147.36,60.19 147.36,57.56 147.38,57.54
  IN3 w0.152: v2(199.53,23.34) 198.87,22.68 198.87,18.1 198.71,17.94 198.44,17.94 198.29,18.1 198.29,23.03 198.87,23.61 198.87,25.5 197.2,27.16 197.2,28.36 196.58,28.98 195.91,28.98 193.53,31.37 193.53,32.61 191.48,34.66 159.89,34.66 147.16,47.39 147.16,55.91 147.38,56.14 147.38,57.54
  BOTTOM w0.076: v2(147,67.96) 147.32,68.29 UC1.AK35
  BOTTOM w0.152: JDIMM2.113 198.48,24.38 199.52,23.34 v2(199.53,23.34)
DDR_CKE0_DIMMA: length 60
  IN1 w0.14: v2(141.42,63.58) 141.83,63.17 141.83,58.51 139.92,56.6 139.11,56.6 137.91,55.41 137.42,55.41 136.21,54.2 136.21,53.09 131.97,48.86 131.97,48.66 132.94,47.69 132.94,47.46 132.77,47.3 132.54,47.3 131.58,48.26 131.38,48.26 131.18,48.07 131.18,47.87 131.34,47.71 131.34,47.51 131.14,47.32 130.94,47.32 130.78,47.47 130.59,47.47 111.13,28.02 111.13,27.4 111.27,27.26 111.48,27.26 111.62,27.12 111.62,26.84 111.48,26.7 111.27,26.7 111.13,26.56 111.13,26.28 111.27,26.14 111.48,26.14 111.62,26 111.62,25.72 111.48,25.58 111.27,25.58 111.13,25.44 111.13,25 111.27,24.86 v2(111.62,24.86)
  BOTTOM w0.076: v2(141.42,63.58) 141.57,63.58 UC1.AU43
  BOTTOM w0.152: v2(111.62,24.86) 111.98,25.22 JDIMM1.73
DDR_CKE1_DIMMA: length 58.3
  IN1 w0.14: v2(141.41,62.28) 140.97,61.83 140.97,58.87 139.5,57.41 139.06,57.41 137.57,55.92 137.35,55.92 135.79,54.35 135.79,53.71 135.79,53.71 135.79,53.27 110.71,28.19 110.71,22.44 111.18,21.97 111.18,20.88 v2(112.28,19.79)
  BOTTOM w0.076: v2(141.41,62.28) 141.42,62.28 141.72,62.58 UC1.AW43
  BOTTOM w0.152: JDIMM1.74 v2(112.28,19.79)
DDR_CKE2_DIMMB: length 86.1
  IN3 w0.076: 139.36,58.2 139.36,58.97 v2(139.85,59.46)
  IN3 w0.152: 139.36,58.2 138.29,57.14 138.29,56.32 137.4,55.43 137.01,55.04 137.01,44.98 142.51,39.48 142.51,38.57 162.95,18.13 183.28,18.13 184.57,19.42 184.57,21.67 185.84,22.94 v2(185.84,23.38)
  BOTTOM w0.076: UC1.AY49 138.67,60.75 139.85,59.57 v2(139.85,59.46)
  BOTTOM w0.152: v2(185.84,23.38) 186.48,24.01 JDIMM2.73
DDR_CKE3_DIMMB: length 86.4
  IN3 w0.076: v2(138.41,58.51) 138.41,58.08 137.87,57.54 137.87,56.51 136.61,55.24 136.61,54.67
  IN3 w0.152: v2(185.83,20.1) 185.83,20.61 185.65,20.79 185.3,20.79 185.12,20.61 185.12,19.39 183.45,17.72 162.75,17.72 142.08,38.39 142.08,39.3 136.61,44.78 136.61,54.67
  BOTTOM w0.076: v2(138.41,58.51) 137.83,59.1 137.83,60.91 137.39,61.35 137.39,62.03 137.41,62.08 137.41,62.08 137.46,62.19 137.46,62.32 137.39,62.47 137.39,62.68 137.41,62.73 137.45,62.82 137.46,62.83 137.46,63.59 UC1.AU50
  BOTTOM w0.152: v2(185.83,20.1) 186.17,20.1 186.78,19.5 JDIMM2.74
DDR_CS0_DIMMA#: length 61.6
  IN1 w0.076: v2(147.97,65.43) 148.45,64.95 148.45,64.15 149.09,63.51 149.09,54.06
  IN1 w0.14: v2(125.21,19.79) 126.28,20.86 126.28,24.36 127.81,25.89 132.39,25.89 134.1,27.6 134.1,28.69 149.09,43.68 149.09,54.06
  BOTTOM w0.076: v2(147.97,65.43) 148.24,65.69 UC1.AP33
  BOTTOM w0.152: v2(125.21,19.79) 124.42,19.79 124.28,19.65 JDIMM1.114
DDR_CS1_DIMMA#: length 62.3
  IN1 w0.076: 149.57,54.06 149.57,54.37 149.44,54.49 149.44,64.19 v2(148.93,64.71)
  IN1 w0.14: v2(126.7,24.1) 126.7,24.18 127.91,25.39 134.51,25.39 137.11,27.99 137.11,31.01 145.71,39.61 145.91,39.61 146.65,38.87 146.85,38.87 147.05,39.07 147.05,39.26 146.3,40.01 146.3,40.2 146.5,40.4 146.7,40.4 147.59,39.51 147.79,39.51 147.99,39.71 147.99,39.9 147.09,40.8 147.09,40.99 149.57,43.47 149.57,54.06
  BOTTOM w0.076: UC1.AR32 149.25,65.04 v2(148.93,64.71)
  BOTTOM w0.152: JDIMM1.121 126.38,24.43 v2(126.7,24.1)
DDR_CS2_DIMMB#: length 92.6
  IN3 w0.076: v2(148.93,66.66) 149.31,66.28 149.31,64.51 148.8,64.01 148.8,59.22 148.99,59.03 148.99,57.82 149.09,57.72 149.09,57.54
  IN3 w0.152: 149.09,57.54 149.09,56.08 148.99,55.98 148.99,55.97 148.68,55.66 148.68,48.02 160.09,36.61 192.92,36.61 200.68,28.86 200.68,22.54 201.23,21.98 201.23,20.44 201.08,20.29 v2(199.53,20.29)
  BOTTOM w0.076: v2(148.93,66.66) 149.25,66.99 UC1.AM32
  BOTTOM w0.152: JDIMM2.114 198.78,19.54 v2(199.53,20.29)
DDR_CS3_DIMMB#: length 92
  IN3 w0.076: 149.36,59.01 149.36,64.3 149.47,64.41 149.47,67.39 v2(148.9,67.96)
  IN3 w0.132: 149.36,59.01 149.36,56.04
  IN3 w0.152: 149.36,56.04 149.36,55.61 149.11,55.36 149.11,48.2 160.27,37.04 193.1,37.04 201.11,29.04 201.11,26 202.02,25.08 202.02,22.87 201.87,22.72 201.26,22.72 201.11,22.87 201.11,24.85 v2(201.23,24.97)
  BOTTOM w0.076: UC1.AK32 149.23,68.29 v2(148.9,67.96)
  BOTTOM w0.152: JDIMM2.121 200.88,25.33 v2(201.23,24.97)
DDR_PG_CTRL: length 237.6
  TOP w0.102: v3(116.48,14.79) 117.57,14.79 121.03,11.33 138.5,11.33 139.2,10.63 149.02,10.63 149.72,11.33 184.03,11.33 184.1,11.31 192.3,11.31 192.37,11.33 221.72,11.33 226.99,16.6 226.99,16.6 227.4,17 227.4,17 229.73,19.34 v1(229.73,20.37) R34.2 229.82,26 U5.2
  IN1 w0.097: v3(87.27,36.99) 84.23,33.96 84.23,20.1 87.05,17.28 89.68,17.28 90.06,16.9 90.06,15.85 90.42,15.49 91.55,15.49 91.84,15.77 92.97,15.77 93.2,16 93.2,17.16 93.75,17.72 98.8,17.72 99.56,16.95 99.56,16.65 100.46,15.75 115.52,15.75 v3(116.48,14.79)
  BOTTOM w0.076: 128.26,61.99 128.41,62.14 128.41,62.7 129.26,63.55 130.29,63.55 130.34,63.5 UC1.AV61
  BOTTOM w0.305: 128.26,61.99 126.91,60.64 122.19,60.64 98.21,36.66 87.6,36.66 v3(87.27,36.99)
DDR_XDP_SMBCLK_R1: length 6.8
  TOP w0.102: JXDP1.53 96.41,50.36 96.54,50.24 97.37,50.24 99.01,51.88 99.28,51.88 v3(99.76,51.88) 100.83,51.88 RC112.2
DDR_XDP_SMBDAT_R1: length 6.8
  TOP w0.102: JXDP1.51 96.4,49.86 96.55,50.01 v3(97.18,50.01) 97.46,50.01 99.1,51.65 99.19,51.65 100.83,51.65 RC111.2
DDR_XDP_WAN_SMBCLK: length 534.4
  TOP w0.102: U15.4 218.72,124.51 218.85,124.64 218.85,126.34 R123.2 218.56,127.11 218.56,127.93 218.76,128.13 220.49,128.13 v3(220.62,128.01) ; v4(185.36,89.04) 185.56,88.84 185.56,88.3 186.38,87.49 188.46,87.49 188.98,86.97 188.98,77.01 187.88,75.92 QC1.1 ; R2598.2 127.8,120.89 128.64,120.89 130.55,118.97 148.37,118.97 v2(148.46,118.88) ; v3(108.77,54.3) 108.21,54.3 107.61,53.71 105.63,53.71 103.8,51.88 102.4,51.88 RC112.1 ; v3(215.92,140.78) 216.17,141.03 216.31,141.03 216.87,140.47 218.09,140.47 228.11,140.47 229.2,141.56 237.11,141.56 237.27,141.72 238.85,141.72 240.59,139.98 244.91,139.98 246.52,141.59 246.52,147.64 249.16,150.28 249.16,151.47 247.89,152.74 247.89,153.14 248.02,153.27 248.31,153.27 v2(248.55,153.03)
  IN1 w0.097: v3(215.92,140.78) 216.15,141.01 216.37,141.01 216.48,140.9 216.48,136.39 220.21,132.66 220.21,128.42 v3(220.62,128.01) 220.87,127.76 220.87,125.99 220.56,125.68 220.56,121.16 220.56,121.15 220.56,119.87 218.71,118.02 215.2,118.02 200.67,103.5 200.67,91.17 v3(199.28,89.78) ; v3(224.7,16.47) 224.5,16.26 224.5,15.9 224,15.4 211.58,15.4 209.54,17.44 195.41,17.44 194.92,16.95 179.99,16.95 179.69,17.25 162.86,17.25 159.86,20.26 153.78,20.26 153.38,20.66 152.61,20.66 152.4,20.45 v2(152.03,20.45)
  IN3 w0.102: v2(148.46,118.88) 148.61,119.04 149.37,119.04 151.11,120.78 151.11,125.75 151.3,125.94 151.3,126.85 154.41,129.96 156.86,129.96 159.4,132.5 159.4,133.39 160.49,134.48 167,134.48 168.24,135.72 170.81,135.72 172.02,136.94 172.02,139.21 173.55,140.74 175.72,142.9 175.73,142.92 175.73,145.23 176.06,145.55 177.69,145.55 v3(177.89,145.35) ; v2(152.03,20.45) 152.31,20.74 153.08,20.74 153.38,20.43 153.38,19.16 152.24,18.02 119.26,18.02 117.1,20.18 117.1,29.2 113.78,32.52 113.78,49 108.77,54.01 v3(108.77,54.3) ; v3(199.28,89.78) 199.28,89.57 198.9,89.19 193.89,89.19 193.23,89.85 185.99,89.85 185.61,89.47 185.61,89.29 v4(185.36,89.04) 185.39,89.04 185.56,88.86 185.56,88.3 187.14,86.73 187.14,85.59 187.49,85.24 189.3,85.24 192.12,82.43 192.12,77.44 194.14,75.41 195.44,75.41 197.7,73.15 197.7,69.84 200.3,67.25 200.3,62.75 201.45,61.6 201.74,61.6 201.88,61.45 202.55,61.45 204.59,59.42 204.59,58.48 204.96,58.11 205.89,58.11 207.13,56.87 207.13,56.87 209.11,54.9 209.11,54.22 210.66,52.67 210.66,52.11 212.31,50.46 212.31,49.24 216.88,44.67 216.88,43.58 218.3,42.16 218.3,40.52 222.01,36.82 223.34,36.82 228.62,31.54 228.62,27.73 228.97,27.38 228.97,26.24 228.59,25.87 228.59,18.25 225.8,15.45 224.93,15.45 224.48,15.91 224.48,16.24 v3(224.7,16.47)
  BOTTOM w0.102: v3(224.7,16.47) 224.7,16.66 225.18,17.13 JDIMM2.202 ; v2(152.03,20.45) 151.81,20.67 150.54,20.67 150.48,20.61 150.48,19.57 150.68,19.38 JDIMM1.202 ; R218.2 246.19,156.15 246.61,156.15 247.31,155.44 247.31,153.56 247.66,153.21 248.37,153.21 v2(248.55,153.03) ; v3(215.92,140.78) 215.74,140.95 212.25,140.95 209.28,137.98 189.87,137.98 189.68,137.98 189.26,138.4 187.38,140.28 186.35,141.31 184.01,141.31 179.77,145.55 178.1,145.55 v3(177.89,145.35)
DDR_XDP_WAN_SMBDAT: length 539.9
  TOP w0.102: v3(108.33,53.8) 108.08,53.8 107.76,53.48 105.72,53.48 103.9,51.65 102.4,51.65 RC111.1 ; v2(148.46,119.47) 148.19,119.2 130.65,119.2 128.73,121.12 127.8,121.12 R2597.2 ; v3(186,89.04) 185.88,88.93 185.88,88.31 186.47,87.72 188.59,87.72 189.2,87.1 189.2,76.92 188.18,75.89 188.18,74.21 186.9,72.94 186.15,72.94 185.93,73.15 QC1.4 ; U15.6 216.6,125.88 216.67,125.94 216.68,125.94 216.7,125.97 216.7,126.55 216.75,126.61 R122.2 218.33,127.16 218.33,128.02 218.67,128.36 220.33,128.36 v3(220.62,128.64) ; v3(215.89,141.41) 216.04,141.26 216.4,141.26 216.96,140.7 218.19,140.7 218.19,140.7 228.01,140.7 229.1,141.79 237.02,141.79 237.18,141.95 238.95,141.95 240.69,140.21 244.81,140.21 246.29,141.69 246.29,147.74 248.94,150.38 248.94,151.38 247.67,152.65 247.67,153.24 247.93,153.5 248.44,153.5 v2(248.55,153.61)
  IN1 w0.097: v3(199.87,89.54) 199.87,90.05 200.9,91.08 200.9,103.41 215.29,117.8 218.8,117.8 220.79,119.78 220.79,121.06 220.79,121.06 220.79,125.59 221.09,125.89 221.09,128.17 v3(220.62,128.64) 220.44,128.82 220.44,132.75 216.7,136.49 216.7,140.99 216.47,141.23 216.07,141.23 v3(215.89,141.41) ; v2(152.03,21.09) 152.4,21.09 152.61,20.88 153.48,20.88 153.88,20.48 159.95,20.48 162.96,17.48 179.78,17.48 180.08,17.18 194.83,17.18 195.32,17.66 209.64,17.66 211.67,15.63 223.91,15.63 224.27,15.99 224.27,16.32 v3(224.07,16.52)
  IN3 w0.102: v3(224.07,16.52) 224.25,16.34 224.25,15.82 224.84,15.23 225.89,15.23 228.82,18.16 228.82,25.77 229.2,26.14 229.2,27.47 228.84,27.82 228.84,31.63 223.43,37.04 222.11,37.04 218.53,40.62 218.53,42.25 217.11,43.67 217.11,44.77 212.54,49.34 212.54,50.56 210.9,52.2 210.9,52.75 209.34,54.32 209.34,54.99 205.99,58.34 205.05,58.34 204.82,58.58 204.82,59.51 203.13,61.2 202.65,61.68 201.98,61.68 201.83,61.83 201.54,61.83 200.52,62.85 200.52,67.35 197.93,69.94 197.93,73.25 195.54,75.64 194.24,75.64 192.34,77.53 192.34,82.52 189.4,85.47 187.58,85.47 187.37,85.69 187.37,86.82 185.79,88.4 185.79,88.83 v3(186,89.04) 185.84,89.19 185.84,89.38 186.09,89.62 193.14,89.62 193.18,89.58 193.8,88.96 199.29,88.96 v3(199.87,89.54) ; v3(108.33,53.8) 108.66,53.8 113.55,48.9 113.55,32.42 116.87,29.1 116.87,20.09 119.17,17.79 152.33,17.79 153.61,19.07 153.61,20.53 153.17,20.97 152.15,20.97 v2(152.03,21.09) ; v2(148.46,119.47) 148.66,119.26 149.27,119.26 150.88,120.87 150.88,125.85 151.07,126.04 151.07,126.94 154.32,130.19 156.77,130.19 159.17,132.59 159.17,133.48 160.4,134.71 166.9,134.71 168.15,135.95 170.71,135.95 171.8,137.04 171.8,139.31 175.5,143.01 175.5,145.33 175.96,145.78 177.69,145.78 v3(177.89,145.99)
  BOTTOM w0.102: R219.2 246.11,156.37 246.7,156.37 247.54,155.54 247.54,153.66 247.76,153.44 248.37,153.44 v2(248.55,153.61) ; JDIMM2.200 224.58,17.03 v3(224.07,16.52) ; v2(152.03,21.09) 151.84,20.9 150.45,20.9 150.25,20.71 150.25,19.48 150.26,19.48 150.08,19.3 JDIMM1.200 ; v3(177.89,145.99) 178.1,145.78 179.87,145.78 184.11,141.54 186.45,141.54 187.61,140.37 189.42,138.57 189.77,138.21 209.19,138.21 212.15,141.18 215.66,141.18 v3(215.89,141.41)
DEVICE_DET#: length 141.7
  TOP w0.102: U38.B1 162.19,118.7 162.02,118.53 161.61,118.53 161.51,118.43 161.51,117.94 161.84,117.61 162.32,117.61 162.57,117.36 v3(162.57,116.52) RP17.2
  IN2 w0.102: v3(162.57,116.52) 163,116.09 165.35,116.09 167.18,114.26 167.64,114.26 168.35,113.55 168.35,112.68 170.14,110.9 172.12,110.9 173.48,109.53 176.95,109.53 180.75,105.74 180.75,103.89 181.2,103.44 182.74,103.44 v3(183.66,102.53)
  BOTTOM w0.102: v3(183.66,102.53) 189.25,102.53 190.63,101.15 194.94,101.15 196.15,99.94 196.15,98.27 199.93,94.5 200.46,93.97 200.46,93.97 200.99,93.43 204.64,93.43 208.07,90 210.24,90 210.8,89.45 219.65,89.45 221.02,88.07 221.02,87.88 221.02,83.09 225.9,78.22 226.16,78.22 227.98,76.4 227.98,71.13 227.13,70.28 v1(227.13,68.16) 227.13,61.46 232.88,55.71 232.88,39.25 232.27,38.65 232.27,35.29 232.73,34.84 234.05,34.84 235.26,36.04 JSATA2.8
DGPU_CORE_EN: length 340.4
  TOP w0.102: RC305.2 176.55,96.05 177.13,95.46 v2(177.13,95.03)
  IN2 w0.076: v2(165.73,76.78) 166.01,77.06 166.01,77.21 166.19,77.39 167.05,77.39
  IN2 w0.102: v2(177.13,95.03) 177.13,93.15 175.76,91.78 174.74,91.78 170.88,87.92 170.88,80.89 170.68,80.68 170.68,79.42 168.65,77.39 167.05,77.39 ; v3(65.93,22.52) 66.34,22.11 75.62,22.11 77.26,20.47 77.26,17.85 79.99,15.12 113.94,15.12 116.82,12.24 138.38,12.24 140.45,10.17 150.26,10.17 152.24,12.15 226.25,12.15 230.52,16.42 230.52,23.74 229.53,24.73 229.53,31.77 212.13,49.17 212.13,50.38 210.68,51.83 210.68,52.35 209,54.04 208.81,54.04 208.81,54.04 208.13,54.04 207.05,55.11 207.05,55.22 202.73,59.54 199.97,59.54 198.03,61.47 198.03,63.61 198.92,64.5 198.92,67.83 199.79,68.69 199.79,73.57 203.09,76.87 203.09,79.83 200.38,82.53 200.38,83.14 198.92,84.6 198.92,85.12 198.25,85.8 198.25,88.72 197.96,89.02 197.96,95.29 194.45,98.79 194.45,99.83 v3(193.59,100.7)
  IN3 w0.102: v3(193.59,100.7) 191.1,100.7 189.7,99.3 183.85,99.3 180.63,96.07 179.47,96.07 178.38,96.07 177.87,95.57 177.62,95.57 177.13,95.07 v2(177.13,95.03)
  BOTTOM w0.076: v2(165.73,76.78) 165.51,76.56 UC1.R5
  BOTTOM w0.102: v3(65.93,22.52) 65.93,25.61 65.6,25.95 v1(65.6,30.25) 65.6,32.57 65.27,32.9 62.44,32.9 PR627.2
DGPU_HOLD_RST#: length 135.6
  IN1 w0.097: v3(96.57,79.96) 96.57,80.79 97.17,81.39 99.15,81.39 99.54,81.78 107.58,81.78 108.73,80.63 112.53,80.63 112.69,80.79 112.91,81.02 115.24,83.34 115.24,83.79 119.42,87.97 132.88,87.97 135.15,90.24 135.15,92.03 137.44,94.32 138.69,94.32 143.36,99 145.96,99 146.19,98.77 155.74,98.77 156.28,99.3 156.29,99.3 156.53,99.54 156.53,99.55 157.39,100.42 160.08,100.42 160.91,99.59 164.13,99.59 164.59,100.06 165.7,100.06 165.91,100.27 170.53,100.27 171.29,101.02 174.92,101.02 v3(175.96,99.99)
  IN2 w0.102: v3(172.94,77.86) 172.94,77.94 172.53,78.35 172.53,78.88 173.27,79.62 173.27,80.31 174.07,81.11 178.04,81.11 180.92,83.99 180.92,88.13 180.28,88.77 180.28,96.71 179.64,97.34 178.6,97.34 v3(175.96,99.99)
  IN3 w0.102: v3(172.94,77.86) 172.94,77.41 170.63,75.1 v2(170.63,73.95)
  BOTTOM w0.076: UC1.Y3 167.08,73.31 167.61,73.31 167.85,73.56 167.85,73.68 168.04,73.88 168.3,73.88 168.32,73.9 168.32,73.9 168.58,74.15 168.58,74.16 168.78,74.36 v1(170.32,74.36) 170.63,74.05 v2(170.63,73.95)
  BOTTOM w0.102: UV14.1 v3(96.57,79.96) ; v3(172.94,77.86) 173.12,78.04 174.23,78.04 174.34,78.15 RP9.6
DGPU_PEX_RST#: length 80.2
  TOP w0.102: RV2427.2 69.37,91.77 70.59,91.77 70.73,91.63 71.77,91.63 71.77,91.63 71.85,91.63 72.13,91.35 v3(72.13,89.99) 72.13,89.83 71.77,89.47 71.77,82.08 69.99,80.3 69.99,78.52 69.15,77.68 v1(67.62,77.68) 66.86,77.68 64.05,74.88 64.05,71.06 v3(64.56,70.55)
  IN1 w0.097: v3(64.56,70.55) 66.92,70.55 68.02,69.46 75.52,69.46 78.88,72.82 78.88,73.39 80.71,75.22 87.65,75.22 89.42,77 92.27,77 94.43,79.16 v3(97.17,79.16)
  BOTTOM w0.102: R346.1 77.65,98.72 72.13,93.19 v3(72.13,89.99) ; v3(97.17,79.16) 97.41,78.92 UV14.4 97.87,78.4 97.65,78.18 RV29.1
DGPU_PEX_RST_R#: length 4.3
  TOP w0.102: v1(68.88,92.37) 68.88,92.21 68.52,91.86 68.52,91.81 68.04,91.33 RV2427.1 67.47,91.33 v2(67.29,91.15)
  BOTTOM w0.102: v2(67.29,91.15) 67.29,91.76 67.09,91.96 66.41,91.96 UV1.AC7
DGPU_PWR_EN: length 254.7
  IN1 w0.076: v2(155.97,81.62) 154.58,81.62 154.14,82.05
  IN1 w0.097: v3(57.04,82.63) 55.45,81.04 51.1,81.04 48.61,83.53 36.11,83.53 34.99,84.64 27.24,84.64 23.23,88.66 23.23,93.36 24.3,94.42 24.3,98.79 25.19,99.68 25.19,100.9 24.55,101.54 24.55,104.32 23.1,105.77 v3(23.1,112.79) ; v3(146.78,85.81) 147.89,85.81 149.09,84.62 151.58,84.62 154.14,82.05
  IN3 w0.076: 169.38,78.22 169.33,78.22 167.53,76.41 166.13,76.41 166.06,76.35 165.35,76.35 165.31,76.39 163.41,76.39 163.4,76.38 163.4,76.38 163.08,76.06 162.35,76.06
  IN3 w0.102: 169.38,78.22 171.44,78.22 v2(172.25,77.41) ; 162.35,76.06 161.17,76.06 159.78,77.45 159.78,78.04 159.53,78.29 158.11,78.29 156.61,79.79 156.38,79.79 155.57,80.61 155.57,81.22 v2(155.97,81.62) ; v3(146.78,85.81) 146.55,86.04 145.19,86.04 144.99,86.24 132.76,86.24 130,83.48 127.48,83.48 123.56,79.56 120.4,79.56 118.66,77.81 118.66,76.64 117.84,75.82 112.91,75.82 111.3,74.21 110.6,74.21 106.89,74.21 106.59,73.92 106.59,73.06 106.44,72.91 105.02,72.91 104.82,72.71 104.82,71.35 104.44,70.98 99.39,70.98 98.83,71.54 97.48,71.54 97.28,71.74 95.17,73.85 85.56,73.85 84.22,75.19 84.08,75.32 68.14,75.32 64.98,78.48 64.98,81.13 v3(63.33,82.78)
  BOTTOM w0.076: UC1.L3 167.08,77.81 169.61,77.81 169.7,77.9 170.49,77.9 170.78,78.19
  BOTTOM w0.102: QV2806.2 27.6,119.87 27.32,120.15 24.68,120.15 23.1,118.58 v3(23.1,112.79) ; R155.1 87.19,80.94 86.73,80.48 86.73,78.88 86.43,78.57 86.43,77.05 84.73,75.35 77.99,75.35 v1(77.03,76.31) 71.9,81.44 64.66,81.44 v3(63.33,82.78) 63.3,82.75 57.17,82.75 v3(57.04,82.63) ; 170.78,78.19 170.93,78.35 171.57,78.35 171.9,78.02 171.9,77.76 v2(172.25,77.41) 172.43,77.23 173.26,77.23 173.36,77.33 176.05,77.33 176.48,76.9 RC306.2
DGPU_PWROK: length 418.5
  TOP w0.102: v3(181.03,79.36) 181.46,78.93 182.2,78.93 182.73,78.39 RP11.6 ; v3(198.87,124.47) 199.35,124.47 R354.2 198.52,123.99 197.92,123.39 U37.A56
  IN1 w0.097: v3(216.78,65.82) 216.78,65.62 217.55,64.85 217.55,62.13 212.61,57.2 210.79,57.2 208.64,55.05 208.64,52.89 v3(208.97,52.56)
  IN2 w0.102: v3(198.87,124.47) 199.76,123.58 199.76,118.8 200.63,117.93 200.63,115.42 201.33,114.71 201.33,109.79 203.39,107.73 203.39,105.25 204.23,104.41 204.23,100.11 206.7,97.65 206.7,88.73 209.59,85.84 209.59,84.36 214.19,79.76 214.19,71.76 214.08,71.65 213.81,71.38 213.66,71.23 213.48,71.05 213.48,71.05 213.48,70.29 213.48,70.29 213.48,70.03 213.48,68.51 213.48,68.51 213.48,67.76 214.01,67.22 214.01,67.22 214.47,66.76 216.81,66.76 216.96,66.61 216.96,66 v3(216.78,65.82) ; v3(83.46,26.22) 83.05,25.82 73.42,25.82 72.71,25.11 65.17,25.11 65.17,25.11 64.68,25.11 63.41,23.84 60.98,23.84 60.65,24.17 51.45,24.17 48.81,26.81 48.81,29.89 v2(50.67,31.76)
  IN3 w0.102: v2(38.35,28.48) 38.35,30.01 38.98,30.64 50.05,30.64 50.67,31.26 v2(50.67,31.76) ; v3(83.46,26.22) 83.46,25.58 84.5,24.54 84.5,20.28 85.84,18.93 91.61,18.93 92.64,17.91 93.2,17.91 94.37,16.73 94.37,16.56 95.67,15.25 114.01,15.25 116.42,12.84 138.91,12.84 139.91,11.84 145.42,11.84 146.36,12.79 201.57,12.79 201.7,12.92 203.75,14.97 221.66,14.97 222.9,16.22 222.9,16.85 223.18,17.13 225.18,17.13 226.99,18.94 226.99,20.84 226.63,21.2 226.63,22.68 227.17,23.21 227.17,26.1 227.62,26.55 227.62,29.23 226.63,30.21 226.63,31.49 217.82,40.31 217.82,40.93 215.42,43.33 215.42,44.49 208.65,51.26 208.65,51.83 208.97,52.15 v3(208.97,52.56) 208.97,52.64 202.75,58.86 202.75,59.53 201.78,60.49 201.48,60.49 201.33,60.63 201.05,60.63 200.66,61.02 198.67,61.02 198.19,61.51 196.18,61.51 195.86,61.18 195.25,61.18 194.91,61.52 194.91,61.93 193.56,63.28 192.37,63.28 191.73,63.92 183.61,63.92 181.75,65.77 181.75,68.04 180.95,68.85 179.9,68.85 178.63,70.12 178.63,71.13 v2(178.4,71.36) 178.33,71.36 176.87,72.81 176.87,74.15 177.76,75.04 178.15,75.04 179.37,76.26 179.77,76.26 179.99,76.48 179.99,77.14 179.71,77.42 179.71,78.02 181.03,79.33 v3(181.03,79.36)
  BOTTOM w0.076: UC1.P4 166.4,76.55 166.78,76.17 166.96,76.17 166.98,76.14 167.8,76.14 167.95,76.29 168.26,76.29 168.36,76.39 170.04,76.39 170.57,75.86 170.78,75.86
  BOTTOM w0.102: 170.78,75.86 172.99,75.86 173.42,75.42 175.35,75.42 176.86,73.92 176.86,73.82 178.4,72.27 v2(178.4,71.36)
  BOTTOM w0.254: v2(38.35,28.48) 37.44,28.48 PR709.1 ; PR633.2 51.18,32.71 v1(50.85,32.38) 50.67,32.2 v2(50.67,31.76)
DH_1.35V: length 9
  TOP w1.016: 42.64,14.69 42.82,14.87 47.21,14.87 49.47,17.13 50.64,17.13
  vias: v2(40.91,14.64) v2(41.42,15.15) v2(52.49,17.44) v2(52.49,16.8) v6(51.55,16.7)
DIS_BAT_PROCHOT#: length 81.1
  TOP w0.102: PR514.1 v1(146.32,135.55) v3(145.56,134.78) ; U37.B51 196.45,119.05 196.61,118.88 v3(196.62,118.88)
  IN1 w0.097: v3(196.62,118.88) 194.38,118.88 193.49,117.99 193.49,116.76 193.08,116.34 192.19,116.34 191.54,115.7 190.07,115.7 189.61,115.23 182.62,115.23 179.95,112.56 178.46,112.56 175.64,109.73 170.92,109.73 170.44,109.25 164.74,109.25 164.46,109.54 155.05,109.54 151.17,113.42 151.17,114.32 146.07,119.42 146.07,134.28 v3(145.56,134.78)
DISP_ON: length 87.1
  TOP w0.102: v3(92.22,146.8) 92.12,146.9 92.12,152.31 94.76,154.95 JLVDS1.12 ; D80.1 141.11,109.87 140.85,109.6 v1(139.7,109.6) 139.07,109.6 138.75,109.92 R2581.1 139.41,111.34 v3(139.41,112.15)
  IN1 w0.097: v3(92.22,146.8) 91.79,146.37 91.79,144.66 97.7,138.75 97.7,133.36 102.19,128.87 102.19,126.68 113.92,114.95 136.62,114.95 v3(139.41,112.15)
DK_AC_OFF: length 2.5
  TOP w0.254: PD511.2 129.35,159 129.65,158.69 PU701.25
DK_AC_OFF_EN: length 2.2
  TOP w0.254: PR546.1 131.57,159.25 131.15,158.83 PU701.22
DK_CSS_GC: length 25.2
  TOP w0.254: v3(122.01,155.97) 121.78,155.73 v1(121.78,155.35) PR417.2 PR418.2 120.97,152.61 120.73,152.61 120.14,152.03 120.14,151.58 ; PU701.11 134.18,153.2 134.7,152.68 v2(134.7,152.34) ; PQ403.1 120.14,151.58 ; 120.14,151.58 120.02,151.45 120.02,150.06 120.39,149.68 PQ403.3
  BOTTOM w0.254: v3(122.01,155.97) 122.01,155.45 122.86,154.6 124.63,154.6 126.89,152.34 v2(134.7,152.34)
DK_PWRBAR: length 2.3
  TOP w0.254: PR531.1 125.79,154.81 126.4,154.2 PU701.33
DL_1.35V: length 6
  IN2 w1.016: 40.4,16.39 40.49,16.3 42.73,16.3 43.25,15.79 46.14,15.79
  vias: v1(47.01,15.33) v2(39.36,16.29) v2(39.78,16.76) v2(46.55,16.17) v2(47.16,16.17)
DMIC0: length 264.5
  TOP w0.102: R2595.2 CE11.1 107.2,158.3 v3(106.92,158.02) ; v3(176.62,142.56) 175.53,143.65 163.51,143.65 162.14,142.28 161.23,142.28 160.22,141.26 154.3,141.26 v1(153.81,141.75) 152.64,142.91 152.64,149.87 151.83,150.69 151.83,152.19 151.12,152.9 151.12,153.99 v3(150.97,154.14)
  IN3 w0.102: v3(150.97,154.14) 150.97,151.07 149.37,149.47 144.67,149.47 140.5,145.3 137.79,145.3 133.63,141.15 114.77,141.15 110.02,145.9 v3(110.02,151.55)
  BOTTOM w0.102: v3(110.02,151.55) 110.15,151.68 110.15,153.76 106.92,156.99 v3(106.92,158.02) ; v3(176.62,142.56) 177.08,142.1 177.08,141.03 179.31,138.8 186.1,138.8 193.16,131.74 196.23,131.74 198.39,133.9 204.51,133.9 205.36,133.04 206.07,133.04 206.92,133.9 211.39,133.9 215.72,138.22 230.73,138.22 231.11,137.85 231.11,135.75 232.75,134.1 234.11,134.1 234.92,134.91 239.93,134.91 239.93,134.91 240.35,134.91 240.36,134.91 240.82,134.91 244.32,138.42 264.07,138.42 273.9,148.25 283.02,148.25 285.05,150.28 291.89,150.28 295.16,153.55 295.16,157.64 296.61,159.09 296.61,160.08 298.19,161.66 306.47,161.66 306.87,161.25 306.87,161.17 306.78,161.07 306.78,159.36 306.87,159.27 306.87,157.66 307.23,157.3 U17.4
DMIC0_R: length 8.8
  TOP w0.102: R2595.1 105.68,158.99 D77.2 101.57,158.99 101.13,159.42 101.13,160.31 100.9,160.54 v1(100.7,160.54) 100.47,160.54 99.88,159.95 JLVDS1.2
DMIC1: length 25.1
  TOP w0.102: JPWR1.7 311.75,167.85 310.18,166.28 v6(310.18,163.79) v3(308.93,162.55)
  IN1 w0.097: v3(303.72,155.71) 303.88,155.87 310.56,155.87 312.13,157.44 312.13,159.65 309.24,162.55 v3(308.93,162.55)
  BOTTOM w0.102: v3(303.72,155.71) 303.72,155.59 304.58,154.73 U17.46
DMIC_CLK0: length 252.9
  TOP w0.102: v3(150.92,155.13) 151.6,154.44 151.6,153.1 152.31,152.39 152.31,150.89 153.13,150.07 v1(153.13,145.63) 153.13,143.19 154.58,141.74 160.02,141.74 161.03,142.76 161.94,142.76 163.31,144.13 163.71,144.13 175.78,144.13 v3(176.65,143.27) ; v3(107.59,157.95) 107.2,157.57 CE10.1 R2596.2
  IN3 w0.102: v3(150.92,155.13) 149.93,154.14 149.93,150.74 149.32,150.13 144.59,150.13 140.35,145.88 137.65,145.88 133.39,141.63 116.97,141.63 114.91,143.69 114.23,143.69 110.51,147.41 110.51,150.91 v3(110.76,151.17)
  BOTTOM w0.102: LE3.2 301.8,161.07 C139.1 299.91,160.29 298.59,160.29 295.65,157.34 295.65,153.35 292.07,149.77 289.86,149.77 289.17,149.08 285.18,149.08 283.66,147.56 273.9,147.56 264.27,137.93 244.52,137.93 241.02,134.43 240.15,134.43 239.73,134.43 235.12,134.43 234.15,133.46 227.65,133.46 223.37,137.74 216.94,137.74 211.73,132.52 200.71,132.52 199.44,131.25 192.76,131.25 189.81,134.2 183.23,134.2 176.6,140.83 176.6,141.87 176.04,142.43 176.04,142.66 v3(176.65,143.27) ; v3(107.59,157.95) 110.76,154.77 v3(110.76,151.17)
DMIC_CLK0_R: length 8.4
  TOP w0.102: R2596.1 v1(105.38,156.3) 105.3,156.3 105.12,156.12 103.42,156.12 102.48,157.06 D77.3 101.3,158.22 100.76,158.22 100.03,158.95 JLVDS1.4
DMIC_CLK1: length 18
  TOP w0.102: JPWR1.8 311.25,169.84 310.82,170.27 308.14,170.27 307.38,169.51 307.38,167.19 307.89,166.69 307.89,165.09 v6(305.81,163) 304.38,161.58 304.38,160.46 v3(304.33,160.41)
  BOTTOM w0.102: LE4.2 303.51,161.07 C130.1 304.61,160.69 v3(304.33,160.41)
DMIC_CLK_L: length 6.8
  BOTTOM w0.102: U17.2 306.23,157.07 306.06,157.24 v1(306.06,157.66) 305.69,158.03 303.86,158.03 303.44,158.44 303.44,159.56 LE4.1 LE3.1
DOCK_AC_OFF: length 59.5
  TOP w0.102: PD509.1 129.28,165.46 v1(129.05,165.7)
  TOP w0.254: PR537.1 130.51,161.92 v3(130.06,162.37) PD511.1 129.28,162.44 PD509.1
  IN1 w0.097: v3(130.06,162.37) 130.06,162.98 131.23,164.15 156.4,164.15 157.67,165.42 157.67,169.12 159.22,170.67 159.22,173.42 161.51,175.7 164.68,175.7 165.26,176.27 165.26,177.18 166.56,178.49 166.56,181.22 v3(167.33,181.98)
  BOTTOM w0.102: v3(167.33,181.98) 166.95,182.35 JDOCK1.2
DOCK_AC_OFF_EC: length 151.4
  TOP w0.102: U37.A63 198.23,126.89 v2(198.26,126.86) ; PR547.1 133.07,161.92 v1(133.15,162)
  TOP w0.254: PR546.2 131.57,160.9 v2(131.94,161.28) 131.94,161.67 PR547.1
  IN1 w0.097: v2(198.26,126.86) 198.26,126.38 199.5,125.14 199.5,123.11 198.74,122.35 198.72,122.35 197.54,121.17 197.54,118.59 196.98,118.03 195.3,118.03 194.91,117.64 194.91,116.65 193.94,115.67 193.54,115.67 193.35,115.67 192.46,115.67 191.82,115.03 190.35,115.03 189.88,114.56 189.88,114.24 189.19,113.55 182.44,113.55 177.96,109.06 171.2,109.06 170.72,108.58 164.46,108.58 164.2,108.85 154.78,108.85 150.5,113.14 150.5,113.29 150.5,113.48 150.5,114.04 141.22,123.31 136.45,123.31 132.3,127.47 132.3,133.55 132,133.86 129.41,133.86 126.78,136.49 117.54,136.49 v3(116.07,137.96)
  BOTTOM w0.102: v2(131.94,161.28) 131.94,161.28 131.61,160.95 131.61,160.74 130.19,159.32 127.23,159.32 126.08,160.48 123.76,160.48 120.01,156.73 120.01,154.96 117.16,152.11 117.16,146.67 116.07,145.58 v3(116.07,137.96)
DOCK_DCIN_IS+: length 105.2
  TOP w0.127: v2(201.82,186.19) v1(201.18,186.19)
  TOP w0.508: PQ403.6 124.89,151.58 v2(125.06,151.75)
  IN1 w0.508: v2(201.82,186.19) 191.2,186.19 190.21,185.2 182.1,185.2 181.03,186.27 177.97,186.27 177.51,185.81 175.11,185.81 173.19,183.89 173.19,182.85 172.81,182.47 171.25,182.47 171.23,182.45 170.59,182.45 169.36,181.22 169.36,180.58 169.36,180.38 168.12,179.15 168.12,179.14 167.22,178.24 167.22,177.21 165.08,175.07 162.6,175.07 161.15,173.62 161.15,171.71 158.28,168.84 158.28,164.51 156.85,163.08 147.4,163.08 146.64,162.32 137.62,162.32 137.24,162.7 131.38,162.7 130.14,161.45 128.44,161.45 127.04,160.06 127.04,156.16 125.06,154.18 v2(125.06,151.75)
  BOTTOM w0.254: v2(201.82,186.19) 201.95,186.06 JDOCK1.134
DOCK_DCIN_IS-: length 108.5
  TOP w0.508: PQ403.4 124.4,149.68 124.57,149.52 124.94,149.52 125.85,150.42 v1(125.85,150.85) v2(125.85,151.6)
  IN1 w0.508: v2(202.61,186.19) 202.61,185.61 202.43,185.43 194.73,185.43 192.57,183.27 191.21,183.27 190.94,183.55 190.93,183.55 190.03,184.44 181.45,184.44 180.33,183.32 178.93,183.32 177.28,184.97 175.35,184.97 173.96,183.58 173.96,182.54 173.13,181.71 171.49,181.71 171.27,181.67 171.07,181.58 170.89,181.46 170.12,180.69 170.12,179.89 167.99,177.76 167.99,176.9 165.4,174.31 162.92,174.31 161.92,173.3 161.92,171.39 159.05,168.52 159.05,164.2 157.17,162.32 147.72,162.32 146.95,161.55 137.31,161.55 136.92,161.94 131.7,161.94 130.45,160.69 128.75,160.69 127.8,159.74 127.8,154.66 125.85,152.7 v2(125.85,151.6)
  BOTTOM w0.254: v2(202.61,186.19) 202.45,186.04 JDOCK1.136
DOCK_DET#: length 205.4
  TOP w0.102: PR560.2 PR564.2 145.35,139.23 v3(145.35,137.25) ; v3(156.1,111.93) 155.99,111.82 153.11,111.82 152.61,111.31 152.61,108.69 152.59,108.69 v3(151.98,108.08) ; v3(149.52,107.35) 149.52,108.51 U4.10 ; v3(156.38,150.63) 156.21,150.8 PQ512.2 ; v2(202.48,181.14) 202.48,182.08 D19.2 201.75,182.81 201.75,183.53 201.32,183.95 R272.1 ; v2(191.7,120.41) 191.69,120.41 191.25,119.97 191.25,119.61 191.08,119.45 U37.B41
  TOP w0.254: PU506.2 151.77,167.87 152.02,168.12 152.57,168.12 153.6,169.15 153.6,170.26 153.28,170.57 153.28,176.47 153.38,176.57 v1(154.73,176.57) 160.15,176.57 163.38,173.34 163.97,173.34 v3(164.48,172.83)
  IN1 w0.097: v3(145.35,137.25) 146.5,137.25 151.74,132.01 151.74,130.31 153.27,128.78 153.27,125.8 152.61,125.14 152.61,116.8 153.6,115.8 153.6,114.37 156.04,111.93 v3(156.1,111.93) 156.58,112.41 158.13,112.41 158.14,112.41 160.71,112.41 160.8,112.5 162.05,112.5 162.05,112.5 163.53,112.5 163.53,112.5 163.74,112.5 164.49,111.74 165.1,111.74 165.58,111.27 167.84,111.27 168.53,111.96 174.84,111.96 177.53,114.65 178.64,114.65 181.85,117.86 183.61,117.86 183.98,117.49 187.18,117.49 187.54,117.86 189.49,117.86 191.06,119.43 191.06,119.74 191.7,120.38 v2(191.7,120.41) ; v3(164.48,172.83) 164.51,172.86 167.25,172.86 169.75,175.37 169.75,176.29 174.36,180.9 174.36,181.56 175.28,182.48 175.28,182.68 175.66,183.06 176.55,183.06 177.36,182.25 180.42,182.25 180.6,182.25 180.6,182.25 180.92,181.93 201.69,181.93 202.25,181.37 v2(202.48,181.14)
  IN2 w0.102: v3(151.98,108.08) 151.49,107.58 149.75,107.58 v3(149.52,107.35)
  BOTTOM w0.102: v3(164.48,172.83) 164.48,166.36 164.1,165.98 164.1,157.67 159.07,152.64 158.39,152.64 v3(156.38,150.63) 151.53,145.78 151.53,140.63 148.15,137.25 v3(145.35,137.25)
DOCK_DET_R#: length 19.7
  TOP w0.102: D87.2 v1(204.84,171.69) 204.49,172.04 204.49,177.09 204.7,177.3 204.7,179.37 205.29,179.97 205.29,181.42 204.85,181.87 204.85,182.75 v2(204.28,183.32) 203.78,183.82 D19.1
  BOTTOM w0.102: JDOCK1.144 204.45,183.49 v2(204.28,183.32) 203.95,183.65 JDOCK1.142
DOCK_HP_DET: length 158
  TOP w0.102: v3(194.68,133.41) 194.11,132.84 194.11,131.09 193.96,130.94 193.53,130.94 192.95,130.36 192.95,130.2 192.84,130.08 U37.A7
  BOTTOM w0.102: v3(194.68,133.41) 196.5,135.23 209.39,135.23 210.1,135.94 212.02,135.94 215.29,139.21 231.14,139.21 232.1,138.26 232.1,136.98 232.65,136.43 239.94,136.43 240.07,136.56 243.96,140.45 263.02,140.45 272.54,149.97 281.4,149.97 285.11,153.68 291.78,153.68 292.8,154.7 292.8,159.81 296.15,163.16 306.21,163.16 307.6,164.55 314.58,164.55 v1(315.47,163.65) 317.14,161.99 320.92,161.99 321.17,161.73 321.17,157.9 320.72,157.44 R158.2 321.33,156.81 Q21.2
DOCK_LOM_ACTLED_YEL#: length 27.7
  TOP w0.102: v2(203.75,181.97) 203.99,181.97 204.84,181.12 204.84,180.16 203.85,179.17 v1(203.85,175.75) 203.92,175.68 203.92,171.26 203.44,170.78 202.56,170.78 202.28,170.5 201.51,170.5 201.4,170.38 U23.19
  BOTTOM w0.102: JDOCK1.100 193.45,183.62 193.36,183.52 193.36,182.76 194.15,181.97 v2(203.75,181.97)
DOCK_LOM_SPD10LED_GRN#: length 39.3
  TOP w0.102: U23.40 191.26,170.88 191.02,170.65 190.58,170.65 190.29,170.94 v1(190.29,172.96) 191.53,174.2 v3(191.53,174.61)
  IN2 w0.102: v3(191.53,174.61) 191.02,174.61 190.64,174.99 190.64,176.06 189.68,177.02 189.68,180.45 188.51,181.62 181.65,181.62 181.22,182.05 177.64,182.05 176.17,180.58 173.93,180.58 172.79,179.44 v3(171.34,179.44)
  BOTTOM w0.102: JDOCK1.3 167.45,178.65 168.24,179.44 v3(171.34,179.44)
DOCK_LOM_SPD100LED_ORG#: length 50.9
  TOP w0.102: v3(202.91,179.34) 202.91,178.85 203.42,178.35 203.42,174.28 v1(203.58,174.12) 203.69,174.01 203.69,171.36 203.34,171 202.46,171 202.18,170.73 201.69,170.73 201.53,170.88 U23.20
  IN2 w0.102: v3(167.88,182.46) 168.42,181.93 173.85,181.93 174.79,182.87 176.6,182.87 177.18,182.28 181.12,182.28 181.13,182.28 181.31,182.28 181.75,181.85 192.42,181.85 193.46,180.81 197.32,180.81 198.8,179.34 v3(202.91,179.34)
  BOTTOM w0.102: v3(167.88,182.46) 167.45,182.89 JDOCK1.4
DOCK_LOM_TRD0+: length 13
  TOP w0.089: U23.36 193.42,173.39 193.76,173.73 193.76,174.22 193.53,174.45 193.53,180.88 194.54,181.9 194.54,182.72 v2(194.4,182.86)
  BOTTOM w0.089: JDOCK1.104 194.45,183.64 194.5,183.59 194.5,182.96 v2(194.4,182.86)
DOCK_LOM_TRD0-: length 13
  TOP w0.089: U23.35 193.92,172.78 193.81,172.88 193.81,173.22 194.15,173.57 194.15,173.89 194.15,174.38 193.92,174.62 v1(193.92,175.28) 193.92,180.72 194.94,181.74 194.94,182.81 v2(194.99,182.86)
  BOTTOM w0.089: JDOCK1.106 194.95,183.65 194.89,183.59 194.89,182.96 v2(194.99,182.86)
DOCK_LOM_TRD1+: length 12.6
  TOP w0.089: v2(195.91,182.88) 196,182.78 196,176.08 195.65,175.73 195.65,173.33 195.44,173.13 195.42,173.1 U23.32
  BOTTOM w0.089: v2(195.91,182.88) 195.99,182.96 195.99,183.69 195.95,183.73 JDOCK1.110
DOCK_LOM_TRD1-: length 12.6
  TOP w0.089: U23.31 195.92,173.05 196.04,173.17 196.04,175.56 196.4,175.92 v1(196.4,176.45) 196.4,182.78 v2(196.49,182.88)
  BOTTOM w0.089: JDOCK1.112 196.45,183.65 196.38,183.58 196.38,182.99 v2(196.49,182.88)
DOCK_LOM_TRD2+: length 13.9
  TOP w0.089: v2(198.9,182.85) 198.99,182.75 198.99,182.54 198.84,182.39 198.09,182.39 197.2,181.49 197.2,176.54 197.47,176.26 197.47,174.81 197.98,174.29 197.98,173 197.92,172.93 U23.27
  BOTTOM w0.089: v2(198.9,182.85) 199,182.95 199,183.65 198.95,183.7 JDOCK1.122
DOCK_LOM_TRD2-: length 13.9
  TOP w0.089: U23.26 198.42,172.94 198.38,172.98 198.38,174.45 197.86,174.97 197.86,176.43 197.59,176.7 v1(197.59,181.04) 197.59,181.33 198.25,181.99 199.01,181.99 199.39,182.37 199.39,182.77 v2(199.53,182.92)
  BOTTOM w0.089: JDOCK1.124 199.45,183.65 199.4,183.6 199.4,183.05 v2(199.53,182.92)
DOCK_LOM_TRD3+: length 13.4
  TOP w0.089: v2(200.4,182.71) 200.49,182.63 200.49,182.27 201.48,181.27 v1(201.48,179.58) 201.48,179.25 200.4,178.17 200.4,173.34 199.92,172.86 U23.23
  BOTTOM w0.089: v2(200.4,182.71) 200.49,182.79 200.49,183.69 200.45,183.73 JDOCK1.128
DOCK_LOM_TRD3-: length 13.4
  TOP w0.089: U23.22 200.42,172.8 200.79,173.18 200.79,178 201.88,179.09 201.88,181.44 200.88,182.43 200.88,182.6 v2(200.99,182.71)
  BOTTOM w0.089: JDOCK1.130 200.95,183.65 200.88,183.58 200.88,182.82 v2(200.99,182.71)
DOCK_MIC_DET: length 184.2
  TOP w0.102: v3(318.99,157.64) 318.91,157.72 v1(315,157.72) 313.35,157.72 312.51,156.88 307.64,156.88 307.33,157.19 303.56,157.19 302.95,156.58 297.09,156.58 v3(296.54,156.02) ; v2(193.32,126.82) 192.86,127.28 192.86,127.6 192.59,127.87 U37.B8
  BOTTOM w0.102: v2(193.32,126.82) 193.79,127.29 193.79,127.42 194.26,127.9 196.48,127.9 214.57,109.81 214.57,105.57 216.65,103.49 223.14,103.49 223.21,103.42 223.34,103.28 225.42,103.28 225.73,103.28 226.63,104.18 226.63,105.27 225.66,106.25 225.66,112.32 227.6,114.26 227.6,122.29 226.65,123.24 226.65,123.67 227.1,124.12 230.22,124.12 231.55,125.45 233.7,125.45 234.12,125.87 234.62,125.87 243.54,125.87 250.13,132.46 250.13,135.34 252.24,137.45 264.47,137.45 274.1,147.08 290.06,147.08 296.36,153.38 296.36,155.84 v3(296.54,156.02) ; v3(318.99,157.64) 319.19,157.44 R159.2 320.13,156.98 320.13,155.66 321.33,154.47 Q21.5
DOCK_POR_RST#: length 97.5
  TOP w0.102: U38.A21 172.83,121.89 173.07,121.65 v2(173.07,121.45) 173.2,121.32 C357.1 174.83,121.19 RP18.5 ; v2(203.64,183.33) 204.53,182.44 204.53,181.78 205.07,181.25 205.07,180.06 204.23,179.23 204.23,171.41 205.88,169.76 D87.3 206.04,168.92 v1(206.04,167.12) 206.04,163.77 v2(205.63,163.36)
  IN1 w0.097: v3(185.79,163.21) 185.84,163.26 185.84,164.07 185.97,164.2 186.89,164.2 187.27,163.82 202.6,163.82 202.98,164.2 204.79,164.2 v2(205.63,163.36)
  IN3 w0.102: v2(173.07,121.45) 173.52,121.91 173.52,124.32 175.83,126.63 175.83,134.33 176.51,135.01 176.51,139.48 178.47,141.44 180.75,143.72 181.52,144.5 181.52,146.32 182.13,146.93 182.13,148.86 183.68,150.41 183.68,154.24 185.11,155.67 185.11,162.52 v3(185.79,163.21)
  BOTTOM w0.102: JDOCK1.140 203.45,183.53 v2(203.64,183.33)
DOCK_PSID: length 106.1
  TOP w0.102: PU1.1 v1(132.92,139.48) 132.92,142.72 v3(132.93,142.73)
  IN2 w0.102: v3(132.93,142.73) 133.32,142.35 148.47,142.35 150.83,144.72 157.69,144.72 158.69,145.72 158.7,145.72 159.06,146.07 159.06,146.08 159.06,146.09 163.64,146.09 165.85,148.3 v3(165.98,148.3)
  IN3 w0.102: v3(202.79,158.56) 202.79,162.46 201.84,163.4 201.84,170.9 202.58,171.63 202.58,177.72 v2(202.37,177.92)
  BOTTOM w0.102: v3(202.79,158.56) 202.34,159.02 199.66,159.02 199.3,158.66 196.67,158.66 194.86,156.85 194.86,155.47 193.18,153.79 193.18,152.06 190.96,149.84 179.45,149.84 176.69,147.08 168.85,147.08 168.29,147.64 166.64,147.64 v3(165.98,148.3) ; JDOCK1.135 202.45,177.84 v2(202.37,177.92)
DOCK_PWR_BTN#: length 109.1
  TOP w0.102: v3(160.11,118.81) 160.39,118.53 160.39,117.51 160.67,117.23 160.67,115.86 160.21,115.4 R330.2 160.21,114.41 C342.1
  IN1 w0.097: v3(160.11,118.81) 160.44,119.14 160.44,120.21 159.45,121.19 159.45,121.52 159.45,122.05 160.12,122.72 162.9,122.72 163.72,123.54 163.72,125.72 162.73,126.71 162.73,131.05 161.76,132.02 161.76,132.96 161.54,133.18 161.54,134.58 162.73,135.78 162.73,137 163.47,137.73 163.47,146.93 164.66,148.12 164.66,157.72 166.63,159.7 166.82,159.7 167.85,160.74 167.85,161.38 167.43,161.8 167.43,162.79 167.85,163.22 167.85,164.71 168.28,165.14 168.28,166.45 168.77,166.94 168.77,169.12 174.69,175.04 174.69,176.01 176.09,177.41 176.09,178.02 176.45,178.38 176.45,178.38 176.81,178.73 176.81,178.87 177.5,179.56 v2(178.21,179.56)
  BOTTOM w0.102: v2(178.21,179.56) 179.05,178.73 179.67,178.73 179.87,178.93 185.49,178.93 185.89,178.52 186.91,178.52 187.65,179.26 189.42,179.26 189.7,178.98 191.76,178.98 194.29,181.5 201.07,181.5 202.3,180.27 202.3,179.21 203.45,178.06 JDOCK1.139
DOCK_PWR_SW#: length 7.3
  TOP w0.102: R328.2 159.33,116.2 C344.1 R330.1 160.21,116.89 v1(159.85,117.25) 159.68,117.42 159.68,119.82 160.25,120.39 U38.A63
DOCK_SMB_ALERT#: length 187.6
  TOP w0.102: PQ1.3 136.6,139.8 136.6,140.74 137.51,141.64 v2(137.76,141.64) ; U37.A51 197.82,120.89 198.21,120.51 v2(198.34,120.51) 198.77,120.94 R292.2 ; v3(142.66,163.13) 142.51,163.28 PD512.2 142.93,165.08 143.15,164.86 143.15,163.23 143.42,162.95 144.54,162.95 145.05,163.46 152.56,163.46 153.79,162.24 153.79,160.82 154.04,160.57 155.69,160.57 155.85,160.72 155.85,163.05 157.34,164.55 157.34,167.09 160.16,169.91 v1(160.32,169.91) 161.31,169.91 163.76,172.37 v3(163.76,172.5)
  IN1 w0.097: v3(163.76,172.5) 164.02,172.25 166.95,172.25 169.98,175.27 169.98,176.2 174.59,180.81 174.59,181.47 175.51,182.39 175.51,182.59 175.76,182.84 176.39,182.84 177.21,182.03 180.51,182.03 180.83,181.71 196.32,181.71 198.33,179.7 200.5,179.7 v2(201.92,178.29)
  IN3 w0.102: v2(198.34,120.51) 199.11,120.51 202.38,123.77 202.38,126.56 201.42,127.52 198.86,127.52 197.74,128.64 194.28,128.64 193.18,129.73 193.18,132.29 192.83,132.64 192.83,139.39 194.02,140.58 194.16,140.72 194.16,143.56 193.34,144.38 193.34,149.17 198.18,154.01 200.96,154.01 201.67,153.3 202.45,153.3 202.73,153.58 202.73,155.63 203.11,156.02 203.11,157.45 202.25,158.31 202.25,158.65 202.56,158.96 202.56,162.37 201.62,163.31 201.62,171 202.35,171.73 202.35,177.04 201.92,177.47 v2(201.92,178.29)
  BOTTOM w0.102: v3(142.66,163.13) 142.36,162.83 142.36,151.75 141.44,150.84 141.44,148.14 137.76,144.46 v2(137.76,141.64) ; v2(201.92,178.29) 201.95,178.25 JDOCK1.133
DOCK_SMB_CLK: length 94.3
  TOP w0.102: U38.B4 163.69,119.34 163.92,119.56 163.92,120.02 v3(164.48,120.59) ; RP7.4 174.88,137.68 175.12,137.44 175.12,136.81 175.29,136.64 175.57,136.64 v3(175.67,136.73)
  IN3 w0.102: v4(188.69,178.14) 188.53,178.3 188.53,178.29 188.27,178.29 188.05,178.07 188.05,176.95 188.59,176.41 188.59,174 189.93,172.66 189.93,170.02 189.34,169.43 187.13,169.43 186.28,168.58 186.28,164.64 184.55,162.9 184.55,155.79 182.62,153.86 182.62,150.08 181.58,149.04 181.58,147.31 180.84,146.57 180.84,144.62 176.59,140.37 176.01,139.79 176.01,137.08 v3(175.67,136.73) 175.94,136.46 175.94,135.11 175.23,134.4 175.23,126.74 173.39,124.9 172.45,124.9 171.16,123.61 171.16,123.61 171.16,122.14 170.49,121.47 168.75,121.47 168.49,121.22 165.11,121.22 v3(164.48,120.59)
  BOTTOM w0.102: JDOCK1.127 200.45,177.63 200.59,177.76 200.59,178.54 200.23,178.9 198.5,178.9 197.13,180.28 194.07,180.28 193.97,180.18 193.97,180.11 192.03,178.17 189.51,178.17 189.33,178.35 188.89,178.35 v4(188.69,178.14)
DOCK_SMB_DAT: length 98.5
  TOP w0.102: v3(163.44,117.48) U38.A3 ; RP7.3 174.38,137.86 174.89,137.35 174.89,136.72 v4(175.5,136.1)
  IN3 w0.102: v3(163.44,117.48) 163.92,117.96 163.92,120.31 163.77,120.46 163.77,120.88 163.99,121.1 164.27,121.1 164.61,121.45 167.18,121.45 167.18,121.44 168.39,121.44 168.65,121.7 170.4,121.7 170.93,122.24 170.93,123.52 170.93,123.71 172.36,125.13 172.54,125.13 173.29,125.13 175,126.83 175,134.5 175.71,135.21 175.71,135.9 v4(175.5,136.1) 175.26,136.35 175.26,136.94 175.78,137.47 175.78,139.89 175.92,140.02 177.26,141.36 179.62,143.72 180.61,144.72 180.61,146.66 181.35,147.4 181.35,149.14 181.48,149.27 182.39,150.18 182.39,153.95 184.32,155.88 184.32,163 186.05,164.73 186.05,168.67 187.04,169.66 189.25,169.66 189.7,170.12 189.7,172.56 188.36,173.91 188.36,176.32 187.82,176.85 187.82,178.17 188.18,178.52 188.43,178.52 v3(188.69,178.78)
  BOTTOM w0.102: v3(188.69,178.78) 188.89,178.57 189.43,178.57 189.6,178.4 191.94,178.4 193.74,180.2 193.74,180.28 193.97,180.5 197.03,180.5 197.22,180.5 198.59,179.13 200.32,179.13 200.81,178.64 200.81,177.76 200.95,177.63 JDOCK1.129
DOCK_USBP1+: length 203.3
  TOP w0.102: v2(185.88,180.06) 185.4,180.54 185.4,182.78 185.25,182.93 L53.4 185.22,183.27 R415.1
  IN1 w0.076: 168.96,61.44 168.96,61.45 168.96,61.48 168.05,62.39 164,62.39 163.35,63.04 163.35,63.85 163,64.2 v2(162.84,64.2)
  IN1 w0.097: 168.96,61.44 171.69,58.71 172.46,58.71 178.45,52.72 194.91,52.72 199.72,57.54 202.52,57.54 203.1,58.11 203.1,59.09 206.45,62.43 206.45,64.61 205.21,65.85 205.21,70.61 204.94,70.88 204.94,73.76 202.63,76.06 202.63,79.1 201.32,80.42 201.32,86.1 199.9,87.51 198.8,87.51 197.5,88.81 197.5,97.42 196.63,98.28 196.63,100.07 196.23,100.47 196.23,103.88 201.86,109.5 201.86,110.62 203.12,111.88 203.36,111.88 207.88,116.4 207.88,126.59 207.53,126.94 207.53,132.31 207.21,132.63 207.21,133.25 203.67,136.79 197.54,136.79 195.94,138.38 195.02,138.38 191.41,141.98 191.41,145.05 189.66,146.8 189.66,149.97 185.72,153.9 185.72,154.76 184.53,155.95 184.53,162.65 183.36,163.82 183.36,165.27 182.6,166.03 182.35,166.03 180.97,167.41 180.97,172.25 181.78,173.05 181.78,175.04 185.23,178.5 185.23,179.95 185.55,180.27 185.79,180.27 185.88,180.17 v2(185.88,180.06)
  BOTTOM w0.076: UC1.AT10 162.52,64.53 v2(162.84,64.2)
DOCK_USBP1-: length 203.3
  TOP w0.102: R407.1 186.11,183.26 L53.1 186.1,182.73 185.61,182.25 185.61,180.69 185.71,180.59 185.9,180.59 v2(185.95,180.64)
  IN1 w0.076: v2(162.88,64.85) 163.24,64.49 163.24,64.2 163.52,63.92 163.52,63.11 164.07,62.56 168.12,62.56 169.02,61.65 169.05,61.65 169.11,61.59
  IN1 w0.097: v2(185.95,180.64) 185.78,180.48 185.46,180.48 185.02,180.04 185.02,178.58 181.57,175.13 181.57,173.14 180.76,172.34 180.76,167.32 182.26,165.82 182.51,165.82 183.15,165.19 183.15,163.74 184.32,162.56 184.32,155.87 185.51,154.67 185.51,153.82 189.45,149.88 189.45,146.71 191.2,144.96 191.2,141.9 194.93,138.17 195.86,138.17 197.45,136.58 203.58,136.58 207,133.16 207,132.54 207.32,132.22 207.32,126.85 207.67,126.5 207.67,116.49 203.28,112.09 203.03,112.09 201.65,110.7 201.65,109.59 196.02,103.97 196.02,100.38 196.42,99.98 196.42,98.2 197.29,97.33 197.29,88.72 198.71,87.3 199.82,87.3 201.11,86.01 201.11,80.33 202.42,79.02 202.42,75.98 204.72,73.68 204.72,70.8 205,70.52 205,65.76 206.24,64.52 206.24,62.52 202.89,59.17 202.89,58.2 202.44,57.75 199.63,57.75 194.82,52.93 178.54,52.93 172.54,58.92 171.78,58.92 169.11,61.59
  BOTTOM w0.076: v2(162.88,64.85) 162.55,65.18 UC1.AR10
DOCK_USBP1_D+: length 3
  TOP w0.102: v2(185.38,185.93) 185.56,185.74 185.56,185.57 185.25,185.25 L53.3 185.22,184.92 R415.2
  BOTTOM w0.102: JDOCK1.72 185.45,185.34 185.58,185.47 185.58,185.73 v2(185.38,185.93)
DOCK_USBP1_D-: length 3
  TOP w0.102: v2(185.96,185.93) 185.78,185.74 185.78,185.6 186.1,185.28 L53.2 186.11,184.93 R407.2
  BOTTOM w0.102: JDOCK1.74 185.95,185.3 185.79,185.46 185.79,185.75 v2(185.96,185.93)
DOCK_USBP2+: length 111.9
  TOP w0.102: U4.5 151.41,109.4 151.46,109.36 151.46,109.27 151.51,109.22 151.77,109.22 151.9,109.35 151.9,111.63 152.8,112.53 154.63,112.53 154.96,112.86 154.96,113.14 153.2,114.9 153.2,115.94 150.22,118.92 150.22,119.38 148.19,121.42 144.54,121.42 142.04,123.93 142.04,124.87 v3(141.62,125.28) ; v2(183.01,174.62) 183.18,174.78 183.18,174.97 182.79,175.35 182.79,175.75 183.15,176.11 183.94,176.11 184.29,176.46 184.29,179.07 183.92,179.43 L43.4 183.91,179.9 R269.1
  IN3 w0.086: v2(183.01,174.62) 183.08,174.55 183.08,174.35 182.86,174.13 182.48,174.13 180.47,172.12 165.73,172.12 163.24,169.63 159.04,169.63 153.15,163.75 153.15,160.09 152.13,159.06 152.13,149.41 149.6,146.88 149.6,138.04 141.97,130.41 141.97,125.63 v3(141.62,125.28)
DOCK_USBP2-: length 112
  TOP w0.102: R270.1 184.8,179.91 L43.1 184.77,179.45 184.5,179.18 184.5,176.37 184.03,175.89 183.24,175.89 183.01,175.66 183.01,175.44 183.39,175.06 183.39,174.82 v2(183.6,174.62) ; U4.4 151.86,109 152.11,109.26 152.11,111.54 152.89,112.32 154.72,112.32 155.17,112.77 155.17,113.23 153.41,114.99 153.41,116.03 150.44,119.01 150.44,119.47 148.28,121.64 144.63,121.64 142.26,124.02 v4(142.26,125.28)
  IN3 w0.086: v2(183.6,174.62) 182.93,173.95 182.55,173.95 180.55,171.95 165.8,171.95 163.31,169.46 159.11,169.46 153.33,163.68 153.33,160.01 152.3,158.99 152.3,149.33 149.77,146.8 149.77,137.96 142.14,130.33 142.14,125.4 v4(142.26,125.28)
DOCK_USBP2_D+: length 3.9
  TOP w0.102: v2(183.71,183.26) 183.87,183.09 183.87,182.62 184.24,182.26 184.24,182.16 183.92,181.84 L43.3 183.91,181.57 R269.2
  BOTTOM w0.102: JDOCK1.66 183.95,183.78 183.99,183.74 183.99,183.5 183.75,183.26 v2(183.71,183.26)
DOCK_USBP2_D-: length 3.9
  TOP w0.102: R270.2 184.8,181.56 L43.2 184.77,181.85 184.46,182.17 184.46,182.35 184.09,182.71 184.09,183.05 v2(184.29,183.26)
  BOTTOM w0.102: v2(184.29,183.26) 184.2,183.35 184.2,183.64 184.45,183.89 JDOCK1.68
DOCKED: length 58.9
  TOP w0.102: v2(199.08,167.19) 198.54,167.73 198.54,168.03 198.42,168.16 U23.13 ; U37.A38 v2(190.84,117.47)
  IN3 w0.102: v2(190.84,117.47) 190.84,118.72 191.13,119.01 191.13,126.18 191.59,126.65 191.59,127.84 189.78,129.65 189.78,130.97 190.19,131.38 190.19,140.4 191,141.21 191,144.16 191.38,144.54 191.38,150.48 193.44,152.54 193.44,153.41 193.84,153.81 194.06,153.81 195.04,153.81 195.78,154.55 196.84,155.61 196.84,165.01 199.08,167.25 v2(199.08,167.19)
  BOTTOM w0.102: v2(199.08,167.19) v1(198.29,167.19)
DPB_CA_DET: length 67.3
  TOP w0.102: Q133.2 162.08,169.04 v3(162.09,169.05) 162.09,170.27 163.62,171.79 164.1,171.79 v1(165.26,172.95) 165.61,173.3 165.61,175.61 167.21,177.21 167.21,178.51 168.88,180.17 168.88,181.42 168.34,181.95 168.34,182.64 v2(167.88,183.09) 167.4,183.58 167.14,183.58 R120.2 ; v3(183.18,163.08) 182.86,163.39 U6.M14 ; v3(160.14,160.79) 159.47,160.12 U11.1 ; U11.4 v3(161.42,159.15)
  IN1 w0.097: v3(162.09,169.05) 160.87,167.83 160.87,167.07 161.13,166.81 161.13,164.5 160.14,163.51 v3(160.14,160.79) ; v3(161.42,159.15) 163.29,159.15 v3(164.86,160.72)
  IN3 w0.102: v3(164.86,160.72) 164.86,161.08 165.18,161.4 165.18,163.4 166.39,164.6 173.96,164.6 175.68,166.32 182.52,166.32 183.18,165.67 v3(183.18,163.08) ; v3(160.14,160.79) 160.14,159.38 160.37,159.15 v3(161.42,159.15)
  BOTTOM w0.102: v2(167.88,183.09) 167.9,183.12 167.9,183.4 167.95,183.44 JDOCK1.6
DPB_CA_DET#: length 12.4
  TOP w0.102: v3(161.9,162.52) 162.07,162.68 U11.10 ; v3(160.77,161.89) 160.32,161.89 160.12,162.09 U11.13 160.12,164.4 160.49,164.78 162.03,164.78 162.17,164.92 v1(162.17,165.21) 162.17,165.36 Q133.1 160.18,167.35 159.66,167.35 159.4,167.09 R161.1
  IN1 w0.097: v3(160.77,161.89) 161.27,161.89 v3(161.9,162.52)
DPB_DOCK_AUX: length 39.9
  TOP w0.089: U11.3 160.77,159.35 161.38,159.97 161.38,160.36 v3(161.2,160.54) 161.36,160.69 161.36,161 161.85,161.49 161.85,161.49 162.09,161.73 162.09,161.83 162.1,161.83 162.02,161.91 161.69,161.91 161.42,162.18 U11.11
  IN1 w0.089: v2(175.19,181.12) 175.33,180.99 175.33,180.63 171.97,177.28 171.97,175.23 167,170.25 166.89,170.25 166.89,170.26 164.42,170.26 162.57,168.41 162.2,168.03 162.2,165.86 163.36,164.7 163.36,162.61 162.59,161.84 162.09,161.84 161.36,161.1 161.36,160.69 v3(161.2,160.54)
  BOTTOM w0.089: JDOCK1.34 174.95,183.7 175,183.66 175,182.14 175.28,181.86 175.28,181.22 v2(175.19,181.12)
DPB_DOCK_AUX#: length 39.8
  TOP w0.089: U11.6 162.72,158.75 161.78,159.69 161.78,160.46 161.85,160.54 161.85,160.55 v3(161.86,160.56) 161.75,160.67 161.75,160.83 163.37,162.45 U11.8
  IN1 w0.089: v2(175.77,181.12) 175.66,181.01 175.66,180.49 172.3,177.14 172.3,175.09 167.14,169.92 166.89,169.92 166.89,169.92 164.55,169.92 162.9,168.27 162.53,167.9 162.53,166 163.69,164.83 163.69,162.47 162.73,161.5 162.23,161.5 161.69,160.96 161.69,160.74 v3(161.86,160.56)
  BOTTOM w0.089: JDOCK1.36 175.45,183.86 175.39,183.8 175.39,182.31 175.68,182.02 175.68,181.22 v2(175.77,181.12)
