# Allegro board Alpine15_LA-A101PR10-0826C.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_ODT0: length 3.6
  BOTTOM w0.152: JDIMM1.116 124.88,17.36 125.01,17.23 125.01,16.45 v1(124.48,15.91) 124.73,15.66 R29.2
M_ODT1: length 3.4
  BOTTOM w0.152: JDIMM1.120 126.08,16.6 125.77,16.29 v1(125.77,15.96) 125.62,15.81 R30.2
M_ODT2: length 3.7
  TOP w0.152: R31.2 199.96,15.65 v2(199.96,16.08)
  BOTTOM w0.152: v2(199.96,16.08) 199.72,16.08 199.38,16.42 JDIMM2.116
M_ODT3: length 3.7
  TOP w0.152: R33.2 201.33,15.88 v2(201.33,16.1)
  BOTTOM w0.152: JDIMM2.120 200.58,16.85 v2(201.33,16.1)
MASK_BASE_LEDS#: length 79.1
  TOP w0.102: Q32.5 Q32.2 204.36,163.54 v3(204.99,162.9) 203.94,161.85 203.94,153.42 204.11,153.25 204.33,153.02 206.49,153.02 v3(206.59,152.92) 206.68,152.83 206.68,152.49 206.38,152.18 U47.4 ; v3(208.55,144.31) 208.42,144.18 Q28.2
  IN3 w0.102: v3(208.55,144.31) 208.55,149.19 207.1,150.63 207.1,152.41 v3(206.59,152.92)
  BOTTOM w0.102: Q22.5 250.02,165.93 249.29,166.66 249.29,167.8 248.05,169.05 v1(244.95,169.05) 237.73,169.05 237.4,169.38 224.91,169.38 223.09,171.21 214.72,171.21 206.41,162.9 v3(204.99,162.9)
MASK_SATA_LED#: length 141.1
  TOP w0.102: Q24.5 221.76,36.33 221.63,36.46 218.63,36.46 218.23,36.87 218.23,39.25 v1(219.73,40.75) 220.11,41.13 224.22,41.13 224.58,40.78 225.29,40.78 228.13,43.62 228.13,44.41 v3(228.41,44.69) ; U37.B9 192.08,127.72 v2(192.36,127.45)
  IN2 w0.102: v2(192.36,127.45) 192.36,128.8 191.72,129.44 191.72,130.26 191.56,130.41 191.56,130.93 192.32,131.69 192.32,133.2 193.04,133.92 194.88,133.92 196.21,132.6 198.39,132.6 199.25,131.74 203.41,131.74 203.83,131.32 203.83,130.09 207.33,126.58 207.33,104.33 210.43,101.23 210.43,92.14 211.39,91.18 211.39,85.06 215.79,80.66 215.79,71.1 215.54,70.85 215.39,70.7 215.21,70.52 215.08,70.39 215.08,69.18 215.48,68.77 218.28,68.77 231.05,56 231.05,50.98 229.3,49.23 229.3,46.19 228.41,45.3 v3(228.41,44.69)
MCARD_PCIE_MSATA#: length 161.8
  TOP w0.102: U37.B3 195.08,127.57 v2(195.2,127.45)
  IN2 w0.102: v3(219.29,66.08) 219.14,66.08 218,67.22 214.66,67.22 214.2,67.68 213.93,67.94 213.93,68.7 213.93,69.84 213.93,69.84 213.93,70.48 213.93,70.86 214.11,71.04 214.27,71.19 214.4,71.33 214.53,71.46 214.65,71.57 214.65,79.95 210.05,84.55 210.05,85.65 210.05,86.22 207.15,89.11 207.15,98.14 206.16,99.13 206.16,101.31 205.58,101.89 205.58,107.35 203.83,109.1 203.83,128.08 201.8,130.11 197.96,130.11 195.3,127.45 v2(195.2,127.45)
  BOTTOM w0.076: UC1.AC1 168.44,72.39 169.13,72.39 169.27,72.53 169.3,72.53 170.72,72.53
  BOTTOM w0.102: v3(219.29,66.08) 223.56,61.81 223.56,57.12 221.09,54.65 216.63,54.65 216.15,55.12 216,55.12 210.14,55.12 210.07,55.19 209.18,55.19 207.87,56.5 204.87,56.5 203.51,55.14 198.33,55.14 196.5,56.97 191.39,56.97 191.28,57.09 190.77,57.09 189.88,57.97 189.88,59.19 190.08,59.4 190.08,61.05 v1(189.32,61.82) 189.07,62.06 184.57,62.06 183.96,62.68 183.76,62.68 183.56,62.87 183.03,62.87 182.55,63.36 181.73,63.36 180.58,64.5 180.58,66.79 177.87,69.51 176.72,69.51 RC12.1 176.06,70.12 174.31,70.12 173.12,71.31 172.2,71.31 170.99,72.53 170.72,72.53
MCARD_WWAN_PWREN: length 104.6
  TOP w0.102: v2(191.68,119.82) 191.59,119.73 U37.B42 ; RC191.1 190.86,135.62 v3(190.88,135.61)
  IN3 w0.102: v3(190.88,135.61) 190.88,133.81 191.07,133.62 191.07,132.57 190.67,132.17 190.67,129.09 191.82,127.94 191.82,123.92 191.7,123.8 191.7,121.58 192.09,121.19 192.09,120.23 v2(191.68,119.82)
  BOTTOM w0.102: U51.5 260.94,151.23 260.93,151.22 260.93,150.32 v1(261.61,149.64) 261.61,143.62 259.17,141.18 243.65,141.18 239.58,137.12 232.93,137.12 232.78,137.27 232.78,138.54 231.42,139.9 215.01,139.9 211.73,136.63 209.81,136.63 209.1,135.91 196.17,135.91 195.55,136.54 191.81,136.54 v3(190.88,135.61)
MCP_TESTLOW1: length 9.8
  TOP w0.102: v2(146.86,87.59) 146.57,87.59 146.37,87.79 146.37,88.37 146.6,88.59 v1(146.6,88.73) 146.37,88.96 146.37,91.27 RC46.1
  BOTTOM w0.076: v2(146.86,87.59) 146.61,87.35 146.43,87.35 146.12,87.04 146.12,85.69 146.38,85.43 146.38,84.92 146.84,84.46 146.84,84.37 146.89,84.32 146.89,84.17 146.87,84.14 146.87,84.14 146.86,84.11 146.85,84.08 146.84,84.05 146.83,84.02 146.83,83.83 146.88,83.67 146.89,83.65 146.97,83.53 UC1.C35
MCP_TESTLOW2: length 10.7
  TOP w0.102: RC47.1 145.81,91.35 v1(145.81,90.59) 146.12,90.28 146.12,87.39 146.5,87.01 v2(146.88,87.01)
  BOTTOM w0.076: UC1.C34 147.58,83.37 147.41,83.55 147.23,83.55 147.02,83.75 146.99,83.86 146.99,83.99 147.02,84.05 147.03,84.06 147.05,84.14 147.05,84.39 147.01,84.44 147.01,84.53 146.55,84.98 146.55,85.5 146.29,85.75 146.29,86.98 146.5,87.18 146.71,87.18 v2(146.88,87.01)
MCP_TESTLOW3: length 15.6
  TOP w0.102: v2(163.41,67.71) 163.41,67.22 163.16,66.97 v1(162.47,66.97) 161.89,66.38 161.89,64.68 162.17,64.4 162.17,63.51 163.94,61.74 166.72,61.74 166.97,61.49 167.87,61.49 RC50.1
  BOTTOM w0.076: v2(163.41,67.71) 163.45,67.71 UC1.AK8
MCP_TESTLOW4: length 26.5
  TOP w0.076: v2(162.83,66.15) 162.35,65.67 162.35,64.71 162.45,64.6 162.45,63.54 163.92,62.06 v1(166.94,62.06) 167.19,62.06 167.35,61.9 167.8,61.9 169.83,59.87 170.35,59.87 170.53,59.69 170.54,59.69 170.73,59.5 170.73,58.56
  TOP w0.102: v2(178.61,56.07) 178.91,55.77 178.91,55.28 RC52.1 ; 170.73,58.56 v3(170.73,57.8)
  IN2 w0.076: v3(170.73,57.8) 170.88,57.8
  IN2 w0.102: 170.88,57.8 171.9,57.8 173.04,56.65 178.03,56.65 v2(178.61,56.07)
  BOTTOM w0.076: v2(162.83,66.15) 162.84,66.16 162.84,66.75 163.01,66.92 163.02,66.92 163.3,67.2 163.59,67.2 UC1.AL8
ME_FWP: length 143.1
  TOP w0.102: RC9.1 v6(174.12,52.68) 176.75,50.05 203.99,50.05 205.5,51.56 205.5,51.94 205.5,52.74 205.71,52.95 206.72,52.95 207.92,54.14 207.92,56.02 208.8,56.91 208.8,57.57 207.61,58.76 207.61,60.14 207.36,60.39 207.36,64.81 209.91,67.37 210.5,67.37 211.29,68.16 v3(215.18,68.16) ; U37.A8 v2(192.33,129.87) 192.61,130.14 192.61,130.18 192.72,130.29 192.72,130.49 R326.1
  IN2 w0.102: v2(192.33,129.87) 193.75,131.28 203.22,131.28 203.37,131.13 203.37,129.9 206.87,126.4 206.87,104.14 209.95,101.07 209.95,91.98 210.94,90.99 210.94,84.87 215.33,80.47 215.33,71.29 215.22,71.18 215.08,71.04 214.93,70.89 214.62,70.58 214.62,68.26 214.72,68.16 v3(215.18,68.16)
ME_RESET#: length 3.8
  BOTTOM w0.102: v1(182.52,81.11) RC76.1 RC81.2 184.42,81 183.53,80.11 UC2.2
ME_SUS_PWR_ACK: length 83.1
  TOP w0.102: v3(186.55,60.01) RC70.2 RC94.1 ; U38.A8 165.94,117.47 v3(165.88,117.41)
  IN2 w0.102: v3(165.88,117.41) 165.4,116.93 165.4,116.37 167.28,114.49 167.99,114.49 168.66,113.82 168.66,112.7 170.23,111.12 172.21,111.12 173.58,109.76 178.81,109.76 183.28,105.29 183.28,103.52 184.1,102.69 184.1,101.34 184.78,100.67 184.78,99.52 185.17,99.12 185.17,97.18 186.38,95.97 188.89,95.97 192.01,92.85 192.01,86.86 191.68,86.53 191.68,83.67 192.48,82.87 192.48,74.89 190.81,73.21 190.81,71.14 190.19,70.52 190.19,64.78 191.2,63.77 191.2,62.7 190.52,62.01 188.56,62.01 v3(186.55,60.01)
  BOTTOM w0.102: v3(186.55,60.01) 186.55,59.9 v1(186.2,59.55)
ME_SUS_PWR_ACK_R: length 31.2
  TOP w0.102: v3(187.19,60.01) 187.24,59.96 187.47,59.96 187.9,60.39 187.9,62.01 187.7,62.22 186.83,62.22 RC94.2 185.18,61.76 RC82.1
  BOTTOM w0.076: UC1.AV4 166.17,63.13 166.45,62.85 166.45,62.21 166.54,62.12 166.54,61.74 167.09,61.2 168.04,61.2 168.74,60.5 170.77,60.5
  BOTTOM w0.102: 170.77,60.5 170.95,60.5 171.97,59.47 173.63,59.47 174.06,59.04 176.11,59.04 176.6,58.56 180.25,58.56 180.53,58.84 180.53,59.69 180.64,59.79 182.96,59.79 183.61,59.14 v1(184.1,59.14) 186.83,59.14 187.19,59.5 v3(187.19,60.01)
MEC_XTAL1: length 7.3
  TOP w0.102: Y4.1 156.59,117.23 156.98,117.62 C364.1 158.82,119.15 v1(158.82,119.8) 158.82,120.04 160.17,121.39 U38.A61
MEC_XTAL2: length 4
  TOP w0.102: v1(156.21,113.26) 156.49,113.26 C365.1 R378.1 157.1,114.73 Y4.2
MEC_XTAL2_R: length 6.9
  TOP w0.102: U38.A62 160,120.89 159.27,120.17 v1(159.27,118.54) 159.27,117.88 157.3,115.9 R378.2
MED_DET#: length 179
  TOP w0.102: JMED1.4 99.85,179.25 101.15,179.25 v1(101.18,179.21) 101.43,179.21 101.62,179.02 R477.1 100.88,177.58 94.96,177.58 94.71,177.33 94.71,174.73 90.92,170.94 90.92,163.35 89.73,162.15 89.73,158.87 90.29,158.32 90.29,156.86 91.43,155.71 91.43,154.93 v3(91.25,154.75) ; v2(196,119.8) 196.34,120.14 U37.B53
  IN1 w0.097: v2(196,119.8) 195.59,119.39 194.15,119.39 193.23,118.48 193.23,116.82 192.98,116.57 192.09,116.57 191.45,115.92 189.98,115.92 189.51,115.45 182.44,115.45 179.77,112.78 178.29,112.78 175.47,109.96 170.83,109.96 170.35,109.48 164.84,109.48 164.36,109.95 163.54,109.95 162.79,110.71 161.54,110.71 161.45,110.62 157.59,110.62 156.92,109.95 156.92,109.95 156.73,109.95 155.62,109.95 155.62,109.95 154.95,109.95 151.39,113.51 151.39,114.41 148.86,116.95 148.86,132.3 145.74,135.42 143.4,135.42 141.7,133.72 133.16,133.72 132.35,134.53 131.37,134.53 130.45,135.44 130.04,135.44 129.07,136.41 127.68,136.41 125.66,138.43 116.97,138.43 115.84,139.56 115.84,142.66 110.38,148.12 108.91,148.12 102.94,154.09 100.85,154.09 99.91,153.15 92.85,153.15 v3(91.25,154.75)
MEDIACARD_IRQ#: length 359.2
  TOP w0.102: v3(188,79.06) 187.84,78.89 RP12.8
  IN1 w0.097: v3(12.97,25.95) 13.61,26.58 17.82,26.58 v2(18.32,26.08) ; v3(188,79.06) 195.62,79.06 197.69,76.99 197.94,76.99 v3(197.94,76.99)
  IN2 w0.076: v2(165.03,72.98) 165.57,73.52 167.73,73.52 168.77,74.56 170.88,74.56
  IN2 w0.102: v3(12.97,25.95) 13.17,25.74 13.17,22.72 18.96,16.93 30.72,16.93 32.6,18.81 33.26,18.81 34.92,20.46 37.15,20.46 39.64,22.95 42.79,22.95 43.35,22.39 54.42,22.39 54.52,22.29 64.84,22.29 65.57,23.02 76.85,23.02 77.16,23.33 79.43,23.33 83.96,18.79 83.96,18.13 86.74,15.35 93.81,15.35 93.97,15.52 114.58,15.52 117.14,12.97 138.3,12.97 140.69,10.58 150.02,10.58 152.1,12.66 226.09,12.66 228.95,15.52 228.95,26.05 229.07,26.17 229.07,31.55 217.1,43.52 216.55,43.52 209.96,50.11 209.96,50.79 210.23,51.05 210.23,52.35 209.04,53.53 207.93,53.53 206.59,54.87 206.59,55.35 204.35,57.59 201.23,57.59 196.92,61.9 196.92,63.23 198.47,64.77 198.47,68.08 198.95,68.57 198.95,75.63 197.94,76.63 v3(197.94,76.99) ; v3(188,79.06) 185.74,79.06 183.13,81.66 181.65,81.66 180.97,80.97 180.97,80.66 180.8,80.49 179.94,80.49 178.55,79.11 176.27,79.11 173.74,76.57 172.96,76.57 170.94,74.56 170.88,74.56
  BOTTOM w0.076: UC1.AB6 164.86,72.8 v2(165.03,72.98)
  BOTTOM w0.102: v2(18.32,26.08) 18.32,25.81 v1(18.53,25.6) U27.16
MEDIACARD_PWREN: length 307
  IN2 w0.102: v2(17.47,22.74) 17.47,22.49 16.42,21.45 16.42,20.38 18.53,18.27 29.71,18.27 34,22.57 36.57,22.57 38.81,24.81 49.29,24.81 50.17,23.94 60.55,23.94 60.88,23.61 63.57,23.61 64.84,24.88 65.08,24.88 72.84,24.88 73.52,25.56 80.09,25.56 87.02,18.63 91.6,18.63 91.72,18.5 106.85,18.5 107.46,17.89 116.67,17.89 119.67,14.9 138.56,14.9 141.28,12.18 145.28,12.18 145.75,12.65 149.9,12.65 151.8,14.56 169.31,14.56 170.01,15.25 187.14,15.25 187.75,14.64 201.29,14.64 202.71,16.06 226.56,16.06 227.19,16.7 227.19,19.44 225.11,21.53 225.11,25.28 225.42,25.59 225.42,28.64 224.78,29.27 224.78,32.63 206.71,50.69 206.71,50.94 206.09,51.56 206.09,52.96 203.84,55.21 195.54,55.21 195.27,55.47 195.27,55.7 195.03,55.94 193.53,55.94 v3(193.27,55.69)
  BOTTOM w0.102: RC181.1 182.68,62.9 183.01,62.57 183.01,61.91 183.09,61.84 183.68,61.84 183.96,61.56 186.76,61.56 187.07,61.25 188.08,61.25 188.79,60.54 188.79,59.69 188.48,59.39 188.48,58.72 190.58,56.63 190.93,56.63 191.16,56.4 192.56,56.4 v3(193.27,55.69) ; v2(17.47,22.74) 17.55,22.82 18.56,22.82 19.65,23.91 20.06,23.91 20.41,24.27 20.41,24.57 20.19,24.8 U27.14
MEDIACARD_PWREN_R: length 15.9
  BOTTOM w0.076: UC1.AP1 168.26,65.22 168.39,65.22 168.65,64.97 168.68,64.97 168.73,64.92 169.75,64.92 170.27,64.4 170.78,64.4 170.78,64.4
  BOTTOM w0.102: RC181.2 RC175.1 180.5,61.72 178.54,61.72 178.02,61.2 174.92,61.2 172.84,63.28 v1(172.84,63.77) 172.2,64.4 170.85,64.4 170.85,64.4 170.78,64.4
MEDIACARD_RST#: length 363.6
  TOP w0.076: T191.1 164.75,69.81 v2(165.16,70.22)
  TOP w0.102: v2(17.65,33.89) 17.65,33.64 v1(18.32,32.98)
  IN1 w0.097: v3(197.86,75.14) 197.2,75.8 182.57,75.8 182.44,75.93 181.8,75.93 v2(181.47,75.6) ; v3(82.03,30.01) 82.03,30.14 82.72,30.82 83.14,30.82 83.14,30.77 83.9,30.01 83.9,17.92 85.7,16.11 88.12,16.11 88.97,15.26 91.64,15.26 91.93,15.55 93.06,15.55 93.42,15.91 93.42,17.06 93.79,17.44 97.91,17.44 99.82,15.53 114.91,15.53 116.1,14.34 v3(117.11,14.34)
  IN2 w0.076: 170.88,71.93 170.82,71.93 170.09,71.2 169.36,71.2 168.05,69.89 166.13,69.89 166.01,69.76 165.62,69.76 v2(165.16,70.22)
  IN2 w0.102: v3(117.11,14.34) 117.14,14.34 118.28,13.19 138.4,13.19 140.74,10.86 149.97,10.86 152.02,12.9 225.99,12.9 228.72,15.63 228.72,25.46 227.73,26.45 227.73,28.74 228.16,29.17 228.16,32.14 217.09,43.22 216.53,43.22 208.37,51.37 208.37,52.71 203.72,57.36 201.13,57.36 196.69,61.81 196.69,63.32 197.37,64.01 197.37,65.92 197.81,66.36 197.81,75.1 v3(197.86,75.14) ; v2(181.47,75.6) 181.07,76.01 179.92,76.01 178.6,74.69 177.59,74.69 176.22,73.32 175.25,73.32 173.86,71.93 170.88,71.93
  IN3 w0.102: v3(82.03,30.01) 81.68,29.65 77.66,29.65 76.6,30.72 69,30.72 67.02,28.74 67.02,25.54 63.66,22.17 54.49,22.17 53.44,23.21 49.76,23.21 48.35,24.62 37.68,24.62 37.05,23.99 30.27,23.99 29.76,23.48 19.37,23.48 16.75,26.1 16.75,31.03 17.65,31.92 v2(17.65,33.89)
  BOTTOM w0.076: v2(165.16,70.22) 165.16,70.22 165.16,70.23 164.86,69.92 UC1.AG6
MEM_SMBCLK: length 28.5
  TOP w0.102: QC1.6 187.23,75.07 187.05,75.25 186.2,75.25 185.84,74.89 185.41,74.89 RC28.2 184.62,74.71 184.42,74.71 184.29,74.59 184.29,73.12 183.88,72.71 182.41,72.71 180.4,70.7 177.1,70.7 176.75,71.06 175.14,71.06 174.68,70.6 174.46,70.6 172.75,68.9 171.24,68.9 171.05,68.7 171.05,67.89 170.81,67.65 v2(170.81,65.54)
  BOTTOM w0.076: 170.78,65.52 170.35,65.09 168.8,65.09 168.25,65.64 168.02,65.64 167.73,65.34 UC1.AP2
  BOTTOM w0.102: 170.78,65.52 v2(170.81,65.54)
MEM_SMBDATA: length 22.7
  TOP w0.102: QC1.3 185.52,75.92 184.93,75.32 RC30.2 184.6,74.94 184.33,74.94 184.06,74.68 184.06,73.21 183.79,72.94 182.31,72.94 180.31,70.93 177.2,70.93 176.84,71.28 175.05,71.28 174.59,70.83 174.36,70.83 172.66,69.12 171.15,69.12 170.6,68.58 v2(170.6,68.26)
  BOTTOM w0.076: v2(170.6,68.26) 170.05,68.82 169.25,68.82 169.15,68.92 168.42,68.92 168.39,68.95 168.28,68.95 UC1.AH1
MINI2CLK_REQ#: length 202.9
  TOP w0.102: v3(182.31,79.39) 182.31,79.29 182.7,78.89 RP11.5
  IN2 w0.102: v3(175.66,76.28) 175.9,76.52 176.19,76.52 177,77.33 177.49,77.33 178.26,78.1 179.21,78.1 180.03,78.92 181.92,78.92 182.31,79.31 v3(182.31,79.39)
  IN3 w0.102: v3(182.31,79.39) 183.45,80.53 183.45,85.65 183.24,85.87 183.24,86.36 182.57,87.03 182.57,90.2 184.13,91.76 186.97,91.76 187.28,91.45 195.98,91.45 203.88,99.35 203.88,100.74 204.6,101.46 205.48,101.46 210.07,106.05 210.07,107.13 216.08,113.14 220.55,113.14 225.58,118.17 225.58,125.51 227.54,127.48 229.71,127.48 237.1,134.86 239.98,134.86 241.56,136.44 247.95,136.44 257.62,146.11 257.62,146.7 258.41,147.48 263,147.48 270.59,155.08 270.91,155.08 272.74,156.91 273.6,156.91 276.19,159.5 v3(276.19,160.29)
  BOTTOM w0.076: UC1.N1 168.74,77.33 168.89,77.18 169.31,77.18 169.33,77.16 169.62,77.16 169.64,77.18 170.06,77.18 170.1,77.22 170.78,77.22
  BOTTOM w0.102: v3(276.19,160.29) 280.2,164.3 280.2,168.69 282.44,170.93 v1(282.44,172.85) 282.44,173.44 291.2,182.2 292.45,183.45 298.99,183.45 300.76,185.23 302.83,185.23 304.3,186.69 JMINI1.7 ; 170.78,77.22 171.31,77.22 171.45,77.09 171.48,77.05 171.76,76.78 171.76,76.78 171.81,76.73 171.94,76.59 171.98,76.59 173.24,76.59 173.73,76.11 175.49,76.11 v3(175.66,76.28)
MINI_CARD_RST#: length 89.9
  IN3 w0.102: v3(248.48,151.08) 248.15,151.41 248.15,154.37 251.27,157.49 256.13,157.49 259.96,157.49 260.87,158.41 263.21,158.41 273.22,168.41 276.49,168.41 276.74,168.67 276.75,168.67 280.99,172.91 288.76,172.91 v3(291.07,175.22)
  BOTTOM w0.102: JMINI2.22 246.31,152.9 247.4,151.82 U30.4 248.24,151.82 248.25,151.8 R26.1 248.73,151.34 v3(248.48,151.08) ; JMINI1.22 313.5,178.14 313.2,177.84 313.2,176 311.6,174.41 v1(311.39,174.41) 291.89,174.41 v3(291.07,175.22)
MMICLK_REQ#: length 231.9
  IN1 w0.076: 154.04,81.06 154.6,80.5 154.96,80.5 156.09,79.37 v2(156.49,79.37)
  IN1 w0.097: 154.04,81.06 152.54,82.56 150.79,82.56 149.27,84.09 147.72,84.09 146.9,84.9 v2(146.9,85.2)
  IN2 w0.076: v2(169.83,71.74) 170.47,72.38 170.88,72.38
  IN2 w0.102: 170.88,72.38 173.67,72.38 175.06,73.77 175.83,73.77 176.19,74.13 176.19,74.9 177.78,76.49 178.43,76.49 v2(178.86,76.92)
  IN3 w0.076: 169.38,72.2 169.29,72.29 168.8,72.29 168.14,72.95 168.14,74.77 v2(169.23,75.87) 168.82,76.28 168.39,76.28 168.2,76.08 166.25,76.08 166.16,76.17 164.84,76.17 164.79,76.22 163.48,76.22 163.03,75.78 162.35,75.78
  IN3 w0.102: 162.35,75.78 161.08,75.78 159.38,77.48 157.72,77.48 156.49,78.71 v2(156.49,79.37) ; v2(18.93,26.09) 18.99,26.09 20.26,27.37 20.26,33.11 21.78,34.63 23.43,34.63 24.73,33.34 28.95,33.34 30.5,34.89 30.5,50.91 48.61,69.02 48.61,74.92 56.73,83.04 62.25,83.04 64.74,80.56 64.74,78.4 68.27,74.87 83.89,74.87 85.37,73.39 94.98,73.39 97.09,71.29 97.29,71.08 98.64,71.08 99.2,70.52 104.63,70.52 106.82,72.71 106.82,73.82 106.98,73.98 108.95,73.98 111.4,73.98 113.01,75.59 117.93,75.59 118.89,76.55 118.89,77.72 120.5,79.33 123.66,79.33 125.9,81.57 128.42,81.57 132.86,86.01 144.89,86.01 145.1,85.8 145.72,85.8 146.35,85.18 146.88,85.18 v2(146.9,85.2) ; v2(169.83,71.74) 169.38,72.2
  BOTTOM w0.076: UC1.U2 167.95,75.54 168.33,75.54 168.4,75.48 169.01,75.48 169.23,75.7 v2(169.23,75.87)
  BOTTOM w0.102: v2(18.93,26.09) 19.03,26 U27.17 ; v2(178.86,76.92) 178.86,77.46 RC55.2
MODC_EN: length 118.8
  TOP w0.102: U29.4 230.77,44.1 231.16,44.49 231.16,45.86 v3(230.27,46.75) ; U37.B7 193.08,127.72 v2(193.36,127.45)
  IN2 w0.102: v2(193.36,127.45) 193.77,127.45 196.89,130.57 201.8,130.57 201.99,130.57 204.04,128.52 204.31,128.25 204.31,109.27 206.15,107.43 206.15,102.21 207.28,101.08 207.28,98.86 209.49,96.65 209.49,90.18 v3(210.12,89.55)
  BOTTOM w0.102: v3(230.27,46.75) 231.66,46.75 232.17,47.26 232.17,55.84 226.53,61.48 v1(226.53,64.21) 226.53,70.33 227.62,71.42 227.75,71.55 227.75,76.31 226.07,77.99 225.8,77.99 220.79,83 220.79,87.98 219.56,89.22 210.46,89.22 v3(210.12,89.55)
MPCIE_RST#: length 150.2
  IN2 w0.102: v3(181.67,79.39) 181.29,79.77 180.19,79.77 178.84,78.42 176.67,78.42 173.52,75.27 173.52,75.08 172.19,73.75 172.19,73.33 172.04,73.18 v2(172.04,73.11)
  IN3 w0.102: v3(181.67,79.39) 183.23,80.94 183.23,85.56 183.01,85.78 183.01,86.26 182.34,86.93 182.34,90.29 184.06,92.01 187.12,92.01 187.94,92.83 197.04,92.83 203.65,99.45 203.65,100.83 204.51,101.69 205.39,101.69 209.85,106.14 209.85,107.23 215.99,113.37 220.46,113.37 225.35,118.27 225.35,125.61 227.45,127.7 228.7,127.7 236.08,135.09 239.89,135.09 241.47,136.67 247.86,136.67 256.86,145.67 v3(256.86,146.24)
  BOTTOM w0.076: 170.78,74.62 170.7,74.62 170.53,74.8 169.66,74.8 169.55,74.69 168.49,74.69 UC1.V1
  BOTTOM w0.102: 170.78,74.62 170.79,74.62 170.81,74.61 170.89,74.61 172.04,73.46 v2(172.04,73.11) 172.04,72.96 172.48,72.52 173.32,72.52 RC138.2 ; v3(256.86,146.24) 256.84,146.26 256.84,146.79 253.06,150.57 v1(250.96,150.57) 248.28,150.57 247.69,151.17 U30.2
MPHYP_PWR_EN: length 76.9
  TOP w0.102: Q143.2 162.03,108.75 162.21,108.93 162.21,109.72 161.45,110.48 159.97,110.48 159.84,110.6 v1(158.66,110.6) 158.27,110.21 v3(157.85,110.21) 157.44,110.63 U94.4
  IN2 w0.102: v2(178.43,95.13) 175.1,98.46 175.1,100.89 173.93,102.06 173.93,104.93 170.69,108.16 167.92,108.16 166.93,109.16 158.75,109.16 157.85,110.06 v3(157.85,110.21)
  IN3 w0.102: v2(178.43,95.13) 177.94,94.65 177.94,93.81 176.29,92.16 175.3,92.16 170.73,87.6 170.73,82.71 173.35,80.1 173.35,79.84 174.18,79 174.18,77.61 171.54,74.97 171.54,73.24 v2(171.42,73.11)
  BOTTOM w0.076: UC1.Y2 167.49,73.59 167.95,74.04 168.23,74.04 168.25,74.06 168.26,74.06 168.42,74.22 168.42,74.23 168.71,74.52 169.73,74.52 169.84,74.64 170.45,74.64 170.77,74.32 170.78,74.32
  BOTTOM w0.102: RC170.1 RC169.1 174.64,71.61 172.43,71.61 171.42,72.63 v2(171.42,73.11) 171.42,73.76 170.85,74.32 170.78,74.32
MPHYP_PWR_EN#: length 3.4
  TOP w0.102: R108.2 164.02,108.75 Q143.5 ; R108.2 164.29,109.4 Q143.6 ; R108.2 165.22,109.94 v1(165.42,109.94)
MSATA_DEVSLP: length 160.1
  IN3 w0.102: v3(181.07,76.85) 181.07,77.56 183.68,80.17 183.68,85.75 183.46,85.97 183.46,86.45 182.79,87.12 182.79,90.1 184.22,91.53 186.87,91.53 187.18,91.22 195.77,91.22 195.77,91.22 196.08,91.22 204.11,99.26 204.11,100.65 204.7,101.23 205.58,101.23 210.3,105.96 210.3,107.04 216.18,112.91 220.64,112.91 225.81,118.08 225.81,125.42 227.64,127.25 229.97,127.25 237.35,134.63 240.08,134.63 241.64,136.2 248.03,136.2 258.78,146.94 v2(258.78,147.04)
  BOTTOM w0.076: 170.24,76.99 170.23,76.99 170.21,77.01 169.71,77.01 169.69,76.99 169.26,76.99 169.24,77.01 168.58,77.01 168.57,77.02 167.93,77.02 UC1.P2
  BOTTOM w0.102: v2(258.78,147.04) 258.7,147.04 v1(258.11,147.63) 248.72,157.02 248.72,159.13 247.59,160.26 245.51,160.26 245.3,160.46 R480.1 244.35,161.96 244.08,161.7 JMINI2.44 ; v3(181.07,76.85) 181.07,76.55 180.75,76.24 178.02,76.24 177.77,75.98 176.86,75.98 176.69,75.81 175.62,75.81 175.54,75.88 173.63,75.88 173.14,76.36 171.85,76.36 171.66,76.55 171.29,76.92 171.22,76.99 170.24,76.99
MSCLK: length 105.7
  TOP w0.102: v3(218.91,92.52) 219.19,92.24 219.19,91.88 v1(219.47,91.61) 219.8,91.27 221.12,91.27 R395.2 222.19,92.34 222.19,93.31 222.93,94.05 JDEG1.6 ; U38.B43 166.19,127.72 167,126.91 v2(167,126.88)
  IN1 w0.097: v3(165.27,136.46) 164.84,136.03 164.84,135.11 165.17,134.78 165.17,131.37 165.79,130.74 165.79,130.74 165.88,130.66 165.88,130.01 166.54,129.35 166.54,127.11 166.77,126.88 v2(167,126.88)
  BOTTOM w0.102: v3(165.27,136.46) 165.07,136.26 164.76,136.26 164.61,136.41 164.61,136.92 165.09,137.4 171.64,137.4 171.92,137.68 174.47,137.68 174.84,137.31 174.84,135.71 177.23,133.33 177.23,131.91 179.67,129.48 179.67,123.58 179.87,123.38 179.87,114.86 185.88,108.85 186.78,108.85 189.65,105.98 192.8,105.98 203.11,95.67 204.16,95.67 204.54,95.29 205.41,95.29 205.56,95.13 205.58,95.13 206.4,94.32 208.42,92.29 217.64,92.29 217.97,92.62 218.81,92.62 v3(218.91,92.52)
MSDATA: length 102.4
  TOP w0.102: v3(218.91,93.15) 219.14,93.38 221.38,93.38 221.58,93.18 R398.2 221.96,93 221.96,93.64 v1(222.87,94.55) JDEG1.7 ; R366.2 167.15,131.25 v2(166.34,130.44) 166.44,130.33 166.44,129.43 166.44,129.43 U38.A40
  IN1 w0.097: v3(165.24,135.8) 165.4,135.65 165.4,132.98 166.34,132.04 v2(166.34,130.44)
  BOTTOM w0.102: v3(218.91,93.15) 218.79,93.03 218.05,93.03 217.54,92.52 208.52,92.52 206.62,94.41 205.67,95.36 205.65,95.36 205.5,95.52 204.64,95.52 204.26,95.9 203.2,95.9 192.89,106.21 189.75,106.21 186.88,109.08 185.98,109.08 180.1,114.96 180.1,123.47 179.9,123.68 179.9,129.57 177.46,132.01 177.46,133.42 175.07,135.81 175.07,137.4 174.56,137.91 171.83,137.91 171.55,137.63 165,137.63 164.38,137.01 164.38,136.31 164.67,136.03 165.01,136.03 v3(165.24,135.8)
NB_PSID: length 49.9
  TOP w0.254: v3(121.4,145.58) 121.92,145.58 122.14,145.35 PL3.1
  IN1 w0.254: v3(90.29,159.55) 90.29,160.31 92.01,162.04 97.81,162.04 99.46,160.39 104.99,160.39 106.87,158.51 107.92,158.51 112.56,153.86 113.66,153.86 121.4,146.11 v3(121.4,145.58)
  BOTTOM w0.254: PJPDC1.1 92.09,153.92 92.09,153.91 92.08,153.9 89.45,153.9 89.18,154.16 89.18,156.76 90.29,157.86 v1(90.29,158.05) v3(90.29,159.55)
NB_PSID_TS5A63157: length 7.5
  TOP w0.102: PD5.1 129.85,136.37 130.46,135.76 130.46,135.42 v1(130.42,135.38)
  TOP w0.254: PD5.1 129.8,136.7 129.98,136.88 131,136.88 131.62,137.49 PU1.3 131.62,138.44 130.41,139.64 PR8.2 PR9.2
NVVDD_GND_SENSE: length 138.6
  IN1 w0.315: v2(62.45,81.37) 62.71,81.62 63.41,81.62 63.72,81.31 68.74,81.31 74.59,87.16 74.59,90.42 74.26,90.75 73.09,91.92 73.09,93.61 72.13,94.58 72.13,98.21 73.27,99.35 73.27,102.91 72.03,104.15 72.03,104.94 71.26,105.7 71.26,105.96 v3(71.39,106.08)
  IN3 w0.338: v3(55.26,24.68) 54.45,24.68 54.09,24.32 54.09,23.82 54.45,23.47 58.17,23.47 59.5,24.8 60.39,24.8 61.12,24.07 63.12,24.07 66.17,27.13 66.17,29.09 66.17,29.11 68.66,31.6 77.19,31.6 78.17,30.62 80.97,30.62 82.54,32.19 82.54,48.34 83.47,49.27 83.47,54.65 77.45,60.67 77.45,63.31 75.73,65.03 75.73,69.9 73.24,72.39 66.24,72.39 61.66,76.97 61.66,80.31 62.45,81.1 v2(62.45,81.37)
  BOTTOM w0.254: UV1.F1 71.03,106.44 v3(71.39,106.08)
  BOTTOM w0.267: v3(55.26,24.68) 55.34,24.59 55.34,23.34 55.05,23.05 PR615.1
NVVDD_SENSE: length 138.5
  IN1 w0.315: v3(70.53,106.06) 70.53,105.68 71.42,104.79 71.42,103.95 72.71,102.66 72.71,99.58 71.56,98.44 71.56,94.35 72.53,93.38 72.53,91.68 74.03,90.19 74.03,87.39 68.51,81.88 64.02,81.88 63.69,82.21 62.47,82.21 61.71,81.44 v3(61.71,81.44)
  IN3 w0.338: v2(49.7,25.16) 50.64,26.1 60.14,26.1 61.43,24.81 62.66,24.81 65.43,27.59 65.43,29.41 68.36,32.35 77.64,32.35 78.58,31.41 80.68,31.41 81.79,32.51 81.79,48.64 82.73,49.58 82.73,54.34 76.71,60.36 76.71,63 74.99,64.73 74.99,64.86 74.99,64.86 74.99,68.86 72.2,71.65 65.94,71.65 60.91,76.68 60.91,80.63 61.71,81.43 v3(61.71,81.44)
  BOTTOM w0.254: UV1.F2 70.51,106.06 v3(70.53,106.06)
  BOTTOM w0.267: v2(49.7,25.16) 49.39,25.16 49.09,24.85 PR618.1
O-USR: length 7.5
  BOTTOM w0.102: PR309.1 77.41,94.56 v1(77.41,94.07)
  BOTTOM w0.203: PR304.2 79.3,94.46 79.95,94.46 81.36,93.05 82.56,93.05 82.88,92.74 PU300.9
  BOTTOM w0.254: PR309.1 PR304.2
OCP-I: length 3.4
  BOTTOM w0.203: PU300.12 v1(84.08,93.56) 84.08,94.52 PR301.2
  BOTTOM w0.254: PR306.1 83.63,94.58 PR301.2
ODD_DA#: length 144
  TOP w0.102: RC137.2 178.83,92.09 v2(178.73,91.99) ; v2(219.09,42.86) v1(219.76,42.86)
  IN1 w0.097: v2(219.09,42.86) 219.62,42.86 219.93,43.17 219.93,45.81 221.68,47.56 226.48,47.56 227.14,48.22 227.14,51.09 228.11,52.06 229.96,52.06 230.44,51.57 230.44,50.66 232.95,48.16 232.95,39.43 233.61,38.77 v3(234.08,38.77)
  IN2 w0.076: 170.88,77.91 170.83,77.86 170.83,77.41 170.2,76.77 168.44,76.77 167.83,76.16 166.23,76.16 166.17,76.09 164.84,76.09 v2(164.55,75.8)
  IN2 w0.102: v3(214.6,41.95) 214.6,42.21 207.41,49.39 206.9,49.39 205.17,51.12 205.17,51.88 202.71,54.34 191.15,54.34 189.27,56.22 184.9,56.22 182.89,54.22 180.15,54.22 178.99,55.37 178.99,56.23 178.24,56.98 176.39,56.98 v3(174.79,58.58) ; 170.88,77.91 171.85,78.88 171.85,79.2 172.41,79.75 172.41,83.2 172.33,83.27 172.33,87.29 175.38,90.33 177.28,90.33 178.73,91.78 v2(178.73,91.99)
  IN3 w0.076: v2(164.55,75.8) 164.97,75.37 165.38,75.37 165.68,75.67 166.14,75.67 166.35,75.88 167.38,75.88 167.86,75.4 167.86,66.48 168.18,66.17 168.18,63.27 170.17,61.28 171.03,61.28
  IN3 w0.102: v3(174.79,58.58) 172.1,61.28 171.03,61.28
  BOTTOM w0.076: v2(164.55,75.8) 164.86,75.49 UC1.U6
  BOTTOM w0.102: JSATA2.11 234.35,39.04 v3(234.08,38.77) ; v2(219.09,42.86) 218.18,41.95 v3(214.6,41.95)
P33ALW: length 2.3
  TOP w0.254: PR553.1 135.38,156.62 134.15,156.62 134.07,156.7 PU701.18
P33ALW2: length 3.9
  TOP w0.254: PR550.2 134.68,150.05 v1(134.46,150.27) 134.23,150.5 133.42,150.5 132.65,151.28 PU701.9
P50ALW: length 4.7
  TOP w0.254: PR536.1 127.63,161.12 127.19,160.69 127.19,159.03 127.41,158.81 127.88,158.81 128.65,158.04 PU701.27
PANEL_BKEN_CVT: length 45.8
  TOP w0.102: R2586.1 v3(113.54,120.95) ; v2(144.4,111.05) U87.1 145.77,111.05 145.95,110.87 145.95,109.38 v1(145.9,109.33) ; U52.44 114.42,123.36 v3(114.39,123.33)
  IN1 w0.097: v2(144.4,111.05) 143.95,111.5 140.9,111.5 137.13,115.28 119.57,115.28 115.43,119.42 115.43,122.29 v3(114.39,123.33)
  BOTTOM w0.102: v3(113.54,120.95) 114.58,120.95 114.99,121.36 114.99,122.73 v3(114.39,123.33)
PANEL_BKEN_EC: length 55.3
  TOP w0.102: v3(154.37,113.02) 152.54,113.02 v1(151.89,112.36) 151.73,112.2 147.87,112.2 147.23,112.84 141.77,112.84 140.55,112.84 140.46,112.75 D80.3 ; U37.A35 189.33,117.84 v2(188.95,117.46)
  IN1 w0.097: v2(188.95,117.46) 188.57,117.08 188.15,117.08 187.82,117.41 187.42,117.41 187.19,117.18 183.84,117.18 183.38,117.64 181.94,117.64 178.73,114.42 177.62,114.42 174.93,111.73 168.62,111.73 167.93,111.04 165.48,111.04 165.01,111.52 164.4,111.52 163.64,112.27 163.44,112.27 163.44,112.27 162.14,112.27 160.89,112.27 160.8,112.18 158.04,112.18 158.04,112.19 156.94,112.19 156.27,111.52 155.87,111.52 v3(154.37,113.02)
PANEL_BKLEN: length 45.9
  TOP w0.102: U87.2 146.2,111.7 v2(146.24,111.75) 146.66,112.17 v1(146.66,112.34)
  BOTTOM w0.076: 164.1,90.18 164.1,89.7 163.02,88.62 163.02,85.35 162.69,85.02 UC1.A9
  BOTTOM w0.102: 164.1,90.18 164.56,90.64 164.56,90.68 164.71,90.83 164.71,93.81 163.62,94.9 163.59,94.9 160.18,98.31 159.27,98.31 155.87,101.71 150.84,101.71 150.08,100.95 146.85,100.95 144.77,103.03 144.77,107.59 144.98,107.8 146.57,109.39 146.57,111.42 v2(146.24,111.75)
PBAT_PRES#: length 191.5
  TOP w0.102: v3(88.69,157.15) 88.69,165.09 89.37,165.77 89.37,166.79 v2(88.46,167.7) ; v3(150.13,159.12) 150.13,158.99 150.31,158.81 v1(150.71,158.81) 150.89,158.99 PQ506.1 ; U37.B40 190.59,119.73 v2(190.68,119.83)
  TOP w0.254: v2(147.59,143.9) 147.59,143.47 147.78,143.28 PU502.1 ; v2(134.66,144.36) 134.53,144.36 PD4.1 134.12,145.3 PR2.2
  IN1 w0.097: v3(88.69,157.15) 89.06,156.78 90.56,156.78 91.96,155.38 98.67,155.38 99.77,156.48 103.44,156.48 103.93,155.99 104.79,155.99 119.62,141.16 128.73,141.16 130.64,139.25 131.41,139.25 131.92,138.75 133.19,138.75 v3(133.67,139.23) 133.67,138.94 136.22,136.39 141.47,136.39 143.39,138.31 146.78,138.31 152.24,132.85 152.24,130.64 153.76,129.12 153.76,125.67 153.06,124.96 153.06,116.98 154.05,115.99 154.05,114.55 155.21,113.39 158.45,113.39 158.57,113.52 160.38,113.52 160.5,113.4 161.03,113.4 161.49,112.94 161.86,112.94 161.86,112.94 163.71,112.94 163.72,112.94 163.92,112.94 164.58,112.28 172.99,112.28 173.71,113 175.08,113 176.95,114.87 178.55,114.87 181.76,118.08 183.72,118.08 184.09,117.72 187.08,117.72 187.44,118.08 188.93,118.08 v2(190.68,119.83) ; v2(147.59,143.9) 146.57,144.92 135.22,144.92 v2(134.66,144.36)
  BOTTOM w0.102: v3(133.67,139.23) 133.67,143.37 v2(134.66,144.36) ; v2(147.59,143.9) 147.59,146.24 150.13,148.78 v3(150.13,159.12) ; PR4.2 v2(88.46,167.7)
PBAT_SMBCLK: length 116.2
  TOP w0.102: RP15.1 158.45,126.92 v2(158.52,126.85) 158.94,126.43 158.94,124.64 159.15,124.44 159.39,124.44 159.94,123.89 U38.A56
  IN1 w0.097: v2(158.52,126.85) 158.75,127.07 158.75,129.77 158.79,129.82 158.79,132.73 158.46,133.06 158.46,134.29 157.72,135.02 157.72,136.21 152.64,141.29 150.46,141.29 149.14,142.61 144.43,142.61 143.23,141.41 142.16,141.41 141.79,141.04 138.97,141.04 136.52,143.5 132.95,143.5 132.31,144.14 121.04,144.14 115.47,149.71 115.47,150.7 114.44,151.73 113.4,151.73 107.84,157.28 106.77,157.28 105.27,158.78 104.99,159.06 104.99,159.06 104.63,159.42 98.23,159.42 97.22,160.43 91.95,160.43 91.07,159.55 91.07,159.23 90.6,158.76 89.92,158.76 89.51,159.18 89.51,161.74 93.17,165.4 93.17,166.72 92.61,167.29 90.75,167.29 88.89,169.15 88.89,173.6 88.73,173.76 v3(88.72,173.76)
  BOTTOM w0.102: PR3.2 88.61,173.07 88.87,173.33 88.87,173.62 v3(88.72,173.76)
PBAT_SMBDAT: length 118.6
  TOP w0.102: v2(159.13,126.92) 158.63,127.42 RP15.2 ; U38.B59 162.17,124.14 162.3,124.27 v2(162.3,124.24)
  IN1 w0.097: v2(162.3,124.24) 161.1,125.44 159.27,125.44 159.02,125.69 159.02,126.81 v2(159.13,126.92) 158.97,127.08 158.97,129.68 159.01,129.72 159.01,132.82 158.68,133.15 158.68,134.38 157.95,135.11 157.95,136.3 152.74,141.51 150.55,141.51 149.23,142.83 144.33,142.83 143.13,141.63 142.07,141.63 141.7,141.26 139.07,141.26 136.61,143.72 136.42,143.72 133.04,143.72 132.4,144.36 121.14,144.36 115.7,149.8 115.7,150.79 114.53,151.95 113.49,151.95 108.93,156.51 107.94,157.51 106.86,157.51 105.49,158.87 105.08,159.28 104.72,159.65 98.32,159.65 97.31,160.66 91.86,160.66 90.84,159.64 90.84,159.32 90.51,158.99 90.01,158.99 89.73,159.27 89.73,161.65 93.39,165.31 93.39,166.82 92.7,167.51 90.85,167.51 89.11,169.24 89.11,173.53 89.35,173.76 v4(89.36,173.76)
  BOTTOM w0.102: PR5.2 89.31,173.07 89.09,173.29 89.09,173.5 v4(89.36,173.76)
PBATT+_C:
  vias: v1(128.21,181.18) v2(124.73,182.79) v2(125.37,182.79) v2(126,182.79) v2(126.89,182.79) v2(127.78,182.79) v2(128.41,185.33) v2(128.41,184.7) v2(128.41,184.06) v2(128.41,183.43) v2(128.41,182.79) v2(129.05,185.33) v2(129.05,184.7) v2(129.05,184.06) v2(129.05,183.43) v2(129.05,182.79) v2(129.68,185.33) v2(129.68,184.7) v2(129.68,184.06) v2(129.68,183.43) v2(129.68,182.79)
PC_BEEP: length 4.3
  BOTTOM w0.102: R353.1 309.52,163.18 v6(308.73,163.18)
  BOTTOM w0.254: R353.1 R160.1 310.48,161.3 310.84,160.95 310.84,160.94 310.98,160.79 310.99,160.79 C143.1
PC_SPKR: length 3.1
  BOTTOM w0.102: v1(310.4,163.64) 311.12,163.64 311.34,163.41 R387.1 R167.1 C133.1
PCH_ALW_ON: length 43.8
  TOP w0.102: v3(173.9,119.42) 174.16,119.17 RP18.7 ; U38.A23 172.4,122.89 v2(172.46,122.95) ; R416.1 167.6,108.7 171.89,108.7 171.9,108.71 v6(172.91,108.71) 178.36,108.71 180.54,110.88 v3(181.3,110.88)
  IN1 w0.097: v2(172.46,122.95) 174.39,121.02 174.39,119.75 174.06,119.42 v3(173.9,119.42)
  IN2 w0.102: v3(181.3,110.88) 181.04,110.88 179.31,112.61 177.44,112.61 176.53,111.7 173,111.7 172.61,112.09 172.27,112.09 171.62,112.74 171.62,113.58 169.66,115.53 169.66,118.55 170.91,119.8 172.46,119.8 172.58,119.67 173.65,119.67 v3(173.9,119.42)
PCH_AUDIO_EN: length 16.6
  IN1 w0.097: v2(182.03,73.56) 180.83,73.56 180.05,72.78 v2(178.45,72.78)
  BOTTOM w0.076: 170.78,76.11 170.55,76.11 170.08,76.58 UC1.P1
  BOTTOM w0.102: v2(182.03,73.56) RP3.4 ; v2(178.45,72.78) v1(178.05,73.18) 177.82,73.18 177.09,73.92 177.09,74.02 175.45,75.65 173.52,75.65 173.07,76.11 170.78,76.11
PCH_AZ_BITCLK: length 3.8
  TOP w0.076: v2(162.93,60.69) 162.8,60.69 v1(162.37,60.26) 162.37,59.5 RC26.2
  BOTTOM w0.076: v2(162.93,60.69) 162.98,60.74 162.98,62.29 UC1.AW8
PCH_AZ_CODEC_BITCLK: length 246.1
  TOP w0.102: RC26.1 CC5.1 163.03,57.06 163.03,56.27 162.17,55.41 162.17,54.19 v1(163.66,52.7) 166.59,49.77 167.28,49.77 170.32,46.72 170.33,46.72 171.39,45.66 208.32,45.66 212.44,49.77 212.44,50.13 212.61,50.3 212.94,50.63 v2(212.92,50.63)
  IN1 w0.097: v2(212.92,50.63) 214.64,52.36 217.61,52.36 218.46,53.2 220.41,53.2 228.19,60.98 228.19,78.87 235.07,85.75 235.07,91.68 234.68,92.07 234.68,95.36 228.19,101.85 228.19,112.81 229.13,113.75 229.13,121.78 232.66,125.31 253.32,125.31 272.95,144.94 287.06,144.94 290.76,148.64 291.55,148.64 296.15,153.25 300.54,153.25 302.06,154.77 302.06,155.74 302.43,156.12 303.38,157.06 307.71,157.06 v2(308.04,157.4)
  BOTTOM w0.102: v2(308.04,157.4) 307.81,157.63 307.81,158.53 307.97,158.68 R149.1 308.52,158.38 308.52,157.31 308.23,157.02 U17.6
PCH_AZ_CODEC_RST#: length 262.2
  TOP w0.102: RC25.1 163.53,58.32 163.53,56.08 162.69,55.24 162.69,54.35 166.76,50.28 167.45,50.28 v1(168.6,49.14) 171.59,46.14 208.12,46.14 211.9,49.92 211.9,50.46 v2(212.61,51.16)
  IN1 w0.097: v2(212.61,51.16) 214.28,52.83 216.48,52.83 217.96,54.31 220.83,54.31 224.01,57.48 224.01,58.81 227.71,62.52 227.71,79.07 234.59,85.94 234.59,91.48 234.18,91.89 234.18,95.01 227.71,101.47 227.71,113.01 228.65,113.95 228.65,121.99 232.45,125.79 253.12,125.79 272.76,145.43 v3(286.86,145.43) 289.73,148.3 289.73,149.29 290.59,150.15 291.84,150.15 296.29,154.6 301.21,154.6 301.58,154.96 301.58,155.93 302.24,156.59 303.18,157.54 303.58,157.54 303.58,157.54 307.46,157.54 307.79,157.88 308.24,157.88 308.52,157.6 308.52,157.14 308.65,157.01 309.16,157.01 309.26,157.11 309.27,157.11 309.49,157.33 309.49,157.34 310.27,158.12 310.84,158.12 310.96,158 v2(310.96,157.39)
  BOTTOM w0.102: U17.11 310.73,157.16 v2(310.96,157.39) ; v3(286.86,145.43) 300.06,145.43 300.34,145.71 R142.1
PCH_AZ_CODEC_SDIN0: length 242.7
  IN1 w0.097: v3(211.32,53) 211.78,53 213.1,54.32 215.23,54.32 215.43,54.11 217.13,54.11 217.77,54.75 220.24,54.75 221.2,55.72 221.2,56.3 222.18,57.28 222.49,57.28 222.85,57.63 222.85,62.71 227.27,67.13 227.27,79.26 234.13,86.12 234.13,91.22 233.7,91.65 233.7,94.86 227.27,101.29 227.27,113.19 228.2,114.13 228.2,122.18 232.27,126.24 252.54,126.24 278.08,151.78 278.69,151.78 291.05,151.78 297.57,158.3 297.57,159.72 298.77,160.92 302.35,160.92 304.36,158.91 308.16,158.91 v2(308.98,158.09)
  BOTTOM w0.089: UC1.AY10 162.52,60.42 165.24,57.7 v1(165.24,57.57) 165.24,57.19 167,55.43 170.45,55.43 170.78,55.76
  BOTTOM w0.102: 170.78,55.76 171.06,56.04 171.43,56.04 173.31,54.16 185.9,54.16 186.58,54.84 186.58,54.98 186.96,55.36 187.65,55.36 188.79,54.22 194.22,54.22 194.92,53.51 205.04,53.51 205.59,54.06 207.62,54.06 208.69,53 v3(211.32,53) ; v2(308.98,158.09) 308.8,158.27 308.8,159.16 R136.1
PCH_AZ_CODEC_SDOUT: length 228.1
  TOP w0.102: RC23.1 v6(175.24,50.67) 176.34,49.57 204.19,49.57 205.51,50.89 207.74,50.89 209,52.15 209.3,52.15 209.64,52.49 211.19,52.49 v3(211.32,52.36)
  IN1 w0.097: v3(211.32,52.36) 211.83,52.36 213.55,54.09 215.14,54.09 215.34,53.89 215.52,53.89 215.61,53.81 217.14,53.81 217.86,54.53 220.6,54.53 223.07,57 223.07,62.62 227.49,67.04 227.49,79.16 234.36,86.03 234.36,91.4 233.95,91.8 233.95,94.92 227.49,101.38 227.49,113.1 228.43,114.04 228.43,122.09 232.36,126.02 252.66,126.02 278.21,151.56 291.34,151.56 297.8,158.02 297.8,159.44 298.38,160.03 301.37,160.03 303.63,157.76 303.67,157.76 307.15,157.76 v2(307.3,157.92)
  BOTTOM w0.102: U17.5 307.73,157.09 307.3,157.52 v2(307.3,157.92) 307.3,158.64 R148.1
PCH_AZ_CODEC_SYNC: length 244.8
  TOP w0.102: v2(212.92,49.93) 212.92,49.57 208.52,45.17 169.08,45.17 v1(164.35,49.9) 160.15,54.1 RC24.1
  IN1 w0.097: v2(212.92,49.93) 213.96,49.93 214.84,50.81 216.06,50.81 217.14,51.88 219.34,51.88 220.19,52.72 220.61,52.72 228.67,60.78 228.67,78.68 235.57,85.58 235.57,95.14 228.67,102.04 228.67,112.53 229.71,113.57 229.71,121.18 232.59,124.06 252.75,124.06 273.14,144.46 287.29,144.46 291,148.17 291.99,148.17 296.03,152.21 301.74,152.21 302.53,153 302.53,155.54 303.58,156.59 309.32,156.59 v2(310.48,157.75)
  BOTTOM w0.102: U17.10 310.23,157.06 310.48,157.31 v2(310.48,157.75)
PCH_AZ_RST#: length 5
  TOP w0.076: RC25.2 163.47,60.03 v2(163.52,60.08)
  BOTTOM w0.076: UC1.AU8 163.58,63.6 163.58,63.06 163.58,63.06 163.58,61.44 163.85,61.17 163.85,60.86 163.9,60.81 163.9,60.46 v2(163.52,60.08)
PCH_AZ_SDIN0_R: length 2.3
  BOTTOM w0.102: R136.2 309.46,158.46 v1(309.46,157.68) 309.46,157.26 309.23,157.03 U17.8
PCH_AZ_SDOUT: length 18.7
  TOP w0.102: v3(171.33,55.56) 171.09,55.31 RC3.2 RC23.2 RC9.2
  BOTTOM w0.076: UC1.AU11 162.2,63.49 162.2,62.98 162.24,62.93 162.24,60.37 163.74,58.87 163.74,57.3 v1(163.97,57.07) 164.33,56.72 165.18,56.72 166.79,55.1 170.78,55.1
  BOTTOM w0.102: v3(171.33,55.56) 170.88,55.1 170.78,55.1
PCH_AZ_SYNC: length 8.9
  TOP w0.102: v2(161.42,62.89) 161.08,62.55 v1(161.08,61.77) 161.08,60.16 161.74,59.5 161.74,57.68 160.15,56.09 RC24.2
  BOTTOM w0.076: UC1.AV11 161.47,62.89 v2(161.42,62.89)
PCH_BATLOW#: length 32
  IN1 w0.076: 169.21,64.5 168.5,64.5 v2(166.53,66.47)
  IN1 w0.097: v3(180.71,67.58) 181.96,66.33 181.96,65.62 181.95,65.61 181.95,65.39 181.95,64.62 181.45,64.12 181.45,63.6 181.25,63.4 181.25,62.96 180.97,62.68 180.97,62.68 178.69,60.4 178.67,60.4 177.88,60.4 172.98,60.4 172.7,60.68 170.64,62.74 170.64,63.5 169.64,64.5 169.21,64.5
  BOTTOM w0.076: v2(166.53,66.47) 166.19,66.13 UC1.AN4
  BOTTOM w0.102: RP3.2 182.67,72.56 181.93,71.82 181.93,70.56 181.08,69.71 181.08,69.31 180.78,69.01 180.29,69.01 v1(179.85,68.57) 179.85,67.88 180.15,67.58 v3(180.71,67.58)
PCH_CL_CLK1: length 238.8
  IN3 w0.076: 170.66,70.95 v2(170.63,70.91)
  IN3 w0.102: 170.66,70.95 170.96,71.24 170.96,71.54 171.69,72.27 172.62,72.27 173.79,73.45 173.79,75.81 175.17,77.2 175.17,80.09 174.42,80.85 174.39,80.87 174.07,80.87 171.72,83.22 171.72,87.18 175.22,90.68 176.56,90.68 178.75,92.87 180.06,92.87 184.94,97.75 190.57,97.75 190.57,97.75 190.76,97.75 190.89,97.62 192.02,97.62 192.21,97.62 192.34,97.49 192.72,97.12 194.33,97.12 197.63,100.42 198.8,100.42 199.96,101.58 199.96,103.3 204.47,107.81 207.13,107.81 215.53,116.2 220.51,116.2 221.56,117.26 221.83,117.26 222.09,117.51 223.21,117.51 224.41,118.71 224.41,126 226.94,128.52 226.94,129.06 230.4,132.52 231.9,132.52 234.92,135.54 235.41,136.03 239.4,136.03 241.03,137.65 247.16,137.65 257.7,148.2 262.7,148.2 271.03,156.52 271.22,156.52 272.9,158.2 273.52,158.2 v4(273.73,158.41)
  BOTTOM w0.076: v2(170.63,70.91) 170.73,71.02 170.73,71.14 170.5,71.37 170.07,71.37 169.85,71.16 168.64,71.16 168.53,71.05 168.02,71.05 167.94,71.13 167.68,71.13 167.53,70.98 167.53,70.63 UC1.AF2
  BOTTOM w0.102: v4(273.73,158.41) 273.93,158.2 277.05,158.2 281.96,163.11 281.96,166.85 281.96,167.04 285.31,170.39 285.31,173.96 293,181.65 302.65,181.65 303.59,182.59 305.32,182.59 305.78,182.13 306.19,182.13 306.29,182.23 306.29,183.32 306.52,183.55 307.12,183.55 307.36,183.32 307.36,182.23 307.46,182.13 307.86,182.13 307.97,182.23 307.97,183.32 308.2,183.55 308.8,183.55 309.03,183.32 309.03,182.23 309.13,182.13 309.54,182.13 309.64,182.23 309.64,183.32 309.88,183.55 310.47,183.55 310.71,183.32 310.71,182.23 310.81,182.13 311.22,182.13 311.32,182.23 311.32,183.32 311.55,183.55 321.16,183.55 323.27,185.67 323.27,186.74 323.05,186.96 322.82,186.96 322.7,187.08 JMINI1.45
PCH_CL_DATA1: length 239.1
  IN3 w0.102: v4(273.75,157.76) 273.75,157.9 273.68,157.97 272.99,157.97 271.31,156.29 271.12,156.29 262.8,147.97 257.79,147.97 247.25,137.43 241.12,137.43 239.5,135.8 235.5,135.8 235.15,135.45 232,132.29 230.5,132.29 227.17,128.97 227.17,128.43 224.64,125.9 224.64,118.62 223.31,117.28 222.18,117.28 221.93,117.03 221.66,117.03 220.6,115.97 215.62,115.97 207.23,107.58 204.56,107.58 200.19,103.21 200.19,101.48 198.9,100.19 197.73,100.19 194.43,96.89 194.24,96.89 194.24,96.89 192.62,96.89 192.12,97.4 190.8,97.4 190.67,97.52 190.57,97.52 185.04,97.52 180.16,92.65 178.84,92.65 176.65,90.46 175.31,90.46 171.95,87.09 171.95,83.32 174.17,81.1 174.49,81.1 174.58,81.01 175.4,80.18 175.4,77.1 174.02,75.72 174.02,73.35 172.71,72.05 171.79,72.05 171.19,71.44 171.19,70.97 v2(171.24,70.91)
  BOTTOM w0.076: UC1.AD2 167.73,71.34 168.19,71.8 168.27,71.8 168.55,72.08 169.33,72.08 169.44,72.2 169.93,72.2 170.37,71.75 170.41,71.71 170.43,71.71
  BOTTOM w0.102: 170.43,71.71 170.58,71.56 171.1,71.56 171.24,71.42 v2(171.24,70.91) ; JMINI1.47 323.5,185.57 321.25,183.32 311.65,183.32 311.55,183.22 311.55,182.14 311.31,181.9 310.72,181.9 310.48,182.14 310.48,183.22 310.38,183.32 309.97,183.32 309.87,183.22 309.87,182.14 309.64,181.9 309.04,181.9 308.8,182.14 308.8,183.22 308.7,183.32 308.3,183.32 308.19,183.22 308.19,182.14 307.96,181.9 307.36,181.9 307.13,182.14 307.13,183.22 307.03,183.32 306.62,183.32 306.52,183.22 306.52,182.14 306.28,181.9 305.69,181.9 305.23,182.36 303.69,182.36 302.75,181.42 293.09,181.42 285.54,173.86 285.54,170.29 282.18,166.94 282.18,163.01 277.15,157.97 273.97,157.97 v4(273.75,157.76)
PCH_CL_RST1#: length 225.6
  IN3 w0.076: 169.79,71.03 169.59,70.83 169.59,69.99 v2(169.94,69.63)
  IN3 w0.102: v3(271.36,157.44) 271.26,157.44 262.5,148.68 257.31,148.68 246.79,138.16 240.85,138.16 239.2,136.51 234,136.51 231.05,133.56 229.99,133.56 225.69,129.27 225.24,129.27 223.19,127.23 223.19,121.18 219.52,117.51 214.85,117.51 206.39,109.05 204.97,109.05 204.31,109.05 197.32,102.06 189.59,102.06 188.31,100.77 185.74,100.77 185.53,100.98 185.03,100.98 180.48,96.43 178.12,96.43 177.66,95.97 176.67,95.97 173.93,93.24 173.93,92.57 172.28,90.92 172.28,89.65 170.37,87.74 170.37,81.94 171.86,80.45 172.15,80.45 173.35,79.26 173.35,77.27 171.09,75.01 171.09,73.71 170.5,73.12 170.5,71.74 169.79,71.03
  BOTTOM w0.076: UC1.AF4 166.52,70.23 166.91,70.23 167,70.13 167.79,70.13 167.94,70.28 168.32,70.28 168.37,70.23 168.85,70.23 168.98,70.11 169.47,70.11 v2(169.94,69.63)
  BOTTOM w0.102: v3(271.36,157.44) 271.92,156.88 277.23,156.88 281.02,160.67 288.08,160.67 290.97,163.56 v6(290.97,165.39) 299.28,173.7 315.38,173.7 318.18,176.49 319.88,176.49 320.56,175.81 326.48,175.81 R223.1
PCH_CL_RST1#_R: length 12.3
  BOTTOM w0.102: JMINI1.49 324.3,187.31 327.17,184.44 v1(327.17,178.29) 327.17,177.41 R223.2
PCH_DPWROK: length 178.1
  TOP w0.076: v2(165.45,60.03) 164.98,59.56 164.62,59.56 RC79.1 164.84,58.81 164.84,58.56
  TOP w0.102: 164.84,58.56 164.84,58.18 165.03,57.99 165.03,55.21 167.21,53.02 167.21,51.98 v6(170.82,48.37) 172.08,47.1 207.72,47.1 210.48,49.86 v3(210.48,50.48) ; R319.1 182.19,130.37 v2(182.07,130.25)
  IN1 w0.097: v3(210.48,50.48) 210.48,51.54 210.15,51.87 210.15,53.59 212.71,56.15 216.53,56.15 220.3,59.92 220.3,65.78 221.66,67.13 221.66,73.87 222.7,74.92 222.7,77.38 216.53,83.55 v3(216.53,93)
  BOTTOM w0.076: v2(165.45,60.03) 165.75,59.73 167.15,59.73 167.32,59.9 167.32,60.13 167.32,60.13 167.32,60.48 167.22,60.57 166.06,60.57 165.5,61.14 165.5,61.51 165.22,61.79 165.22,62.97 UC1.AV5
  BOTTOM w0.102: v3(216.53,93) 216.53,94.12 212.54,98.11 209.29,98.11 208.63,98.77 206.7,98.77 206.16,99.3 204.94,99.3 204.31,99.94 204.31,105.04 197.07,112.28 188.54,112.28 187.85,112.97 186.99,112.97 185.84,114.11 185.84,114.97 183.49,117.32 183.49,118.87 182.75,119.62 182.75,129.56 v2(182.07,130.25)
PCH_GPIO9: length 36.2
  IN3 w0.076: 170.12,60.11 167.66,62.57 167.66,65.95 v2(167.14,66.47)
  IN3 w0.102: v2(192.04,60.79) 190.57,59.32 188.83,59.32 188.05,58.53 185.36,58.53 184.29,59.6 182.93,59.6 182.74,59.79 180.57,59.79 179.37,58.58 177.71,58.58 176.85,57.72 172.98,57.72 172.24,58.46 172.05,58.46 171.86,58.46 171.86,58.46 171.77,58.46 170.12,60.11
  BOTTOM w0.076: UC1.AM3 166.84,66.77 v2(167.14,66.47)
  BOTTOM w0.102: v1(192.73,60.79) v2(192.04,60.79) 192.04,62.27 192.31,62.53 RP14.5
PCH_GPIO15: length 22.9
  TOP w0.102: v3(181.7,76.92) 181.63,76.85 181.63,76.31 v1(181.73,76.21) 182.67,76.21 RC190.2
  IN2 w0.076: v2(165.03,72.03) 165.63,71.43 167.37,71.43 167.64,71.16 168.85,71.16 169.33,71.64 169.33,71.75 170.27,72.68 170.79,72.68
  IN2 w0.102: v3(181.7,76.92) 181.31,77.32 179.78,77.32 179.54,77.56 178.36,77.56 175.94,75.13 175.94,74.2 175.74,74 175.36,74 175.32,74.04 175.01,74.04 173.64,72.68 170.79,72.68
  BOTTOM w0.076: v2(165.03,72.03) 164.86,71.85 UC1.AD6
PCH_GPIO26: length 5.7
  BOTTOM w0.076: UC1.AN3 167.1,65.8 167.61,65.8 167.85,66.04 167.85,66.22 167.91,66.27 168.02,66.39 168.26,66.39 168.58,66.07 170.77,66.07
  BOTTOM w0.102: 170.77,66.07 171.14,66.07 171.39,65.82 v1(171.39,65.39)
PCH_GPIO36: length 22.4
  TOP w0.102: RP10.7 182.71,80.81 182.32,81.2 180.91,81.2 v2(180.58,80.87)
  IN2 w0.076: v2(165.06,74.89) 165.42,74.53 167.17,74.53 167.73,75.09 170.88,75.09
  IN2 w0.102: v2(180.58,80.87) 180,80.87 178.46,79.34 176.18,79.34 173.64,76.8 172.64,76.8 170.93,75.09 170.88,75.09
  BOTTOM w0.076: UC1.V6 164.86,74.69 v2(165.06,74.89)
  BOTTOM w0.102: v2(180.58,80.87) 181.04,80.42 v1(181.13,80.42)
PCH_GPIO44: length 28.4
  TOP w0.102: v3(187.44,76.82) 187.44,76.82 187.68,77.06 187.68,77.29 187.58,77.39 RP12.5
  IN2 w0.102: v2(169.87,68.24) 169.87,68.35 171.09,69.58 171.14,69.58 171.54,69.99 172.9,69.99 173.89,70.98 174.29,70.98 175.71,72.4 178.29,72.4 178.29,72.4 179.45,72.4 182.44,75.39 182.44,75.4 183.14,76.1 184.95,76.1 185.21,76.36 185.21,77.37 185.65,77.81 186.45,77.81 v3(187.44,76.82)
  BOTTOM w0.076: v2(169.87,68.24) 169.51,68.59 169.24,68.59 169.08,68.76 168.36,68.76 168.33,68.79 167.94,68.79 167.79,68.63 167,68.63 166.96,68.67 166.48,68.67 UC1.AK4
  BOTTOM w0.102: v3(187.44,76.82) 187.25,76.63 v1(186.88,76.63)
PCH_GPIO46: length 17.8
  TOP w0.102: v1(179.76,75.7) 179.89,75.58 v2(180.28,75.58)
  IN2 w0.076: v2(167.14,69.47) 168.13,69.47 168.73,70.06 169.37,70.06 169.59,70.28 169.59,70.69 169.92,71.03 170.2,71.03 170.86,71.7 170.88,71.7
  IN2 w0.102: v2(180.28,75.58) 179.15,74.45 177.68,74.45 176.32,73.09 175.34,73.09 173.95,71.7 170.88,71.7
  BOTTOM w0.076: v2(167.14,69.47) 166.84,69.77 UC1.AG3
  BOTTOM w0.102: RC230.2 180.48,75.37 v2(180.28,75.58)
PCH_GPIO48: length 99
  TOP w0.102: v2(211.23,122.24) R76.2 RC286.2
  IN1 w0.076: 173.98,74.48 173.37,75.09 172.95,75.09 172.55,75.5 171.04,75.5 170.78,75.23 169.13,75.23 169.12,75.24 168.74,75.24 168.21,74.72 166.27,74.72 165.79,74.24 v2(165.79,73.96)
  IN1 w0.097: 173.98,74.48 174.13,74.34 175.64,74.34 177.78,76.47 179.78,76.47 179.92,76.62 179.92,76.85 180.32,77.25 180.46,77.25 180.66,77.45 187.78,77.45 188,77.23 189.99,77.23 190.42,77.65 195.08,77.65 195.9,76.83 v2(195.9,76.44)
  IN2 w0.102: v2(212.58,97.43) 212.42,97.59 212.42,101.43 213.58,102.59 213.58,105.38 209.57,109.4 209.57,121.65 210.15,122.24 v2(211.23,122.24)
  IN3 w0.102: v2(212.58,97.43) 212.08,97.93 204.77,97.93 204.46,97.62 204.46,97.06 204.02,96.61 204.02,96.07 204.56,95.53 204.56,94.85 204.05,94.33 203.25,94.33 202.05,93.13 202.05,87.74 200.84,86.53 200.84,83.86 195.9,78.92 v2(195.9,76.44)
  BOTTOM w0.076: UC1.U4 166.19,74.85 165.79,74.45 v2(165.79,73.96)
PCH_GPIO59: length 1
  BOTTOM w0.076: UC1.AT5 165.24,64.12 v2(165.67,63.69)
PCH_GPIO60: length 3.7
  BOTTOM w0.076: UC1.AL2 167.49,67.68 167.87,68.05 168.19,68.05 168.32,68.05 168.52,67.86 169.37,67.86 169.74,67.48 v1(170.77,67.48)
PCH_GPIO66: length 19.6
  TOP w0.102: RC288.1 173.37,93.33 173.97,93.93 173.97,94.06 RC283.2 174.82,93.89 175.53,93.89 175.66,93.76 175.66,93.03 v3(176.04,92.65)
  BOTTOM w0.076: 170.78,85.05 168.75,83.02 168.03,83.02 167.8,82.79 167.8,82.4 167.61,82.2 167.15,82.2 UC1.D3
  BOTTOM w0.102: v3(176.04,92.65) 176.04,91.78 v1(175.64,91.39) 171.52,87.26 171.52,85.79 170.78,85.05
PCH_GPIO73: length 21.8
  TOP w0.102: v2(182.58,60.24) 182.58,59.92 182.92,59.57 182.92,59.12 183.32,58.72 RP13.4
  BOTTOM w0.076: 170.77,60.75 168.87,60.75 168.23,61.39 167.6,61.39 167.2,61.79 167.2,62.06 167.15,62.12 167.15,62.7 166.9,62.95 166.72,62.95 166.53,63.15 166.53,63.35 166.17,63.71 UC1.AU4
  BOTTOM w0.102: 170.77,60.75 171.08,60.75 172.13,59.7 173.78,59.7 174.13,59.35 v1(176.94,59.35) 180.11,59.35 180.31,59.54 180.31,59.78 180.55,60.02 182.36,60.02 v2(182.58,60.24)
PCH_GPIO83: length 32.2
  TOP w0.102: v2(179.31,95.69) v1(179.31,96.6) 179.1,96.81 178.4,96.81 RC290.2 RC85.1
  IN2 w0.076: v2(165.12,76.82) 165.51,76.42 166.03,76.42 166.13,76.53 167.45,76.53 168.07,77.15 170.06,77.15 170.46,77.56
  IN2 w0.102: v2(179.31,95.69) 178.96,95.34 178.96,93.76 176.22,91.02 175.03,91.02 171.36,87.35 171.36,80.63 171.64,80.35 171.64,79.81 170.46,78.62 170.46,77.56
  BOTTOM w0.076: UC1.R6 164.86,76.56 v2(165.12,76.82)
PCH_GPIO84: length 22.9
  TOP w0.102: RC291.2 172.99,96.05 v1(172.74,95.8) 172.33,95.8 v2(172.18,95.95)
  IN2 w0.102: v2(165.65,78.7) 166.06,79.11 166.06,79.99 166.7,80.63 167.12,80.63 169.15,82.66 169.15,88.56 171.36,90.77 171.36,94.3 171.77,94.7 171.77,95.52 171.77,95.53 171.77,95.54 v2(172.18,95.95)
  BOTTOM w0.076: UC1.L6 165.34,78.7 v2(165.65,78.7)
