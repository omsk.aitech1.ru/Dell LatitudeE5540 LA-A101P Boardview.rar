# Allegro board Alpine15_LA-A101PR10-0826C.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_A_D12: length 73.6
  IN1 w0.076: 126.23,64.83 126.41,65.01 126.41,65.59 v2(126.26,65.74)
  IN1 w0.097: 126.23,64.83 125.7,64.3 123.82,64.3 119.77,60.25 117.34,60.25 88.79,31.7 88.79,23.84 88.66,23.71 88.23,23.71 88.13,23.61 88.13,23.42 88.23,23.33 88.52,23.33 88.64,23.21 88.64,23.05 88.52,22.94 88.23,22.94 88.13,22.84 88.13,22.65 88.23,22.55 88.7,22.55 88.96,22.29 88.96,21.32 v2(88.48,20.84)
  BOTTOM w0.076: UC1.AM61 130.68,66.74 130.28,67.14 129.87,67.14 129.7,67.3 129.32,67.3 129.07,67.05 127.63,67.05 126.33,65.74 v2(126.26,65.74)
  BOTTOM w0.102: v2(88.48,20.84) 89.48,19.85 JDIMM1.6
DDR_A_D13: length 74.7
  IN1 w0.097: v2(90.03,24.5) 90.03,21.96 89.91,21.83 89.4,21.83 89.27,21.96 89.27,25.32 89.37,25.42 89.64,25.42 89.75,25.53 89.75,25.69 89.64,25.81 89.26,25.81 89.14,25.92 89.14,26.08 89.26,26.19 89.62,26.19 89.73,26.3 89.73,26.46 89.62,26.58 89.3,26.58 89.12,26.76 89.12,31.59 117.46,59.93 119.89,59.93 123.9,63.94 125.63,63.94 v2(125.93,63.64)
  BOTTOM w0.076: UC1.AM60 131.46,66.08 131.26,65.88 130.42,65.88 130.27,65.95 130.06,65.95 129.9,65.88 129.77,65.88 129.62,65.95 129.23,65.95 128.58,65.3 128.27,65.3 126.61,63.64 v2(125.93,63.64)
  BOTTOM w0.102: v2(90.03,24.5) 89.18,25.35 JDIMM1.5
DDR_A_D14: length 72.9
  IN1 w0.097: v2(126.37,62.15) 126.15,61.94 125.1,61.94 121.15,57.98 117.97,57.98 117.85,57.86 117.85,57.73 118.03,57.55 118.03,57.42 117.89,57.28 117.75,57.28 117.58,57.45 117.44,57.45 117.31,57.32 117.31,57.18 117.48,57.01 117.48,56.87 117.34,56.73 117.21,56.73 117.03,56.91 116.9,56.91 116.76,56.77 116.76,56.63 116.93,56.46 116.93,56.32 116.8,56.19 116.66,56.19 116.49,56.36 116.35,56.36 116.21,56.22 116.21,56.09 116.39,55.91 116.39,55.78 116.25,55.64 116.11,55.64 115.94,55.81 115.8,55.81 115.67,55.68 115.67,55.54 115.84,55.37 115.84,55.23 115.7,55.1 115.57,55.1 115.4,55.27 115.26,55.27 115.12,55.13 115.12,55 115.29,54.82 115.29,54.69 115.16,54.55 115.02,54.55 114.85,54.72 114.71,54.72 114.58,54.59 114.58,54.45 114.75,54.28 114.75,54.14 114.61,54 114.48,54 114.3,54.18 114.17,54.18 114.03,54.04 114.03,53.9 114.2,53.73 114.2,53.59 114.07,53.46 113.93,53.46 113.76,53.63 113.62,53.63 113.48,53.49 113.48,53.36 113.66,53.18 113.66,53.05 113.52,52.91 113.38,52.91 113.21,53.08 113.07,53.08 112.94,52.95 112.94,52.81 113.11,52.64 113.11,52.5 112.97,52.37 112.84,52.37 112.66,52.54 112.53,52.54 112.39,52.4 112.39,52.26 112.56,52.09 112.56,51.96 112.43,51.82 112.29,51.82 112.12,51.99 111.98,51.99 111.85,51.86 111.85,51.72 112.02,51.55 112.02,51.41 111.88,51.27 111.75,51.27 111.57,51.45 111.44,51.45 111.3,51.31 111.3,51.17 111.47,51 111.47,50.86 111.34,50.73 111.2,50.73 111.03,50.9 110.89,50.9 110.75,50.76 110.75,50.63 110.93,50.45 110.93,50.32 110.79,50.18 110.65,50.18 110.48,50.35 110.34,50.35 110.21,50.22 110.21,50.08 110.38,49.91 110.38,49.77 110.24,49.63 110.11,49.63 109.93,49.81 109.8,49.81 109.66,49.67 109.66,49.53 109.83,49.36 109.83,49.22 109.7,49.09 109.56,49.09 109.39,49.26 109.25,49.26 109.12,49.12 109.12,48.99 109.29,48.82 109.29,48.68 109.15,48.54 109.01,48.54 108.84,48.71 108.71,48.71 108.57,48.58 108.57,48.44 108.74,48.27 108.74,48.13 108.61,48 108.47,48 108.3,48.17 108.16,48.17 108.02,48.03 108.02,47.9 108.2,47.72 108.2,47.59 108.06,47.45 107.92,47.45 107.75,47.62 107.61,47.62 107.48,47.49 107.48,47.35 107.57,47.25 107.57,47.09 107.46,46.98 107.3,46.98 107.2,47.08 107.07,47.08 91.51,31.52 91.51,29.45 v2(91.38,29.32)
  BOTTOM w0.076: UC1.AP61 130.58,65.49 130.33,65.74 130.23,65.79 130.1,65.79 130.08,65.78 129.99,65.74 129.99,65.74 129.94,65.71 129.74,65.71 129.58,65.79 129.3,65.79 128.65,65.13 128.34,65.13 126.68,63.47 126.57,63.47 126.37,63.27 v2(126.37,62.15)
  BOTTOM w0.102: v2(91.38,29.32) 91.66,29.32 92.4,28.58 92.4,27.72 92.18,27.5 JDIMM1.15
DDR_A_D15: length 73.4
  IN1 w0.097: v2(128.22,63.83) 128.22,62.81 126.36,60.95 125.44,60.95 121.53,57.04 119.1,57.04 112.69,50.63 104.31,42.25 100.96,38.9 99.69,37.63 98.99,37.63 92.48,31.12 92.48,25.68 92.58,25.58 93.17,25.58 93.28,25.47 93.28,25.31 93.17,25.19 92.61,25.19 92.48,25.07 92.48,24.86 92.61,24.74 92.77,24.74 92.88,24.62 92.88,24.46 92.77,24.35 92.59,24.35 92.48,24.25 92.48,24.06 92.59,23.96 92.73,23.96 92.83,23.87 92.83,23.67 92.73,23.58 92.59,23.58 92.47,23.46 92.47,23.3 92.59,23.19 93.12,23.19 93.21,23.1 93.21,22.9 93.12,22.81 92.64,22.81 92.55,22.71 92.55,22.52 92.64,22.42 93.1,22.42 93.21,22.31 93.21,22.15 93.1,22.03 92.59,22.03 92.48,21.93 92.48,21.75 92.59,21.65 92.82,21.65 92.92,21.54 92.92,21.37 92.82,21.26 92.62,21.26 92.5,21.13 92.5,20.87 92.62,20.74 v2(93.38,20.74)
  BOTTOM w0.076: UC1.AP60 131.24,65.27 131,65.27 130.94,65.2 130.69,65.2 130.68,65.21 130.3,65.21 130.28,65.2 129.87,65.2 129.7,65.04 129.25,65.04 128.85,64.64 128.55,64.64 128.22,64.31 v2(128.22,63.83)
  BOTTOM w0.102: v2(93.38,20.74) 92.48,19.84 JDIMM1.16
DDR_A_D16: length 61.3
  IN3 w0.076: 130.27,62.9 130.83,63.46 131.41,63.46 131.84,63.89 132.3,63.89 132.64,64.23 132.64,65.01 v2(132.28,65.36)
  IN3 w0.102: 130.27,62.9 127.33,59.97 127.33,59.95 126.87,59.49 126.85,59.49 124.08,56.71 124.08,49.35 124.18,49.25 124.55,49.25 124.65,49.15 124.65,48.95 124.55,48.85 124.18,48.85 124.08,48.75 124.08,48.54 124.18,48.44 124.55,48.44 124.65,48.34 124.65,48.14 124.55,48.03 124.18,48.03 124.08,47.93 124.08,47.73 124.18,47.63 124.55,47.63 124.65,47.53 124.65,47.32 124.55,47.22 124.18,47.22 124.08,47.12 124.08,46.92 124.18,46.81 124.55,46.81 124.65,46.71 124.65,46.51 124.55,46.41 124.18,46.41 124.08,46.31 124.08,46.1 124.18,46 124.55,46 124.65,45.9 124.65,45.7 124.55,45.6 124.18,45.6 124.08,45.49 124.08,45.29 124.18,45.19 124.55,45.19 124.65,45.09 124.65,38.45 134.19,28.91 134.19,27.54 136.26,25.46 136.26,23.76 v2(135.88,23.38)
  BOTTOM w0.076: v2(132.28,65.36) 132.61,65.69 UC1.AP58
  BOTTOM w0.102: v2(135.88,23.38) 136.93,23.38 137.78,24.23 JDIMM1.159
DDR_A_D17: length 60.7
  IN3 w0.076: 130.46,63.58 130.76,63.88 131.45,63.88 v2(132.28,64.71)
  IN3 w0.102: 130.46,63.58 127.14,60.26 127.14,60.03 126.79,59.68 126.56,59.68 123.77,56.89 123.77,44.87 123.88,44.77 124.25,44.77 124.35,44.67 124.35,44.46 124.25,44.36 123.88,44.36 123.77,44.26 123.77,44.06 123.88,43.96 124.25,43.96 124.35,43.85 124.35,43.65 124.25,43.55 123.88,43.55 123.77,43.45 123.77,43.24 123.88,43.14 124.25,43.14 124.35,43.04 124.35,42.84 124.25,42.74 123.88,42.74 123.77,42.64 123.77,42.43 123.88,42.33 124.25,42.33 124.35,42.23 124.35,42.03 124.25,41.92 123.88,41.92 123.77,41.82 123.77,41.62 123.88,41.52 124.25,41.52 124.35,41.42 124.35,41.21 124.25,41.11 123.88,41.11 123.77,41.01 123.77,40.75 123.88,40.65 124.22,40.65 124.32,40.55 124.32,40.35 124.22,40.25 123.88,40.25 123.77,40.14 123.77,39.94 123.88,39.84 124.22,39.84 124.32,39.74 124.32,39.53 124.22,39.43 123.89,39.43 123.79,39.33 123.79,39.08 123.89,38.98 124.15,38.98 124.27,38.85 124.27,38.39 133.45,29.22 133.45,28.71 133.55,28.61 133.77,28.61 133.87,28.51 133.87,27.36 135.87,25.36 v2(135.87,24.78)
  BOTTOM w0.076: UC1.AR58 132.61,65.04 v2(132.28,64.71)
  BOTTOM w0.102: JDIMM1.157 137.18,24.34 137.08,24.24 136.63,24.24 136.53,24.34 136.53,25.08 136.43,25.18 135.97,25.18 135.87,25.08 v2(135.87,24.78)
DDR_A_D18: length 63.5
  IN3 w0.076: 126.53,61.77 126.8,61.77 129.05,64.02 129.05,65.24 132.07,68.26 132.44,68.26 132.79,67.91
  IN3 w0.084: 132.79,67.91 132.79,67.11 v2(133.22,66.68)
  IN3 w0.102: 126.53,61.77 125.12,61.77 121.74,58.39 121.74,37.43 130.72,28.44 130.72,28.19 130.72,27.52 133.47,24.78 133.47,22.61 v2(134.34,21.73)
  BOTTOM w0.076: UC1.AM57 133.54,66.99 v2(133.22,66.68)
  BOTTOM w0.102: v2(134.34,21.73) 133.88,21.27 JDIMM1.146
DDR_A_D19: length 64.7
  IN3 w0.076: v2(133.19,67.96) 132.73,68.42 131.2,68.42 130.28,67.5 130.28,67 126.44,63.17 125.63,63.17 125.63,63.17
  IN3 w0.102: 125.63,63.17 121.43,58.97 121.43,37.3 130.42,28.31 130.42,27.39 133.16,24.66 133.16,22 133.26,21.9 133.54,21.9 133.65,21.79 133.65,21.59 133.54,21.49 133.26,21.49 133.16,21.39 133.16,21.18 133.26,21.08 133.54,21.08 133.65,20.98 133.65,20.78 133.54,20.68 133.39,20.68 133.29,20.57 133.29,20.31 133.39,20.21 v2(134.34,20.21)
  BOTTOM w0.076: UC1.AK57 133.51,68.29 v2(133.19,67.96)
  BOTTOM w0.102: v2(134.34,20.21) 134.48,20.07 JDIMM1.148
DDR_A_D20: length 63.3
  IN3 w0.076: 126.53,61.1 126.67,61.1 129.53,63.96 129.53,64.93 131.87,67.27 v2(132.29,67.27)
  IN3 w0.102: 126.53,61.1 125.82,61.1 125.32,61.1 124.61,60.4 124.61,59.75 122.35,57.48 122.35,38.3 123.79,36.86 123.79,36.72 123.7,36.62 123.7,36.48 123.84,36.34 123.98,36.34 124.08,36.43 124.22,36.43 124.36,36.28 124.36,36.14 124.27,36.05 124.27,35.9 124.41,35.76 124.56,35.76 124.65,35.85 124.79,35.85 124.97,35.68 124.97,35.53 124.88,35.44 124.88,35.3 125.02,35.15 125.17,35.15 125.26,35.24 125.4,35.24 125.55,35.1 125.55,34.96 125.45,34.86 125.45,34.72 125.6,34.58 125.74,34.58 125.84,34.67 125.98,34.67 126.12,34.52 126.12,34.38 126.03,34.29 126.03,34.14 126.17,34 126.32,34 126.41,34.09 126.55,34.09 126.7,33.95 126.7,33.81 126.61,33.71 126.61,33.57 126.75,33.43 126.89,33.43 126.99,33.52 127.13,33.52 127.27,33.37 127.27,33.23 127.18,33.14 127.18,32.99 127.32,32.85 127.47,32.85 127.56,32.94 127.7,32.94 127.85,32.8 127.85,32.66 127.76,32.56 127.76,32.42 127.9,32.27 128.04,32.27 128.14,32.37 128.28,32.37 128.42,32.22 128.42,32.08 128.33,31.99 128.33,31.84 128.47,31.7 128.62,31.7 128.71,31.79 128.86,31.79 129,31.65 129,31.51 128.91,31.41 128.91,31.27 129.05,31.12 129.19,31.12 129.29,31.22 129.43,31.22 129.57,31.07 129.57,30.93 129.48,30.84 129.48,30.69 129.62,30.55 129.77,30.55 129.86,30.64 130.01,30.64 130.15,30.5 130.15,30.36 130.06,30.26 130.06,30.12 130.2,29.97 130.34,29.97 130.44,30.07 130.58,30.07 130.72,29.92 130.72,29.78 130.63,29.69 130.63,29.54 130.77,29.4 130.92,29.4 131.01,29.49 131.16,29.49 131.3,29.35 131.3,29.21 131.21,29.11 131.21,28.97 131.35,28.82 131.49,28.82 131.59,28.92 131.73,28.92 131.87,28.77 131.87,28.63 131.78,28.54 131.78,28.39 132.03,28.15 132.03,27.08 134.33,24.78 v2(134.34,24.78)
  BOTTOM w0.076: UC1.AL58 132.73,67.4 132.61,67.27 v2(132.29,67.27)
  BOTTOM w0.102: JDIMM1.149 134.78,25.33 134.9,25.21 135.33,25.21 135.46,25.08 135.46,24.57 135.33,24.44 134.47,24.44 134.34,24.57 v2(134.34,24.78)
DDR_A_D21: length 64.1
  IN3 w0.076: v2(132.28,67.88) 132.25,67.88 129.3,64.94 129.3,64.04 126.73,61.47 126.66,61.47
  IN3 w0.102: 126.66,61.47 125.25,61.47 124.12,60.33 124.12,60.19 124.23,60.07 124.23,59.92 124.09,59.78 123.95,59.78 123.83,59.9 123.68,59.9 123.54,59.76 123.54,59.61 123.7,59.45 123.7,59.31 123.56,59.16 123.41,59.16 123.25,59.32 123.11,59.32 122.96,59.18 122.96,58.99 123.11,58.84 123.11,58.69 122.97,58.55 122.83,58.55 122.68,58.7 122.53,58.7 122.37,58.54 122.37,58.39 122.44,58.32 122.44,58.1 122.34,58 122.14,58 122.04,57.9 122.04,37.7 122.21,37.53 122.35,37.53 122.4,37.58 122.54,37.58 122.69,37.44 122.69,37.3 122.64,37.25 122.64,37.1 122.78,36.96 122.93,36.96 122.98,37.01 123.12,37.01 123.26,36.86 123.26,36.72 123.21,36.67 123.21,36.53 131.72,28.02 131.72,27.6 131.62,27.49 131.51,27.49 131.41,27.39 131.41,27.27 133.92,24.75 133.92,24.39 133.78,24.24 133.78,23.96 133.95,23.79 133.95,23.51 133.78,23.34 133.78,22.97 133.88,22.87 134.24,22.87 134.34,22.97 v2(134.34,23.26)
  BOTTOM w0.076: v2(132.28,67.88) 132.17,67.88 132.05,68.01 132.05,68.46 132.17,68.59 132.61,68.59 132.73,68.46 UC1.AK58
  BOTTOM w0.102: v2(134.34,23.26) 133.94,23.66 133.94,25.06 134.18,25.31 JDIMM1.147
DDR_A_D22: length 61.4
  IN3 w0.076: 131.26,62.27 133.24,64.25 v2(133.24,64.71)
  IN3 w0.102: 131.26,62.27 130.5,62.27 125.28,57.05 125.28,56.38 125.18,56.28 124.79,56.28 124.69,56.18 124.69,55.97 124.79,55.87 125.18,55.87 125.28,55.77 125.28,55.57 125.18,55.47 124.79,55.47 124.69,55.37 124.69,55.16 124.79,55.06 125.18,55.06 125.28,54.96 125.28,54.76 125.18,54.65 124.79,54.65 124.69,54.55 124.69,54.35 124.79,54.25 125.18,54.25 125.28,54.15 125.28,53.94 125.18,53.84 124.79,53.84 124.69,53.74 124.69,53.54 124.79,53.43 125.18,53.43 125.28,53.33 125.28,53.13 125.18,53.03 124.79,53.03 124.69,52.93 124.69,52.72 124.79,52.62 125.18,52.62 125.28,52.52 125.28,38.68 135.35,28.61 135.35,27.27 137.1,25.51 137.1,22.81 v2(138.6,21.31)
  BOTTOM w0.076: UC1.AR57 133.56,65.04 v2(133.24,64.71)
  BOTTOM w0.102: JDIMM1.158 137.48,20.19 v2(138.6,21.31)
DDR_A_D23: length 62.7
  IN3 w0.076: 126.7,58.9 130.39,62.59 131.25,62.59 132.85,64.19 132.85,65.63 v2(133.24,66.01)
  IN3 w0.102: v2(138.6,19.79) 137.75,19.79 136.63,20.91 136.63,25.55 135.04,27.14 135.04,28.49 124.97,38.56 124.97,49.6 124.87,49.7 124.49,49.7 124.38,49.8 124.38,50 124.49,50.1 124.87,50.1 124.97,50.2 124.97,50.41 124.87,50.51 124.49,50.51 124.38,50.61 124.38,50.81 124.49,50.92 124.87,50.92 124.97,51.02 124.97,51.22 124.87,51.32 124.49,51.32 124.38,51.42 124.38,51.63 124.49,51.73 124.87,51.73 124.97,51.83 124.97,52.03 124.87,52.14 124.49,52.14 124.38,52.24 124.38,56.59 126.7,58.9
  BOTTOM w0.076: UC1.AN57 133.56,66.34 v2(133.24,66.01)
  BOTTOM w0.102: JDIMM1.160 138.08,19.89 138.19,20 138.39,20 v2(138.6,19.79)
DDR_A_D24: length 68.6
  IN1 w0.076: 126.66,60.13 130.26,63.73 133.01,63.73 133.8,64.52 133.8,65.67 v2(134.15,66.03)
  IN1 w0.097: 126.66,60.13 126.22,60.13 122,55.91 120.35,55.91 116.89,52.46 116.11,52.46 112.69,49.04 104.31,40.66 101.75,38.1 94.5,30.84 94.5,20.4 v2(95.27,19.64)
  BOTTOM w0.076: v2(134.15,66.03) 134.24,66.03 UC1.AP55
  BOTTOM w0.102: JDIMM1.24 94.88,19.25 v2(95.27,19.64)
DDR_A_D25: length 68.1
  IN1 w0.076: 126.83,59.84 130.52,63.54 133.07,63.54 134.19,64.66 v2(134.19,64.71)
  IN1 w0.097: 126.83,59.84 126.37,59.84 122.13,55.6 120.48,55.6 116.97,52.1 116.19,52.1 112.69,48.6 104.31,40.21 101.97,37.88 94.81,30.71 94.81,22.3 94.91,22.2 95.15,22.2 95.27,22.09 95.27,21.93 95.15,21.82 94.91,21.82 94.81,21.72 94.81,21.02 95.06,20.76 v2(95.44,20.76)
  BOTTOM w0.076: UC1.AR55 134.51,65.04 v2(134.19,64.71)
  BOTTOM w0.102: JDIMM1.22 94.28,19.6 v2(95.44,20.76)
DDR_A_D26: length 71.3
  IN1 w0.076: v2(135.14,66.66) 135.67,66.13 135.67,63.58 134.48,62.39 132.67,62.39 132.05,61.76 131.29,61.76 130,60.46
  IN1 w0.097: 130,60.46 127.66,58.13 127.52,58.13 122.89,53.49 122.23,53.49 115.77,47.03 115.18,47.03 114.72,47.48 114.48,47.48 105.54,38.54 105.54,36.83 98.03,29.33 97.96,29.26 97.96,23.56 97.78,23.38 96.21,23.38 96.03,23.2 96.03,21.12 96.23,20.92 v2(96.92,20.92)
  BOTTOM w0.076: v2(135.14,66.66) 135.47,66.99 UC1.AM54
  BOTTOM w0.102: v2(96.92,20.92) 97.58,20.26 97.58,19.95 98.48,19.05 JDIMM1.36
DDR_A_D27: length 72.4
  IN1 w0.076: v2(136.06,68.13) 136.45,67.74 136.45,65.92 135.92,65.39 135.92,63.6 134.49,62.16 133.07,62.16 132.59,61.68
  IN1 w0.084: 132.59,61.68 132.59,61.18 129.01,57.59 128.83,57.59
  IN1 w0.097: 128.83,57.59 127.43,57.59 123.02,53.18 122.36,53.18 115.86,46.67 115.08,46.67 114.75,47 114.47,47 105.85,38.38 105.85,36.7 98.34,29.2 98.34,23.35 97.98,23 96.76,23 96.56,22.8 96.56,22.42 97.33,21.66 97.33,20.15 97.11,19.93 97.09,19.93 v2(96.89,19.72)
  BOTTOM w0.076: v2(136.06,68.13) 135.9,68.29 UC1.AK54
  BOTTOM w0.102: v2(96.89,19.72) 97.11,19.72 97.88,18.95 JDIMM1.34
DDR_A_D28: length 71
  IN1 w0.076: v2(134.13,67.91) 133.62,67.4 133.62,64.59 132.93,63.9 130.1,63.9
  IN1 w0.084: 126.58,60.39 130.1,63.9
  IN1 w0.097: 126.58,60.39 126.03,60.39 121.87,56.23 119.45,56.23 119.15,55.92 119.15,55.79 119.24,55.69 119.24,55.53 119.13,55.42 118.97,55.42 118.87,55.51 118.74,55.51 118.6,55.38 118.6,55.24 118.85,54.99 118.85,54.86 118.71,54.72 118.57,54.72 118.33,54.97 118.19,54.97 118.05,54.83 118.05,54.69 118.3,54.45 118.3,54.31 118.16,54.17 118.03,54.17 117.78,54.42 117.65,54.42 117.51,54.28 117.51,54.15 117.76,53.9 117.76,53.76 117.62,53.63 117.48,53.63 117.24,53.87 117.1,53.87 116.96,53.74 116.96,53.6 117.21,53.35 117.21,53.22 116.76,52.77 115.98,52.77 112.69,49.48 104.31,41.1 100,36.79 99.31,36.79 94,31.48 94,28.79 94.18,28.6 94.18,25.24 v2(93.39,24.45)
  BOTTOM w0.076: UC1.AL55 134.4,67.64 v2(134.13,67.91)
  BOTTOM w0.102: v2(93.39,24.45) 94.58,25.64 JDIMM1.23
DDR_A_D29: length 71.9
  IN1 w0.076: v2(135.09,67.98) 134.75,68.32 132.22,68.32 131.93,68.03 131.93,66.42 129.51,63.99 129.51,63.66 126.46,60.62
  IN1 w0.097: 126.46,60.62 125.82,60.62 121.74,56.54 119.31,56.54 112.69,49.92 104.31,41.54 99.89,37.13 99.2,37.13 93.51,31.44 93.51,31.02 93.68,30.85 93.68,30.61 93.59,30.52 93.08,30.52 92.99,30.43 92.99,30.19 93.08,30.1 93.5,30.1 93.62,29.99 93.62,29.83 93.5,29.71 93.09,29.71 92.99,29.61 92.99,29.43 93.09,29.33 93.56,29.33 93.67,29.22 93.67,28.64 93.87,28.43 93.87,26.28 93.69,26.1 93.17,26.1 92.99,26.28 92.99,28.29 93.08,28.38 v2(93.26,28.38)
  BOTTOM w0.076: UC1.AK55 134.79,68.29 v2(135.09,67.98)
  BOTTOM w0.102: v2(93.26,28.38) 93.39,28.38 93.98,27.79 JDIMM1.21
DDR_A_D30: length 69.3
  IN1 w0.076: 129.46,60.82 130.82,62.17 131.58,62.17 132.28,62.88 133.58,62.88 135.14,64.44 v2(135.14,64.71)
  IN1 w0.097: v2(97.18,25.05) 95.22,25.05 95.12,25.16 95.12,25.4 95.22,25.5 95.51,25.5 95.62,25.61 95.62,25.77 95.51,25.88 95.28,25.88 95.12,26.04 95.12,26.87 97.09,28.85 97.09,29.33 101.16,33.4 101.16,35.08 114.53,48.45 114.77,48.45 115.41,47.82 115.56,47.82 115.68,47.93 115.68,48.09 115.1,48.67 115.1,48.83 115.22,48.94 115.37,48.94 115.94,48.38 116.1,48.38 116.21,48.49 116.21,48.65 115.72,49.14 115.72,49.3 115.84,49.41 115.99,49.41 116.5,48.91 116.66,48.91 116.77,49.02 116.77,49.18 116.43,49.52 116.43,49.68 116.55,49.8 116.71,49.8 117.04,49.46 117.2,49.46 117.54,49.8 117.54,50.63 121.11,54.2 122.71,54.2 127.35,58.84 127.48,58.84 129.46,60.82
  BOTTOM w0.076: v2(135.14,64.71) 135.47,65.04 UC1.AR54
  BOTTOM w0.102: v2(97.18,25.05) 97.58,25.45 JDIMM1.33
DDR_A_D31: length 70.8
  IN1 w0.076: v2(135.14,66.01) 135.5,65.66 135.5,64.45 133.72,62.67 132.57,62.67 131.82,61.92 131.02,61.92 127.57,58.48 127.44,58.48 126.81,57.85
  IN1 w0.097: 126.81,57.85 122.76,53.81 122.11,53.81 115.72,47.42 115.27,47.42 114.7,47.99 114.54,47.99 105.22,38.67 105.22,36.96 97.71,29.46 97.63,29.37 97.63,27.63 97.45,27.45 96.27,27.45 96.16,27.33 96.16,27.17 96.27,27.06 96.52,27.06 96.64,26.95 96.64,26.79 96.52,26.68 95.68,26.68 95.57,26.56 95.57,26.4 95.68,26.29 96.6,26.29 96.71,26.18 96.71,26.02 96.6,25.9 96.1,25.9 96,25.81 96,25.61 96.1,25.52 97.53,25.52 97.63,25.42 97.63,23.91 97.5,23.78 v2(97.18,23.78)
  BOTTOM w0.076: v2(135.14,66.01) 135.47,66.34 UC1.AN54
  BOTTOM w0.102: JDIMM1.35 98.18,24.78 v2(97.18,23.78)
DDR_A_D32: length 53.6
  IN3 w0.102: v2(131.08,60.32) 130.56,60.32 126.5,56.26 126.5,39.81 132.17,34.14 132.17,33.52 137.28,28.41 137.28,27.19 139.21,25.26 139.21,21.57 139.21,21.56 139.21,19.92 139.35,19.79 v2(140.43,19.79)
  BOTTOM w0.076: v2(131.08,60.32) 131.78,60.32 132.5,61.04 132.5,61.66 132.7,61.86 UC1.AY58
  BOTTOM w0.102: JDIMM1.166 139.88,19.23 v2(140.43,19.79)
DDR_A_D33: length 54.5
  IN3 w0.102: v2(131.67,60.77) 131.18,60.77 131,60.95 130.47,60.95 126.19,56.67 126.19,39.68 129.23,36.64 129.23,36.03 129.37,35.88 129.52,35.88 129.68,36.05 129.82,36.05 129.97,35.9 129.97,35.76 129.8,35.6 129.8,35.45 129.95,35.31 130.09,35.31 130.26,35.47 130.4,35.47 130.54,35.33 130.54,35.18 130.38,35.02 130.38,34.88 130.52,34.73 130.67,34.73 130.83,34.9 130.97,34.9 131.12,34.75 131.12,34.61 130.95,34.44 130.95,34.3 131.1,34.16 131.24,34.16 131.41,34.32 131.55,34.32 131.69,34.18 131.69,34.03 131.53,33.87 131.53,33.73 136.97,28.28 136.97,27.06 138.9,25.13 138.9,23.74 v2(138.5,23.34)
  BOTTOM w0.076: v2(131.67,60.77) 131.71,60.73 131.85,60.73 132.32,61.21 132.32,61.76 132.41,61.85 132.41,62.28 UC1.AW58
  BOTTOM w0.102: v2(138.5,23.34) 139.58,24.41 JDIMM1.165
DDR_A_D34: length 54.3
  IN3 w0.084: v2(132.87,60.06) 132.87,59.01 128.84,54.98 128.84,54.95
  IN3 w0.102: 128.84,54.95 128.84,40.78 134.51,35.11 134.51,34.49 139.92,29.08 139.92,27.98 142.38,25.51 142.38,24.09 142.48,23.99 142.89,23.99 142.99,23.89 142.99,23.66 142.89,23.56 142.48,23.56 142.38,23.46 142.38,22.16 142.48,22.06 142.76,22.06 142.87,22.16 142.87,22.92 143.07,23.13 143.23,23.13 v2(143.45,23.34)
  BOTTOM w0.076: UC1.AY56 134.06,61.75 133.93,61.62 133.93,60.64 133.36,60.06 v2(132.87,60.06)
  BOTTOM w0.102: v2(143.45,23.34) 142.58,24.21 JDIMM1.175
DDR_A_D35: length 55.3
  IN3 w0.084: 128.53,55.16 128.53,55.23 129.05,55.74 129.35,55.74 132,58.38 v2(132,59.19)
  IN3 w0.102: 128.53,55.16 128.53,40.65 134.2,34.98 134.2,34.36 139.61,28.95 139.61,27.85 142.08,25.39 142.08,21.83 142.18,21.73 143.09,21.73 143.2,21.62 143.2,20.92 143.09,20.81 142.56,20.81 142.46,20.71 142.46,19.89 142.36,19.79 v2(141.96,19.79)
  BOTTOM w0.076: v2(132,59.19) 132.72,59.19 134.1,60.57 134.1,61.56 134.35,61.8 134.35,62.05 134.06,62.34 UC1.AW56
  BOTTOM w0.102: v2(141.96,19.79) 142.28,19.47 JDIMM1.174
DDR_A_D36: length 55.2
  IN3 w0.076: v2(131.38,61.28) 131.38,61.61 131.16,61.84 130.93,61.84 127.35,58.25
  IN3 w0.102: 127.35,58.25 125.89,56.79 125.89,38.94 126.04,38.79 126.18,38.79 126.34,38.95 126.49,38.95 126.63,38.81 126.63,38.66 126.47,38.5 126.47,38.36 126.61,38.21 126.76,38.21 126.92,38.38 127.06,38.38 127.21,38.23 127.21,38.09 127.04,37.92 127.04,37.78 127.19,37.64 127.33,37.64 127.5,37.8 127.64,37.8 127.78,37.66 127.78,37.51 127.62,37.35 127.62,37.21 127.76,37.06 127.91,37.06 128.07,37.23 128.21,37.23 128.36,37.08 128.36,36.94 128.19,36.77 128.19,36.63 136.67,28.16 136.67,26.81 137.71,25.77 137.71,24.14 137.81,24.04 138.02,24.04 138.12,24.14 138.12,24.78 138.21,24.86 v2(138.5,24.86)
  BOTTOM w0.076: v2(131.38,61.28) 131.38,61.31 131.72,61.65 131.72,62.06 132.48,62.82 132.48,63 UC1.AV58
  BOTTOM w0.102: JDIMM1.163 138.98,25.26 139.25,24.99 139.25,24.6 139.15,24.5 138.61,24.5 138.5,24.6 v2(138.5,24.86)
DDR_A_D37: length 56.6
  IN3 w0.076: v2(128.86,57.97) 128.73,57.97 128.18,57.42
  IN3 w0.102: 128.18,57.42 126.8,56.05 126.8,39.93 132.47,34.26 132.47,33.65 137.58,28.54 137.58,27.32 139.56,25.34 139.56,22.19 v2(140.43,21.31)
  BOTTOM w0.076: UC1.AU58 133.47,63.88 133.67,63.67 133.67,63.43 133.66,63.42 133.66,63.04 133.67,63.02 133.67,62.83 133.66,62.82 133.62,62.73 133.6,62.68 133.6,62.47 133.67,62.32 133.67,62.19 133.62,62.08 133.6,62.03 133.6,61.01 133.51,60.92 133.12,60.92 130.17,57.97 v2(128.86,57.97)
  BOTTOM w0.102: v2(140.43,21.31) 139.28,20.16 JDIMM1.164
DDR_A_D38: length 55.9
  IN3 w0.084: v2(133.26,60.53) 133.57,60.22 133.57,59.46 133.16,59.05 129.45,55.35 129.45,55.08
  IN3 w0.102: v2(143.45,24.86) 143.01,24.43 142.83,24.43 142.69,24.57 142.69,24.85 142.79,24.95 142.94,24.95 143.04,25.06 143.04,25.28 140.56,27.77 140.56,28.08 140.45,28.18 140.33,28.18 140.22,28.28 140.22,28.49 140.33,28.59 140.45,28.59 140.56,28.69 140.56,28.92 140.45,29.02 140.33,29.02 140.22,29.12 140.22,29.82 140.02,30.03 139.88,30.03 139.71,29.86 139.57,29.86 139.43,30.01 139.43,30.15 139.59,30.31 139.59,30.46 139.45,30.6 139.3,30.6 139.14,30.44 138.99,30.44 138.85,30.58 138.85,30.73 139.01,30.89 139.01,31.03 138.87,31.18 138.73,31.18 138.56,31.01 138.42,31.01 138.28,31.16 138.28,31.3 138.44,31.46 138.44,31.61 138.3,31.75 138.15,31.75 137.99,31.59 137.84,31.59 137.7,31.73 137.7,31.88 137.86,32.04 137.86,32.18 137.72,32.33 137.58,32.33 137.41,32.16 137.27,32.16 137.12,32.31 137.12,32.45 137.29,32.61 137.29,32.76 137.15,32.9 137,32.9 136.84,32.74 136.69,32.74 136.55,32.88 136.55,33.03 136.71,33.19 136.71,33.33 136.57,33.48 136.43,33.48 136.26,33.31 136.12,33.31 135.97,33.46 135.97,33.6 136.14,33.76 136.14,33.91 136,34.05 135.85,34.05 135.69,33.89 135.54,33.89 135.4,34.03 135.4,34.18 135.56,34.34 135.56,34.48 135.42,34.63 135.28,34.63 135.11,34.46 134.97,34.46 134.82,34.61 134.82,34.75 134.99,34.92 134.99,35.06 129.14,40.9 129.14,54.77 129.45,55.08
  BOTTOM w0.076: v2(133.26,60.53) 133.4,60.53 133.76,60.89 133.76,61.99 133.81,62.1 133.84,62.12 133.84,62.35 133.81,62.41 133.77,62.5 133.76,62.51 133.76,62.64 133.79,62.69 133.81,62.75 133.95,62.88 UC1.AV56
  BOTTOM w0.102: JDIMM1.177 143.18,25.13 v2(143.45,24.86)
DDR_A_D39: length 57.2
  IN3 w0.084: v2(131.57,58.76) 131.57,58.21 129.48,56.12 128.95,56.12 128.44,55.61
  IN3 w0.102: v2(141.96,21.31) 141.47,21.31 141.28,21.12 141.04,21.12 140.94,21.22 140.94,21.63 141.04,21.73 141.47,21.73 141.77,22.03 141.77,25.18 139.31,27.65 139.31,28.83 133.9,34.24 133.9,34.85 128.23,40.53 128.23,55.4 128.44,55.61
  BOTTOM w0.076: v2(131.57,58.76) 132.52,58.76 134.27,60.51 134.27,61.5 134.51,61.74 134.51,62.53 134.24,62.81 134.24,63.1 134.24,63.11 134.24,63.35 133.95,63.64 UC1.AU56
  BOTTOM w0.102: JDIMM1.176 142.88,20.39 v2(141.96,21.31)
DDR_A_D40: length 61.1
  IN1 w0.097: v2(129.41,56.56) 127.99,56.56 123.41,51.98 122.79,51.98 112.69,41.88 104.31,33.5 99.91,29.1 99.91,22.14 99.81,22.03 99.81,20.41 100.43,19.79 v2(100.68,19.79)
  BOTTOM w0.076: v2(129.41,56.56) 131.03,56.56 134.77,60.3 134.77,61.29 135.01,61.53 135.01,61.8 UC1.AY54
  BOTTOM w0.102: v2(100.68,19.79) 100.28,19.38 JDIMM1.42
DDR_A_D41: length 62.1
  IN1 w0.097: v2(130.23,57.47) 129.74,57.47 129.3,57.03 128.03,57.03 123.34,52.35 122.72,52.35 112.69,42.32 104.31,33.94 99.6,29.23 99.6,22.57 99.47,22.44 99,22.44 98.87,22.57 v2(98.87,23.78)
  BOTTOM w0.076: v2(130.23,57.47) 131.7,57.47 134.6,60.37 134.6,61.36 134.84,61.6 134.84,62.28 UC1.AW54
  BOTTOM w0.102: v2(98.87,23.78) 99.98,24.89 JDIMM1.41
DDR_A_D42: length 61.7
  IN1 w0.084: v2(132.85,57.26) 131.99,57.26 130.65,55.92
  IN1 w0.097: 130.65,55.92 129.42,54.69 129.36,54.69 102.91,28.24 102.91,26.13 102.68,25.89 102.68,20.81 102.78,20.71 102.78,20.43 102.69,20.33 101.18,20.33 101.08,20.23 101.08,19.89 101.18,19.79 v2(102.2,19.79)
  BOTTOM w0.076: UC1.AY52 136.36,61.8 136.36,59.85 133.76,57.26 v2(132.85,57.26)
  BOTTOM w0.102: v2(102.2,19.79) 102.68,19.31 JDIMM1.50
DDR_A_D43: length 62.6
  IN1 w0.076: v2(131.93,56.34) 131.42,56.34 129.72,54.64
  IN1 w0.097: 129.72,54.64 129.67,54.59 129.67,54.56 103.23,28.11 103.23,25.96 103.01,25.74 103.01,21.63 103.14,21.5 103.32,21.5 103.44,21.63 103.44,23.28 103.57,23.41 104.11,23.41 v2(104.18,23.34)
  BOTTOM w0.076: v2(131.93,56.34) 133.08,56.34 136.52,59.79 136.52,61.55 136.78,61.8 136.78,61.99 136.73,62.09 136.73,62.1 136.7,62.15 136.7,62.36 UC1.AW52
  BOTTOM w0.102: JDIMM1.51 102.98,24.54 v2(104.18,23.34)
DDR_A_D44: length 62.7
  IN1 w0.084: 129.47,57.66 129.7,57.89 v2(130.69,57.89)
  IN1 w0.097: 129.47,57.66 129.12,57.31 127.86,57.31 123.21,52.67 122.58,52.67 116.08,46.17 114.35,46.17 114.13,45.96 114.13,45.82 114.66,45.3 114.66,45.16 114.52,45.02 114.38,45.02 113.86,45.55 113.72,45.55 106.35,38.17 106.35,36.5 99.29,29.44 99.29,28.72 99.19,28.62 98.94,28.62 98.85,28.52 98.85,28.33 98.94,28.23 99.19,28.23 99.29,28.14 99.29,27.55 99.19,27.45 98.94,27.45 98.85,27.35 98.85,27.16 98.94,27.06 99.19,27.06 99.29,26.97 99.29,26.77 99.19,26.68 98.94,26.68 98.85,26.58 98.85,26.39 98.94,26.29 99.19,26.29 99.29,26.2 99.29,26 99.19,25.91 98.94,25.91 98.85,25.81 98.85,25.62 98.94,25.52 99.19,25.52 99.29,25.42 99.29,25.16 99.19,25.05 v2(98.87,25.05)
  BOTTOM w0.076: UC1.AV54 135.24,63.1 134.68,62.53 134.68,61.67 134.44,61.43 134.44,60.44 131.89,57.89 v2(130.69,57.89)
  BOTTOM w0.102: JDIMM1.39 99.38,25.56 v2(98.87,25.05)
DDR_A_D45: length 63.4
  IN1 w0.084: v2(135.48,60.39) 133.77,60.39 130.41,57.02
  IN1 w0.097: v2(100.23,21.7) 100.23,26.92 100.97,27.66 100.97,28.06 100.97,28.56 100.97,29.1 104.31,32.43 112.69,40.82 128.07,56.2 129.58,56.2 130.41,57.02
  BOTTOM w0.076: v2(135.48,60.39) 136.03,60.94 136.03,62.03 136.1,62.19 136.1,62.32 136.03,62.47 136.03,62.68 136.05,62.73 136.09,62.82 136.1,62.83 136.1,63.67 135.9,63.88 UC1.AU54
  BOTTOM w0.102: v2(100.23,21.7) 99.68,21.15 JDIMM1.40
DDR_A_D46: length 63.1
  IN1 w0.084: 130.63,56.23 132.12,57.72 v2(133.31,57.72)
  IN1 w0.097: 130.63,56.23 129.42,55.02 129.2,55.02 112.69,38.5 107.02,32.83 104.31,30.12 102.6,28.41 102.6,26.34 102.32,26.06 101.74,26.06 101.64,25.97 101.64,25.77 101.74,25.68 102.16,25.68 102.28,25.56 102.28,25.4 102.16,25.29 101.74,25.29 101.64,25.19 101.64,25 101.74,24.9 102.12,24.9 102.22,24.81 102.22,22.33 102,22.11 102,21.52 v2(102.2,21.31)
  BOTTOM w0.076: v2(133.31,57.72) 133.99,57.72 136.19,59.92 136.19,61.99 136.27,62.15 136.27,62.35 136.24,62.41 136.24,62.41 136.2,62.5 136.19,62.51 136.19,62.64 136.22,62.69 136.24,62.75 136.38,62.88 UC1.AV52
  BOTTOM w0.102: v2(102.2,21.31) 103.28,20.24 JDIMM1.52
DDR_A_D47: length 63.8
  IN1 w0.097: v2(131.47,55.88) 131.47,55.36 131.17,55.05 130.65,55.05 104.27,28.67 104.27,28.21 104.21,28.15 103.72,28.15 103.54,27.97 103.54,27.5 103.65,27.39 103.9,27.39 104,27.29 104,27.14 103.9,27.04 103.64,27.04 103.54,26.94 103.54,26.77 103.64,26.67 104.14,26.67 104.26,26.56 104.26,26.4 104.14,26.28 103.64,26.28 103.54,26.19 103.54,25.99 103.64,25.9 104.17,25.9 104.27,25.8 104.27,25.61 104.17,25.51 103.42,25.51 103.33,25.42 103.33,23.86 103.45,23.74 103.63,23.74 103.75,23.86 103.75,24.69 103.93,24.86 v2(104.18,24.86)
  BOTTOM w0.076: v2(131.47,55.88) 133.05,55.88 136.69,59.52 136.69,61.48 136.94,61.73 136.94,62.03 136.92,62.08 136.87,62.19 136.87,63.49 UC1.AU52
  BOTTOM w0.102: JDIMM1.53 103.58,25.18 103.44,25.05 103.44,24.5 103.55,24.4 103.75,24.4 103.85,24.5 103.85,24.76 103.95,24.86 v2(104.18,24.86)
DDR_A_D48: length 70.7
  IN1 w0.076: 139.6,58.73 140.05,58.73 140.5,59.18 140.5,63.16 141.3,63.96 143.84,63.96 144.32,64.44 144.32,66.93 143.62,67.63 v2(143.62,67.96)
  IN1 w0.097: 139.6,58.73 137.11,56.25 136.59,56.25 135.16,54.82 135.16,54.05 135.16,54.05 135.16,53.92 114.32,33.08 114.04,33.08 113.87,32.91 113.87,32.77 113.93,32.71 113.93,32.57 113.8,32.44 113.66,32.44 113.6,32.5 113.46,32.5 113.32,32.36 113.32,32.23 113.39,32.16 113.39,32.03 113.25,31.89 113.11,31.89 113.05,31.95 112.91,31.95 112.78,31.82 112.78,31.68 112.84,31.62 112.84,31.48 112.7,31.34 112.57,31.34 112.5,31.41 112.37,31.41 112.23,31.27 112.23,31.13 112.29,31.07 112.29,30.93 112.16,30.8 112.02,30.8 111.96,30.86 111.82,30.86 111.68,30.72 111.68,30.59 111.75,30.52 111.75,30.39 111.61,30.25 111.47,30.25 111.41,30.31 111.27,30.31 110.41,29.45 109.79,28.83 109.79,28.38 109.65,28.24 109.35,28.24 109.22,28.11 109.22,27.9 109.35,27.77 109.62,27.77 109.74,27.65 109.74,27.47 109.62,27.34 109.3,27.34 109.19,27.22 109.19,27.06 109.3,26.95 109.71,26.95 109.8,26.86 109.8,26.66 109.71,26.57 108.87,26.57 108.77,26.47 108.77,26.28 108.87,26.18 109.71,26.18 109.8,26.08 109.8,25.89 109.71,25.79 108.87,25.79 108.77,25.7 108.77,25.5 108.87,25.41 109.53,25.41 109.63,25.31 109.63,24.43 109.46,24.27 109.36,24.27 108.98,24.65 v2(108.98,24.86)
  BOTTOM w0.076: v2(143.62,67.96) 143.94,68.29 UC1.AK40
  BOTTOM w0.102: JDIMM1.69 108.38,25.46 v2(108.98,24.86)
DDR_A_D49: length 70.5
  IN1 w0.076: 135.6,55.71 136.46,56.58 136.98,56.58 139.47,59.07 140.02,59.07 140.33,59.37 140.33,63.24 141.23,64.14 143.77,64.14 144.15,64.52 144.15,66.8 142.94,68.01 v2(142.71,68.01)
  IN1 w0.097: 135.6,55.71 134.85,54.96 134.85,54.05 114.21,33.41 113.93,33.41 108.91,28.39 108.91,27.4 108.46,26.95 108.46,22.28 108.54,22.19 109.44,22.19 109.62,22.37 109.62,23.2 109.48,23.34 v2(108.98,23.34)
  BOTTOM w0.076: UC1.AK42 142.98,68.29 v2(142.71,68.01)
  BOTTOM w0.102: v2(108.98,23.34) 107.78,24.54 JDIMM1.67
DDR_A_D50: length 68
  IN1 w0.076: v2(141.75,66.79) 141.25,66.29 140.56,66.29 140.17,65.89 138.57,65.89 138.45,65.77 137.79,65.77 137.56,65.55 137.56,64.43 136.97,63.84 136.97,63.36 136.62,63.01 136.62,59.38 132.76,55.51 132.76,55.36
  IN1 w0.097: 132.76,55.36 132.76,54.85 132.61,54.7 132.36,54.7 132.21,54.56 132.21,54.3 132.06,54.16 131.81,54.16 131.66,54.01 131.66,53.76 131.52,53.61 131.26,53.61 131.12,53.47 131.12,53.21 130.97,53.07 130.72,53.07 130.57,52.92 130.57,52.67 130.43,52.52 130.17,52.52 130.03,52.37 130.03,52.12 129.88,51.97 129.63,51.97 129.48,51.83 129.48,51.57 129.33,51.43 129.08,51.43 128.93,51.28 128.93,51.03 128.79,50.88 128.53,50.88 128.39,50.74 128.39,50.48 128.24,50.34 127.99,50.34 127.84,50.19 127.84,49.94 127.7,49.79 127.44,49.79 127.3,49.64 127.3,49.39 127.15,49.24 126.9,49.24 126.75,49.1 126.75,48.84 126.6,48.7 126.35,48.7 126.2,48.55 126.2,48.3 126.06,48.15 125.8,48.15 125.66,48 125.66,47.75 125.51,47.6 125.26,47.6 125.11,47.46 125.11,47.2 124.96,47.06 124.71,47.06 124.56,46.91 124.56,46.66 124.42,46.51 124.16,46.51 124.02,46.37 124.02,46.11 123.87,45.97 123.62,45.97 123.47,45.82 123.47,45.57 123.33,45.42 123.07,45.42 122.93,45.27 122.93,45.02 122.78,44.87 122.53,44.87 122.38,44.73 122.38,44.47 122.23,44.33 121.98,44.33 121.83,44.18 121.83,43.93 121.69,43.78 121.43,43.78 121.29,43.64 121.29,43.38 121.14,43.24 120.89,43.24 120.74,43.09 120.74,42.84 120.6,42.69 120.34,42.69 120.2,42.54 120.2,42.29 120.05,42.14 119.8,42.14 119.65,42 119.65,41.74 119.5,41.6 119.25,41.6 119.1,41.45 119.1,41.2 118.96,41.05 118.7,41.05 118.56,40.91 118.56,40.65 118.41,40.51 118.16,40.51 118.01,40.36 118.01,40.11 117.87,39.96 117.61,39.96 117.47,39.81 117.47,39.56 117.32,39.41 117.07,39.41 116.92,39.27 116.92,39.01 116.77,38.87 116.52,38.87 116.37,38.72 116.37,38.47 116.23,38.32 115.97,38.32 115.83,38.18 115.83,37.92 115.68,37.78 115.43,37.78 115.28,37.63 115.28,37.38 115.14,37.23 114.88,37.23 114.74,37.08 114.74,36.83 114.59,36.68 114.34,36.68 114.19,36.54 114.19,36.28 114.04,36.14 113.79,36.14 113.64,35.99 113.64,35.74 113.5,35.59 113.24,35.59 105.71,28.06 105.71,27.81 105.81,27.72 106.07,27.72 106.16,27.62 106.16,27.43 106.07,27.33 105.8,27.33 105.71,27.24 105.71,26.93 105.8,26.83 106.34,26.83 106.43,26.74 106.43,24.95 106.34,24.86 v2(106.05,24.86)
  BOTTOM w0.076: UC1.AM43 142.11,66.86 142.05,66.79 v2(141.75,66.79)
  BOTTOM w0.102: v2(106.05,24.86) 105.38,25.54 JDIMM1.59
DDR_A_D51: length 67.7
  IN1 w0.076: 136.42,59.56 136.42,63.15 136.59,63.32 136.59,63.76 137.37,64.54 137.37,65.69 137.66,65.98 138.31,65.98 138.4,66.07 140.09,66.07 140.74,66.72 v2(140.8,66.72)
  IN1 w0.097: 136.42,59.56 132.38,55.51 132.38,55.17 105.4,28.19 105.4,26.61 105.5,26.5 105.87,26.5 105.98,26.38 105.98,26.22 105.87,26.1 105.5,26.1 105.4,26 105.4,25.79 105.5,25.69 105.92,25.69 106.04,25.57 106.04,25.4 105.92,25.28 105.52,25.28 105.4,25.16 105.4,24.86 105.49,24.76 105.56,24.76 105.65,24.66 105.65,24.47 105.56,24.37 105.49,24.37 105.4,24.28 105.4,24.08 105.49,23.99 105.56,23.99 105.65,23.89 105.65,23.7 105.56,23.6 105.49,23.6 105.4,23.5 105.4,22.92 105.47,22.85 105.69,22.85 106.05,23.21 v2(106.05,23.34)
  BOTTOM w0.076: UC1.AM45 141,66.72 v2(140.8,66.72)
  BOTTOM w0.102: JDIMM1.57 104.78,24.31 105.75,23.34 v2(106.05,23.34)
DDR_A_D52: length 68
  IN1 w0.076: v2(140.81,68.02) 140.28,68.02 140.22,67.96 140.22,66.48 139.98,66.24 138.29,66.24 138.2,66.15 137.28,66.15 136.42,65.3 136.42,63.38 136.2,63.16 136.2,59.63
  IN1 w0.097: 136.2,59.63 132.05,55.47 132.05,55.28 105.08,28.32 105.08,22.44 104.92,22.27 104.92,20.46 104.25,19.79 v2(103.88,19.79)
  BOTTOM w0.076: UC1.AK45 141.08,68.29 v2(140.81,68.02)
  BOTTOM w0.102: v2(103.88,19.79) 104.48,19.19 JDIMM1.56
DDR_A_D53: length 69.3
  IN1 w0.076: v2(141.75,68.09) 141.47,68.38 140.41,68.38 140.37,68.34 138.77,68.34 138.46,68.03 138.46,66.79 138,66.33 137.22,66.33 136.15,65.26 136.15,63.46 135.96,63.27 135.96,59.75
  IN1 w0.097: 135.96,59.75 131.82,55.61 131.82,55.36 131.21,54.75 131.07,54.75 104.77,28.45 104.77,22.57 104.38,22.19 104.28,22.19 103.98,21.88 103.98,21.41 v2(103.88,21.31)
  BOTTOM w0.076: v2(141.75,68.09) 142.05,68.09 UC1.AK43
  BOTTOM w0.102: v2(103.88,21.31) 105.08,20.11 JDIMM1.58
DDR_A_D54: length 69.5
  IN1 w0.076: 134.97,55.71 138.05,58.79 138.05,59.63 139.13,60.71 139.13,63.44 139.63,63.94 140.79,63.94 141.16,64.31 143.7,64.31 143.98,64.59 143.98,66.3 v2(143.62,66.66)
  IN1 w0.097: v2(109.28,21.31) 109.49,21.1 109.72,21.1 109.89,21.27 109.89,21.5 109.52,21.88 108.93,21.88 108.75,21.7 108.3,21.7 107.92,22.08 107.92,22.65 108.15,22.88 108.15,27.08 108.6,27.53 108.6,28.52 113.87,33.79 114.15,33.79 134.53,54.18 134.53,55.28 134.97,55.71
  BOTTOM w0.076: v2(143.62,66.66) 143.94,66.99 UC1.AM40
  BOTTOM w0.102: JDIMM1.68 108.08,20.11 v2(109.28,21.31)
DDR_A_D55: length 69
  IN1 w0.076: v2(142.71,66.71) 142.71,66.6 142.01,65.91 141.79,65.91 141.32,65.44 141.32,64.78 140.66,64.12 139.54,64.12 138.71,63.29 138.71,60.72 137.69,59.7 137.69,58.88 134.52,55.71
  IN1 w0.097: 134.52,55.71 134.22,55.41 134.22,54.31 114.03,34.12 113.76,34.12 108.29,28.65 108.29,27.66 107.83,27.21 107.83,23.01 107.46,22.63 107.46,20.92 107.64,20.74 108.18,20.74 108.32,20.6 108.32,20.4 108.18,20.26 107.1,20.26 106.98,20.13 106.98,19.91 107.1,19.79 v2(109.28,19.79)
  BOTTOM w0.076: UC1.AM42 142.98,66.99 v2(142.71,66.71)
  BOTTOM w0.102: JDIMM1.70 108.68,19.19 v2(109.28,19.79)
DDR_A_D56: length 67.2
  IN3 w0.076: 132.9,54.67 132.9,55.35 136.52,58.97 136.52,62.62 136.54,62.64 136.54,63.27 138.33,65.06 138.33,65.57 138.86,66.1 139.13,66.1 139.44,66.41 139.44,66.85 v2(139.85,67.26)
  IN3 w0.102: v2(148.9,21.31) 149.17,21.04 150.41,21.04 150.51,21.14 150.51,21.91 150.41,22.01 149.44,22.01 149.34,22.11 149.34,22.36 149.44,22.46 150.66,22.46 150.77,22.56 150.77,22.77 150.66,22.87 149.44,22.87 149.34,22.97 149.34,23.17 149.44,23.27 150.18,23.27 150.28,23.38 150.28,23.58 150.18,23.68 149.44,23.68 149.34,23.78 149.34,25.67 132.9,42.11 132.9,54.67 132.9,54.67
  BOTTOM w0.076: v2(139.85,67.26) 140.12,66.99 UC1.AM46
  BOTTOM w0.102: JDIMM1.192 147.68,19.47 148.22,20.01 148.22,20.62 v2(148.9,21.31)
DDR_A_D57: length 66.5
  IN3 w0.076: 133.32,55.51 136.67,58.86 136.67,58.89 136.68,58.9 136.68,62.55 136.7,62.57 136.7,63.19 138.5,64.99 138.5,65.47 138.95,65.92 139.66,65.92 140.2,66.46 140.2,67.56 v2(139.85,67.91)
  IN3 w0.102: 133.32,55.51 133.32,42.12 151.32,24.12 151.32,22.72 151.63,22.41 151.63,21.53 151.27,21.17 151.27,20.65 151.1,20.47 150.66,20.47 150.56,20.37 150.56,19.52 150.46,19.42 150.16,19.42 150.05,19.52 150.05,20.33 149.95,20.43 149.72,20.43 149.62,20.33 149.62,19.44 149.52,19.34 149.01,19.34 148.9,19.44 v2(148.9,19.79)
  BOTTOM w0.076: v2(139.85,67.91) 140.22,68.29 UC1.AK46
  BOTTOM w0.102: v2(148.9,19.79) 148.28,19.16 JDIMM1.194
DDR_A_D58: length 64.4
  IN3 w0.076: v2(137.89,66.73) 137.58,66.73 137.14,66.29 136.82,66.29 135.71,65.19 135.71,62.98 135.05,62.32 135.05,60.29 135.53,59.8 135.53,59.39 130.86,54.72 130.86,54.49
  IN3 w0.102: 130.86,54.49 130.86,53.91 130.76,53.81 130.67,53.81 130.57,53.71 130.57,53.5 130.67,53.4 130.76,53.4 130.86,53.3 130.86,53.1 130.76,53 130.67,53 130.57,52.89 130.57,52.69 130.67,52.59 130.76,52.59 130.86,52.49 130.86,52.28 130.76,52.18 130.67,52.18 130.57,52.08 130.57,51.88 130.67,51.78 130.76,51.78 130.86,51.68 130.86,51.47 130.76,51.37 130.67,51.37 130.57,51.27 130.57,51.07 130.67,50.96 130.76,50.96 130.86,50.86 130.86,50.66 130.76,50.56 130.67,50.56 130.57,50.46 130.57,50.25 130.67,50.15 130.76,50.15 130.86,50.05 130.86,49.85 130.76,49.74 130.67,49.74 130.57,49.64 130.57,49.44 130.67,49.34 130.76,49.34 130.86,49.24 130.86,49.03 130.76,48.93 130.67,48.93 130.57,48.83 130.57,48.63 130.67,48.53 130.76,48.53 130.86,48.42 130.86,48.22 130.76,48.12 130.67,48.12 130.57,48.02 130.57,47.81 130.67,47.71 130.76,47.71 130.86,47.61 130.86,47.41 130.76,47.31 130.67,47.31 130.57,47.2 130.57,47 130.67,46.9 130.76,46.9 130.86,46.8 130.86,46.6 130.76,46.49 130.67,46.49 130.57,46.39 130.57,46.19 130.67,46.09 130.76,46.09 130.86,45.99 130.86,45.78 130.76,45.68 130.67,45.68 130.57,45.58 130.57,45.38 130.67,45.27 130.76,45.27 130.86,45.17 130.86,44.97 130.76,44.87 130.67,44.87 130.57,44.77 130.57,44.56 130.67,44.46 130.76,44.46 130.86,44.36 130.86,44.16 130.76,44.06 130.67,44.06 130.57,43.95 130.57,43.75 130.67,43.65 130.76,43.65 130.86,43.55 130.86,43.26 130.76,43.16 130.67,43.16 130.57,43.06 130.57,42.85 130.67,42.75 130.76,42.75 130.86,42.65 130.86,42.45 130.76,42.34 130.67,42.34 130.57,42.24 130.57,42.04 130.67,41.94 130.76,41.94 130.86,41.84 130.86,41.27 142.52,29.61 142.52,29.46 142.12,29.07 142.12,28.92 142.27,28.78 142.41,28.78 142.81,29.18 142.95,29.18 143.25,28.88 143.25,28.1 143.35,28 144.03,28 144.13,27.9 144.13,27.65 144.03,27.55 143.37,27.55 143.27,27.44 143.27,27.24 143.37,27.14 144.03,27.14 144.13,27.04 144.13,26.23 144.97,25.39 144.97,24.57 145.07,24.47 145.48,24.47 145.58,24.57 v2(145.58,24.86)
  BOTTOM w0.076: UC1.AM49 138.15,66.99 v2(137.89,66.73)
  BOTTOM w0.102: JDIMM1.183 144.98,24.6 145.08,24.5 145.48,24.5 145.58,24.6 v2(145.58,24.86)
DDR_A_D59: length 63.6
  IN3 w0.076: 134.29,68.67 137.26,68.67 v2(137.94,67.99)
  IN3 w0.084: 134.29,68.67 133.74,68.13 133.74,59.37 130.4,56.03
  IN3 w0.102: v2(143.73,21.31) 143.83,21.41 143.83,21.7 143.65,21.88 143.65,22.08 143.75,22.18 143.91,22.18 144.04,22.31 144.04,25.01 141.06,27.98 141.06,29.7 129.65,41.12 129.65,54.48 129.91,54.74 129.91,55.54 130.4,56.03
  BOTTOM w0.076: UC1.AK49 138.24,68.29 v2(137.94,67.99)
  BOTTOM w0.102: JDIMM1.182 144.68,20.36 v2(143.73,21.31)
DDR_A_D60: length 66.1
  IN3 w0.076: 137.38,65.62 137.38,64.58 136.21,63.42 136.21,62.78 136.19,62.75 136.19,59.16 132.29,55.26 132.29,54.67 ; 137.71,65.95 138.19,65.95 v2(138.9,66.66)
  IN3 w0.084: 137.71,65.95 137.38,65.62
  IN3 w0.102: v2(147.41,24.74) 147.82,24.74 147.92,24.64 147.92,24.19 148.28,23.84 148.28,23.74 148.38,23.63 148.61,23.63 148.71,23.74 148.71,24.27 148.61,24.37 148.4,24.37 148.3,24.47 148.3,24.73 148.4,24.83 148.61,24.83 148.71,24.93 148.71,25.36 148.61,25.46 148.38,25.46 148.28,25.36 148.28,25.34 148.17,25.23 147.59,25.23 147.49,25.34 147.49,25.54 147.59,25.64 147.95,25.64 148.05,25.74 148.05,25.97 147.95,26.07 147.39,26.07 147.1,25.79 146.96,25.79 146.8,25.95 146.8,26.09 147.34,26.64 147.34,26.78 147.17,26.95 147.03,26.95 146.37,26.29 146.24,26.29 146.08,26.45 146.08,26.58 146.75,27.25 146.75,27.39 146.61,27.54 146.47,27.54 145.82,26.89 145.68,26.89 145.56,27.01 145.56,27.2 146.18,27.82 146.18,27.97 132.29,41.86 132.29,54.67
  BOTTOM w0.076: UC1.AM48 139.22,66.99 v2(138.9,66.66)
  BOTTOM w0.102: v2(147.41,24.74) 146.69,24.74 146.59,24.84 146.59,25.14 146.69,25.24 147.28,25.24 147.38,25.35 JDIMM1.191
DDR_A_D61: length 65.5
  IN3 w0.076: 137.78,65.78 138.29,65.78 138.78,66.27 139,66.27 139.25,66.52 139.25,67.61 v2(138.9,67.96) ; 132.59,54.8 132.59,55.31 136.35,59.07 136.35,62.69 136.37,62.71 136.37,63.34 137.55,64.52 137.55,65.55
  IN3 w0.084: 137.78,65.78 137.55,65.55
  IN3 w0.102: 132.59,54.8 132.59,41.99 149.04,25.54 149.04,22.74 148.94,22.64 148.56,22.64 148.45,22.54 148.45,21.09 148.35,20.99 148.1,20.99 148,21.09 148,23.11 147.89,23.22 v2(147.41,23.22)
  BOTTOM w0.076: UC1.AK48 139.22,68.29 v2(138.9,67.96)
  BOTTOM w0.102: JDIMM1.193 147.98,23.03 147.88,22.93 147.51,22.93 147.41,23.03 v2(147.41,23.22)
DDR_A_D62: length 63.3
  IN3 w0.076: 135.64,67.75 136.23,67.75 136.63,67.35 136.63,67.05 v2(136.97,66.71)
  IN3 w0.084: 130.86,55.82 134.46,59.42 134.46,62.34 135.54,63.42 135.54,67.65 135.64,67.75
  IN3 w0.102: v2(145.58,23.34) 145.58,23.56 145.48,23.66 145.18,23.66 145.08,23.56 145.08,22.44 144.97,22.34 144.77,22.34 144.66,22.44 144.66,25.27 141.67,28.26 141.67,29.98 130.26,41.39 130.26,54.23 130.45,54.41 130.45,54.75 130.52,54.82 130.52,55.48 130.86,55.82
  BOTTOM w0.076: UC1.AM51 137.25,66.99 v2(136.97,66.71)
  BOTTOM w0.102: v2(145.58,23.34) 145.58,23.07 145.49,22.98 144.47,22.98 144.38,23.07 JDIMM1.181
DDR_A_D63: length 62.4
  IN3 w0.076: v2(136.96,67.98) 136.45,68.5 134.85,68.5
  IN3 w0.084: 130.58,55.9 134.23,59.55 134.23,63.2 134.72,63.69 134.72,68.36 134.85,68.5
  IN3 w0.102: 130.58,55.9 130.22,55.54 130.22,54.61 129.96,54.35 129.96,41.25 141.37,29.84 141.37,28.13 144.35,25.15 144.35,22.17 144.97,21.56 144.97,20.53 144.23,19.79 v2(143.73,19.79)
  BOTTOM w0.076: UC1.AK51 137.27,68.29 v2(136.96,67.98)
  BOTTOM w0.102: v2(143.73,19.79) 144.08,19.44 JDIMM1.180
DDR_A_DQS0: length 65.1
  IN3 w0.102: v2(125.24,67.61) 125.24,67.61 125.49,67.61 125.62,67.48 125.62,67.22 119.19,60.79 119.19,52.74 119.09,52.64 118.86,52.64 118.63,52.41 118.63,51.94 118.86,51.71 119.09,51.71 119.19,51.61 119.19,50.47 119.09,50.37 118.98,50.37 118.76,50.15 118.76,49.67 119.19,49.24 119.19,35.27 126.01,28.45 126.01,27.62 126.01,27.62 126.01,27.58 127.57,26.02 128.42,26.02 129.61,24.84 129.61,24.62 129.61,24.62 129.61,24.33 129.61,24.33 129.61,23.26 129.88,22.99 130.15,22.99 130.32,22.82 v2(130.32,22.62)
  BOTTOM w0.076: v2(125.24,67.61) 125.31,67.68 125.54,67.68 125.66,67.55 125.95,67.55 126.47,68.07 127.86,68.07 128.47,68.68 128.92,68.68 129.06,68.82 129.61,68.82 129.67,68.84 129.77,68.89 129.9,68.89 129.92,68.88 130.01,68.84 130.06,68.82 130.27,68.82 130.42,68.89 130.55,68.89 130.66,68.84 130.66,68.67 130.59,68.6 UC1.AJ62
  BOTTOM w0.102: v2(130.32,22.62) 130.32,22.82 130.6,23.1 130.72,23.1 130.99,23.36 130.99,25.08 131.18,25.27 JDIMM1.137
DDR_A_DQS1: length 72.8
  IN1 w0.076: v2(127.27,64.81) 127.27,65.16 127.35,65.24 127.73,65.24 127.79,65.18 127.79,64.62 126.26,63.1 125.52,63.1 125.34,62.92 125.31,62.92
  IN1 w0.097: 125.31,62.92 124.96,62.92 120.81,58.78 117.64,58.78 112.69,53.83 104.31,45.45 99.36,40.5 90.68,31.82 90.68,20.72 90.54,20.59 90.29,20.59 v2(90.11,20.76)
  BOTTOM w0.076: UC1.AN61 130.91,66.39 130.73,66.39 130.57,66.55 130.1,66.55 129.94,66.63 129.74,66.63 129.65,66.59 129.58,66.55 129.31,66.55 129.31,66.55 127.94,66.55 127.27,65.88 v2(127.27,64.81)
  BOTTOM w0.102: JDIMM1.12 91.28,20.31 90.93,20.66 90.21,20.66 v2(90.11,20.76)
DDR_A_DQS2: length 62.2
  IN3 w0.076: v2(132.28,66.01) 132.28,66.11 132.09,66.31 131.67,66.31 131.4,66.03 131.4,65.53 131.09,65.21 130.58,65.21 129.98,64.61 129.98,63.75 129.98,63.34 126.94,60.31 126.57,60.31 126.54,60.29 126.53,60.29
  IN3 w0.102: v2(135.87,22.01) 135.87,21.53 135.69,21.35 135.31,21.35 135.16,21.5 135.16,21.88 135.38,22.1 135.38,22.98 135.22,23.14 135.22,23.59 135.33,23.7 135.33,24.46 135.22,24.56 135.22,25.06 132.84,27.44 132.84,28.96 123.17,38.64 123.17,57.15 125.53,59.5 125.53,59.82 125.43,59.92 125.43,60.06 125.66,60.29 126.53,60.29
  BOTTOM w0.076: UC1.AN58 132.61,66.34 v2(132.28,66.01)
  BOTTOM w0.102: JDIMM1.154 136.28,19.25 136.13,19.4 136.13,19.57 136.82,20.26 136.82,21.33 136.52,21.63 136.06,21.63 135.87,21.82 v2(135.87,22.01)
DDR_A_DQS3: length 69.8
  IN1 w0.076: v2(134.15,66.66) 134.15,66.84 134.23,66.92 134.51,66.92 134.61,66.82 134.61,64.45 133.37,63.22 131.87,63.22 131.31,62.66 130.27,62.66 129.22,61.61
  IN1 w0.097: 129.22,61.61 127.06,59.45 126.83,59.45 122.38,55 120.77,55 117.24,51.47 116.42,51.47 100.07,35.11 100.07,34.79 100.27,34.58 100.27,34.38 100.13,34.24 99.93,34.24 99.75,34.42 99.41,34.42 99.13,34.15 99.13,33.81 99.72,33.22 99.72,33.09 99.51,32.88 99.38,32.88 98.79,33.47 98.45,33.47 98.18,33.19 98.18,32.85 98.76,32.27 98.76,32.13 98.56,31.92 98.42,31.92 97.82,32.52 97.48,32.52 97.21,32.25 97.21,31.91 97.81,31.31 97.81,31.17 97.6,30.97 97.47,30.97 96.99,31.45 96.51,31.45 96.27,31.21 96.27,29.35 95.88,28.97 95.64,28.97 95.42,29.19 95.42,29.58 v2(95.32,29.68)
  BOTTOM w0.076: UC1.AN55 134.48,66.34 v2(134.15,66.66)
  BOTTOM w0.102: JDIMM1.29 96.38,27.58 96.21,27.75 96.21,29.1 95.99,29.32 95.55,29.32 95.32,29.55 v2(95.32,29.68)
DDR_A_DQS4: length 55.1
  IN3 w0.076: 128.44,56.76 128.45,56.77 128.47,56.77 128.51,56.81 128.51,56.81 130.18,58.48 130.18,58.94 130.08,59.04 129.83,59.04 v2(129.73,58.94)
  IN3 w0.102: 128.44,56.76 127.41,55.74 127.41,40.19 133.08,34.52 133.08,33.9 138.26,28.72 138.26,27.5 140.35,25.42 140.35,25.14 140.17,24.96 140.17,23.32 140.44,23.04 140.77,23.04 v2(141.02,22.8)
  BOTTOM w0.076: v2(129.73,58.94) 129.95,58.94 130.22,58.66 130.63,58.66 132.83,60.87 132.83,61.41 133.16,61.74 133.16,62.03 133.14,62.08 133.09,62.19 133.09,62.32 133.1,62.34 133.14,62.42 133.16,62.47 133.16,62.68 133.09,62.84 133.09,62.97 133.14,63.07 133.22,63.15 133.31,63.15 133.38,63.08 UC1.AW57
  BOTTOM w0.102: v2(141.02,22.8) 141.02,23.16 141.19,23.33 141.49,23.33 141.75,23.58 141.75,24.93 141.38,25.3 JDIMM1.171
DDR_A_DQS5: length 61.9
  IN1 w0.076: v2(134.69,59.1) 134.46,59.1 134.34,59.22 133.01,59.22 129.44,55.64 129.33,55.64 129.32,55.66 129.31,55.66
  IN1 w0.097: 129.31,55.66 128.72,55.66 101.58,28.51 101.58,27.3 100.83,26.56 100.83,23.2 v2(101.49,22.53)
  BOTTOM w0.076: UC1.AW53 135.67,62.9 135.59,62.83 135.59,62.47 135.57,62.42 135.53,62.34 135.52,62.32 135.52,62.19 135.54,62.13 135.59,62.03 135.59,61.71 135.34,61.46 135.34,61.38 135.1,61.14 135.1,60.17 134.4,59.47 134.4,59.14 134.45,59.1 v2(134.69,59.1)
  BOTTOM w0.102: v2(101.49,22.53) 101.49,23.05 101.62,23.18 101.96,23.18 102.22,23.44 102.22,24.29 102.22,24.29 102.22,24.54 101.61,25.15 101.61,25.33 101.78,25.5 JDIMM1.47
DDR_A_DQS6: length 68.9
  IN1 w0.076: v2(142.71,67.36) 142.33,66.98 142.33,66.5 141.97,66.14 141.64,66.14 141.34,65.85 140.64,65.85 140.41,65.63 140.41,64.67 140.06,64.32 139.32,64.32 139.05,64.05 138.13,64.05 137.7,63.62 137.7,60.45 137.23,59.98 137.23,59.77 137.22,59.77 137.22,59.34 133.63,55.75 133.63,55.74 133.61,55.72 133.61,55.72 133.61,55.71
  IN1 w0.097: 133.61,55.71 133.61,54.56 113.83,34.77 113.55,34.77 112.69,33.91 110.27,31.49 109.32,30.54 107.23,28.45 107.23,23.26 105.72,21.75 105.72,21.07 105.95,20.84 106.33,20.84 106.47,20.98 106.47,21.24 v2(106.26,21.44)
  BOTTOM w0.076: v2(142.71,67.36) 142.98,67.64 UC1.AL42
  BOTTOM w0.102: v2(106.26,21.44) 106.92,20.78 106.92,19.67 106.88,19.63 JDIMM1.64
DDR_A_DQS7: length 64.5
  IN3 w0.076: v2(137.94,67.34) 137.95,67.34 138.31,66.98 138.31,66.62 138.06,66.37 137.49,66.37 137.13,66.01 136.91,66.01 135.88,64.99 135.88,62.91 135.86,62.89 135.86,59.4 133.56,57.11
  IN3 w0.102: v2(147.39,20.38) 147.38,20.38 147.18,20.58 145.8,20.58 145.58,20.8 145.58,21.36 145.8,21.58 146.5,21.58 146.6,21.68 146.6,21.98 146.5,22.08 146.26,22.08 146.04,22.3 146.04,22.78 146.26,23 146.4,23 146.5,23.1 146.5,24.88 144.74,26.64 144.74,28.25 131.47,41.52 131.47,55.01 133.56,57.11
  BOTTOM w0.076: UC1.AL49 138.24,67.64 v2(137.94,67.34)
  BOTTOM w0.102: JDIMM1.188 146.48,19.23 146.28,19.43 146.28,20.61 146.76,21.09 147.08,21.09 147.39,20.79 v2(147.39,20.38)
DDR_A_DQS#0: length 65.2
  IN3 w0.102: v2(130.32,23.89) 130.32,23.35 130.17,23.2 129.96,23.2 129.82,23.35 129.82,24.25 129.82,24.92 128.51,26.23 127.66,26.23 126.22,27.67 126.22,27.71 126.22,28.54 119.4,35.36 119.4,49.33 118.97,49.76 118.97,50.06 119.07,50.16 119.18,50.16 119.4,50.39 119.4,51.7 119.18,51.92 118.94,51.92 118.84,52.02 118.84,52.33 118.94,52.43 119.18,52.43 119.4,52.65 119.4,60.71 125.83,67.13 125.83,67.57 125.66,67.74 v2(125.66,68.03)
  BOTTOM w0.076: UC1.AJ61 131.02,68.6 130.83,68.79 130.83,68.9 130.76,68.98 130.64,69.03 130.62,69.06 130.39,69.06 130.33,69.03 130.23,68.98 130.1,68.98 129.94,69.06 129.74,69.06 129.6,68.99 129.57,68.98 128.99,68.98 128.86,68.85 128.4,68.85 127.79,68.23 126.4,68.23 125.88,67.72 125.73,67.72 125.66,67.79 v2(125.66,68.03)
  BOTTOM w0.102: v2(130.32,23.89) 130.29,23.86 130.29,23.45 130.44,23.3 130.64,23.3 130.78,23.45 130.78,25.07 130.58,25.27 JDIMM1.135
