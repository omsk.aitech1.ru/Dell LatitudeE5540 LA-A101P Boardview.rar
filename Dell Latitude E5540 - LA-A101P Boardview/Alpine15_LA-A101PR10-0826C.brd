# Allegro board Alpine15_LA-A101PR10-0826C.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
GNDA: length 33.5
  TOP w0.102: v2(334.56,157.97) v6(335.17,157.97) ; v2(326.36,152.18) v6(327.04,152.18)
  TOP w0.508: C141.1 v2(331.11,157.14) ; v2(334.48,159.95) 335.03,159.95 335.17,160.09 C2980.1 ; v3(316.09,152.54) 315.79,152.54 C116.2 315.53,151.83 v3(316.09,151.83)
  BOTTOM w0.254: v2(334.46,161.45) JIO1.67 ; v2(311.02,148.6) 311.02,148.72 310.73,149.01 U17.26 ; JIO1.78 v2(338.56,158.95) ; C167.1 312.1,146.38 v2(311.66,145.93) 311.15,146.44 C115.2 ; v2(305.05,148.64) 305.29,148.64 305.73,149.08 U17.36 ; v2(334.56,157.97) 335.04,158.45 JIO1.79 ; JIO1.70 v2(338.47,160.95) ; JIO1.73 v2(334.48,159.95) ; JIO1.74 v2(338.5,159.95)
  BOTTOM w0.381: v2(321.1,155.51) 320.68,155.93 Q21.1 ; Q21.4 v2(321.98,153.62)
  BOTTOM w0.406: Q123.1 300.43,149.37 v2(300.93,149.87)
  BOTTOM w0.432: v2(297.54,148.07) Q123.4
  BOTTOM w0.508: C412.2 298.76,146.76 v2(299.07,147.07) ; C140.2 v2(317.31,147.57) ; v2(315.38,147.52) 315.25,147.65 C131.2 ; C150.2 301.37,150.31 v2(300.93,149.87) ; v2(299.4,149.68) 299.72,149.99 C144.1 ; C138.2 303.46,146.88 v2(303.08,146.5) ; C142.1 292.09,144.82 v2(292.22,144.94) ; C385.2 307.53,146.63 v2(307.34,146.44) ; C169.2 313.12,146.25 312.8,145.93 v2(312.48,145.93) ; v2(324.88,151.08) C117.2 v2(322.55,151.08) ; v2(318.55,154.71) Q20.3 ; R39.2 v2(315.1,150.4)
  vias: v2(325.44,152.18) v6(295.98,147.64)
GNDA_CHG: length 20.4
  TOP w0.508: v2(123.54,158.56) PC413.1 PR424.1 PC424.2 ; PR428.2 115.46,166.05 115.78,166.37 PC425.1 v3(117.62,166.37) ; v2(118.63,155.96) 118.63,155.99 118.99,156.35 PC407.1 ; v2(115.81,155.96) PC409.2 ; PC438.1 116.4,154.47 v3(117.12,155.2)
  IN3 w0.508: v2(123.54,158.56) 123.54,158.96 122.37,160.13 121.02,160.13 120.64,160.51 ; 118.17,160.22 118.48,159.91 118.48,156.11 v2(118.63,155.96) 117.87,155.2 v3(117.12,155.2) 116.57,155.2 v2(115.81,155.96)
  BOTTOM w0.102: v3(117.62,166.37) v1(116.74,166.37)
  vias: v2(117.66,161.86) v2(117.72,160.59) v2(118.23,161.23) v2(118.86,161.86) v2(118.86,160.59) v2(120.64,166.43) v2(120.64,165.82)
VCCSENSE: length 48.4
  TOP w0.203: v3(91.76,89.32) 91.76,88.89 94.99,85.66 103.96,85.66 106.34,83.28 106.34,82.9 108.67,80.56 v1(111.62,80.56) 114.81,80.56 115.54,81.3 116.12,81.3 116.86,82.03 117.49,82.03 117.77,82.31 121.94,82.31 123.74,84.11 125.91,84.11 v2(127.64,82.38)
  BOTTOM w0.076: v2(127.64,82.38) 127.3,82.71 126.84,82.71
  BOTTOM w0.102: RC250.2 125.95,82.71 126.84,82.71 ; UC1.E63 127.99,81.91 127.64,82.25 v2(127.64,82.38)
  BOTTOM w0.254: v3(91.76,89.32) 91.51,89.57 91.19,89.57 90.76,90.01 PR334.1
VCCST_PWRGD: length 15.3
  BOTTOM w0.076: UC1.B59 131.92,84.23 131.92,84.82 130.54,86.2 129.53,86.2 128.67,87.06 127.07,87.06
  BOTTOM w0.102: RC245.2 120.36,86.55 120.51,86.7 120.74,86.7 120.87,86.57 120.87,86.37 121,86.24 121.25,86.24 121.38,86.37 121.38,86.57 121.5,86.7 124.45,86.7 v1(124.63,86.89) 124.81,87.06 127.07,87.06
VDD_1.35V: length 7.2
  BOTTOM w0.102: PR102.2 37.01,19.16 36.79,19.39 v1(36.13,19.39)
  BOTTOM w0.203: PU100.11 37.61,15.63 37.1,16.14 37.1,16.88 PR101.1
  BOTTOM w0.508: PR102.2 36.98,18.12 PC111.1 36.08,18.08 36.08,17.31 36.34,17.06 PR101.1
VDDA18CR: length 3.4
  TOP w0.254: U90.14 223.98,55.82 v1(224.17,56.02) 224.17,56.76 C3032.1 C3031.1
VDDA18PLL: length 5.7
  TOP w0.102: v1(228.29,45.45) 227.87,45.45 227.45,45.87 C3033.1
  TOP w0.254: U90.34 224.98,47.79
  TOP w0.381: 224.98,47.79 224.98,47.65 226.38,46.24 C3034.1 C3033.1
VSSSENSE: length 49.6
  TOP w0.203: v3(91.38,90.11) 91.38,89.75 91.26,89.63 91.26,88.75 94.8,85.2 103.77,85.2 105.88,83.09 105.88,82.71 108.48,80.11 v1(110.02,80.11) 115,80.11 115.73,80.84 116.31,80.84 117.05,81.57 117.68,81.57 117.96,81.85 122.13,81.85 123.93,83.65 125.7,83.65 v2(127.02,82.33)
  BOTTOM w0.076: 126.84,82.33 v2(127.02,82.33)
  BOTTOM w0.102: v2(127.02,82.33) 127.84,81.51 129.68,81.51 130.03,81.87 UC1.E62 ; RC260.1 125.95,82.33 126.84,82.33
  BOTTOM w0.254: v3(91.38,90.11) 91.38,90.13 90.61,90.9 PR335.1
3301_ACAV_IN_NB: length 2.3
  TOP w0.254: PR545.1 130.15,159.1 PU701.24
3301_DSCHRG_FET_GC: length 80.2
  TOP w0.254: PR559.2 124.57,155.7 v2(124.12,156.15)
  IN1 w0.254: v3(137.05,180.89) 137.18,180.89 138.55,182.26 145.28,182.26 150.77,176.77 156.56,176.77 158.44,174.89 158.44,172.25 157.04,170.85 157.04,166.25 155.29,164.5 130.93,164.5 129.86,163.44 128.95,163.44 127.52,162.01 127.52,161.48 126.41,160.36 126.41,158.36 124.2,156.15 v2(124.12,156.15)
  BOTTOM w0.254: PR510.2 132.77,179.11 v1(133.98,179.11) 136.01,179.11 137.05,180.15 v3(137.05,180.89)
3301_PWRSRC: length 2.7
  TOP w0.254: PU701.15 134.9,155.2 135.14,154.95 135.14,154.62 135.52,154.25 PR558.1
+ALC290_LDO_CAP: length 6.7
  BOTTOM w0.254: C140.1 317.31,151.22 v1(317.03,151.5) 316.6,151.5 316.35,151.24 315.81,151.24 315.43,151.62 312.73,151.62 312.62,151.73 U17.21
+ALC3226_CPVEE: length 4.7
  BOTTOM w0.102: C138.1 305.37,145.56 v1(305.16,145.35)
  BOTTOM w0.254: C138.1 305.37,147.61 306.73,148.97 U17.34
+ALC3226_VREF: length 5.2
  BOTTOM w0.127: C169.1 v1(313.31,148.88)
  BOTTOM w0.254: U17.25 311.23,149.15 311.4,148.98 311.91,148.98 312.23,148.66 312.23,147.59 C167.2
  BOTTOM w0.508: C167.2 313.13,147.47 C169.1
+AUX_LDO: length 5.6
  BOTTOM w0.203: U27.12 20.59,23.19 20.5,23.1 19.29,23.1 18.58,22.39 18.14,22.39
  BOTTOM w0.508: 18.14,22.39 17.66,21.91 v1(17.12,21.91) 16.93,21.91 16.63,22.21 C241.1
+BATT_SUM: length 4.8
  TOP w0.254: 140.73,163.11 141.21,163.11 v1(141.54,162.77) 142.23,162.09 143.91,162.09 144.36,161.63 PR502.1
  vias: v2(137.43,171.49) v2(137.43,170.85) v2(137.43,170.22) v2(137.43,169.58) v2(137.43,168.95) v2(137.43,168.31) v2(137.43,167.68) v2(138.07,171.49) v2(138.07,170.85) v2(138.07,170.22) v2(138.07,169.58) v2(138.07,168.95) v2(138.07,168.31) v2(138.07,167.68) v2(140.61,171.49) v2(140.61,170.85) v2(140.61,170.22) v2(140.61,169.58) v2(140.61,168.95) v2(140.61,168.31) v2(140.61,167.68)
+BL_PWR_SRC:
  vias: v3(95.65,156.69) v3(96.28,156.72) v3(96.92,156.72) v3(97.58,156.73) v6(98.62,157.21)
+CAP_LDO: length 12.1
  TOP w0.102: v1(200.18,116.06) 200.18,116.5 198.9,117.78 197.03,117.78 196.84,117.59 196.84,117.05 196.8,117.02 196.8,116.46 196.78,116.43 C336.1
  TOP w0.305: U37.B46 193.59,119.67 v3(193.72,119.81)
  TOP w0.508: C336.1 196.04,116.43 v3(195.71,116.1)
  IN3 w0.508: v3(193.72,119.81) 193.72,119.18 195.11,117.79 195.11,116.7 v3(195.71,116.1)
+CHGR_DC_IN: length 13.9
  TOP w0.508: v2(124.07,152.64) 124.1,152.61 124.32,152.61 PR530.1
  IN2 w0.508: v2(124.07,152.64) 123.36,151.93 115.51,151.93 112.89,154.55 v2(112.89,154.98)
  vias: v6(109.62,156.12)
+COINCELL: length 14.5
  BOTTOM w0.508: RTCR1.1 7.81,17.48 6.84,16.51 v1(5.59,16.51) 5.2,16.9 5.2,19.65 8.03,22.48 JBT1.1
+DC1_PWR_SRC: length 11.3
  TOP w0.203: PU51.12 215.42,156.01 215.96,155.46 215.96,154 PC68.1
  TOP w0.508: PC68.1 216.75,153.17 v1(215.51,151.93) 215.51,151.34 215.84,151.02 v3(216.04,151.02)
  IN3 w0.508: 218.08,154.32 215.92,152.16 215.92,151.14 v3(216.04,151.02)
  vias: v2(220.97,154.77) v2(221.14,156.27) v2(221.14,155.66) v2(221.17,156.85) v2(221.45,155.15) v2(221.8,156.85) v2(221.78,156.27) v2(221.78,155.66) v2(221.78,154.62) v2(222.16,155.1) v2(222.44,156.85) v2(222.41,156.27) v2(222.41,155.66) v2(222.47,154.6) v2(222.77,155.1) v2(223.05,155.66) v3(219.7,166) v3(219.95,165.37) v3(220.34,166) v3(220.72,165.37) v3(220.97,166) v3(221.35,165.37) v3(221.61,166) v3(221.99,165.37)
+DC_IN: length 71.9
  TOP w0.102: PC11.1 101.87,173.18 102.09,173.39 102.68,173.39 v6(103.24,173.95) ; v3(109.67,152.51) v6(109.67,153.33)
  TOP w0.508: PC11.1 101.72,172.54 PR19.1 99.42,172.54 v3(98.16,173.8) ; PR445.1 111.49,141.9 110.18,143.22 v6(110.18,146.28) 110.18,149.08 109.21,150.05 109.21,152.06 v3(109.67,152.51) ; PQ5.3 127.86,143.17 127.48,143.55 PC5.1 127.48,146.2 PR14.1 126.89,146.31 v3(126.51,146.7)
  IN2 w0.762: 124.35,146.7 121.83,149.21 119.02,149.21 118.48,148.68 115.69,148.68 114.9,149.47 114.9,151.24 113.63,152.51 v3(109.67,152.51) 109.67,153.68 106.06,157.29 106.06,158.53 101.84,162.75 101.84,163.66 99.79,165.72 98.22,165.72 95.93,168.01 95.93,171.56 v3(98.16,173.8)
  vias: v3(125.87,146.7)
+DC_IN_SS: length 74.8
  TOP w0.102: v3(108.59,160.21) 108.78,160.21 v6(109.13,160.57)
  TOP w0.508: PR544.2 143.14,144.53 142.68,144.99 PQ520.3 142.68,149.36 v2(142.36,149.68) ; PR529.1 124.49,153.92 v3(123.31,155.1)
  IN1 w0.508: v3(107.89,159.92) 107.89,160.75 109.97,162.83 109.97,165.29 109.22,166.04 109.17,166.12 108.02,167.27 107.03,167.27 107.01,167.28 106.39,167.28 106.37,167.27 103.65,167.27 99.28,171.64 99.28,176.16 v3(96.36,179.08)
  IN2 w0.508: v3(115,156.68) 119.83,156.68 121.17,155.33 123.08,155.33 v3(123.31,155.1) 123.82,154.6 124.15,154.6 126.81,151.93 130.8,151.93 132.65,150.07 141.96,150.07 v2(142.36,149.68)
  IN3 w0.508: v3(108.59,160.21) 108.63,160.21 112.16,156.68 v3(115,156.68)
  vias: v3(95.72,179.08)
+DCIN:
  vias: v1(115.26,159.88)
+DCIN_JACK: length 8.2
  BOTTOM w0.102: v6(96.47,166.84) 95.88,166.84 95.51,167.2 PL4.1 ; v6(96.79,152.82) 96.09,152.82 95.67,152.39 PJPDC1.2
  vias: v3(87.56,152.96) v3(87.56,152.31) v3(87.57,151.65) v3(87.57,151) v3(87.57,150.35) v3(88.22,152.98) v3(88.2,152.32) v3(88.2,151.65) v3(88.22,151.01) v3(88.2,150.35) v3(91.33,168.74) v3(91.34,168.1) v3(91.35,169.39) v3(91.99,169.39) v3(92.05,168.73) v3(92.08,168.1) v3(92.66,169.43) v3(92.83,168.77) v3(92.79,168.12) v3(93.26,169.87) v6(93.37,169.26)
+DCPRRTC: length 2.3
  TOP w0.254: v2(164.38,71.07) 164.38,70.8 164.17,70.6 163.49,70.6 CC36.1
  BOTTOM w0.254: v2(164.38,71.07) 164.2,70.9 UC1.AE7
+DIMM1_VREF_DQ: length 11.3
  BOTTOM w0.356: JDIMM1.1 87.98,27.94
  BOTTOM w0.508: RD1.2 CD2.1 CD1.1 81.68,28.36 v1(82.36,27.67) 82.79,27.24 85.08,27.24 86.12,28.28 87.64,28.28 87.98,27.94
+DIMM2_VREF_DQ: length 5.3
  TOP w0.508: v2(162.44,27.98) 161.83,27.36 CD33.1 CD32.1 RD7.2 v1(161.78,24.57)
  BOTTOM w0.356: JDIMM2.1 162.48,27.94 v2(162.44,27.98)
+DOCK_PWR_BAR: length 68.8
  TOP w0.508: v3(123.99,155.33) 124.52,154.81 PR531.2
  IN2 w0.508: 122.57,158 123.19,157.38 123.19,156.12 123.98,155.33 v3(123.99,155.33)
  IN2 w1.016: 110.56,159.9 112.8,157.66 122.23,157.66 122.57,158 122.57,159.12 127.98,164.53 155.13,164.53 159.48,168.87 159.48,178.24 159.45,178.27
  vias: v1(157.89,178.23) v2(158.84,182.53) v2(158.84,181.9) v2(158.84,181.26) v2(158.84,180.63) v2(158.84,179.99) v2(158.84,179.36) v2(159.6,182.53) v2(159.6,181.9) v2(159.6,181.26) v2(159.6,180.63) v2(159.6,179.99) v2(159.6,179.36) v3(110.15,161.38) v3(110.18,160.69)
+FB_PLLAVDD: length 22.2
  TOP w0.508: LV76.1 55.14,85.14 v3(56.02,86.02) ; v5(53.97,100.24) 54.42,99.79 CV228.1
  IN2 w1.016: 71.21,98.41 71.21,97.25 69.94,95.97 69.94,95.02 69.05,94.13 69.05,91.55 66.95,89.45 64.86,89.45 63.54,88.12 63.54,87.97 62.2,86.63
  BOTTOM w0.2: v5(53.97,100.24) UV1.P22
  BOTTOM w0.3: UV1.H22 53.57,104.8 53.9,105.13 53.93,105.13 v5(54,105.2) ; v2(58.16,106.1) 58.56,106.5 UV1.F16
  BOTTOM w0.508: L73.1 74.02,98.04 v3(73.47,98.59)
  vias: v1(51.79,87.18) v2(51.76,85.99) v2(52.4,85.99) v2(72.71,104.8) v2(72.71,104.19)
+GPU_CORE: length 1
  TOP w0.381: v3(56.72,85.61) 56.72,86.49 RZ40.1
  vias: v2(47.43,63.89) v2(47.43,62.87) v2(47.82,63.38) v2(48.13,63.89) v2(48.13,62.87) v2(48.45,63.38) v2(48.77,63.89) v2(48.77,62.87) v2(49.09,63.38) v2(49.4,63.89) v2(49.4,62.87) v2(49.72,63.38) v2(50.04,63.89) v2(50.04,62.87) v2(50.36,63.38) v2(50.67,63.89) v2(50.74,62.87) v2(51.07,63.36) v2(51.37,63.89) v2(51.44,62.81) v2(51.75,63.32) v2(52.01,63.89) v2(52.07,62.81) v2(52.39,63.33) v2(52.71,63.89) v2(52.71,62.81) v2(53.02,63.33) v2(53.34,63.89) v2(53.34,62.81) v2(53.66,63.33) v2(54.01,63.86) v2(53.98,62.81) v2(54.29,63.33) v2(54.61,63.89) v2(54.61,62.81) v2(54.93,63.38) v2(55.25,63.89) v2(55.25,62.81) v2(55.56,63.38) v2(55.88,63.89) v2(55.88,62.81) v2(56,97.36) v2(56.2,63.38) v2(56.52,63.89) v2(56.52,62.81) v2(56.83,63.38) v2(57.15,63.89) v2(57.15,62.81) v2(57.47,63.38) v2(57.73,101.36) v2(57.79,63.89) v2(57.79,62.81) v2(58.1,63.38) v2(58.42,63.89) v2(58.42,62.81) v2(58.69,102.38) v2(58.74,63.38) v2(59.06,63.89) v2(59.06,62.81) v2(59.37,63.38) v2(59.69,63.89) v2(59.69,62.81) v2(59.77,101.36) v2(60.01,63.38) v2(60.33,63.89) v2(60.33,62.81) v2(60.64,63.38) v2(60.78,102.31) v2(60.96,63.89) v2(60.96,62.81) v2(61.28,63.38) v2(61.59,63.89) v2(61.6,62.81) v2(61.91,63.38) v2(62.8,103.24) v2(63.67,101.26) v2(64.71,98.23) v2(65.04,102) v3(54.3,85.74) v3(57.47,85.58) v3(58.11,85.56) v3(59.22,85.28) v3(64.94,96.28) v5(56.72,102.22) v5(56.72,100.37) v5(56.72,95.54) v5(57.73,98.34) v5(57.86,96.34) v5(58.72,100.37) v5(58.73,98.34) v5(58.85,96.34) v5(59.65,103.27) v5(59.74,104.17) v5(59.7,98.38) v5(60.63,96.33) v5(60.7,98.33) v5(60.77,100.37) v5(61.74,95.56) v5(62.72,102.17) v5(62.72,100.34) v5(62.72,98.44) v5(62.75,97.36) v5(63.85,97.39) v6(52.29,62.14)
+LCDVDD:
  vias: v3(100.22,139.18) v3(100.98,139.48) v3(100.98,138.85) v3(100.98,138.21) v6(101.5,139.17)
+LOM_VCT: length 1.4
  TOP w0.127: C316.1 v6(197.81,185.96)
  vias: v2(197.45,182.99) v2(197.91,183.35)
+NBDOCK_DC_IN_SS: length 76.5
  TOP w0.102: v1(176.19,177.19) 176.19,178.75 v3(175.78,179.16)
  TOP w0.508: PQ500.1 141.96,156.32 141.74,156.09 v2(141.1,156.09) ; v2(134.62,159.08) 135.19,159.65 PQ522.1 ; v2(139,147.71) 138.73,147.43 PQ517.3 138.73,144.38 PR528.2
  IN1 w0.508: v2(134.62,159.08) 134.92,158.77 140.11,158.77 141.1,157.79 v2(141.1,156.09)
  IN2 w0.508: v2(141.1,156.09) 143.9,156.09 149.04,161.23 156.12,161.23 159.58,164.68 159.58,166.74 161.31,168.46 161.31,170.55 162.55,171.79 164.48,171.79 165.62,172.93 167.38,172.93 173.93,179.49 175.45,179.49 v3(175.78,179.16)
  BOTTOM w0.254: 176.62,177.91 176.95,177.58 JDOCK1.41
  BOTTOM w0.508: v2(141.1,156.09) 139.74,154.74 139.74,148.45 v2(139,147.71) ; 176.62,177.91 176.62,178.32 v3(175.78,179.16)
+PBATT: length 93.2
  TOP w0.254: PR565.1 149.25,177.53 PQ526.3
  TOP w0.508: PR565.1 149.74,178.62 v1(147.65,180.71) 145,183.36 136.25,183.36 136.24,183.37 ; v2(124.03,156.73) 124.41,156.73 124.55,156.59 PR534.2
  IN1 w0.254: v2(124.03,156.73) 124.15,156.73 125.95,158.53 125.95,160.46 127.14,161.66 127.14,162.32 128.72,163.89 129.78,163.89 130.77,164.88 131.09,164.88 155.13,164.88 156.66,166.41 156.66,171.01 158.05,172.41 158.05,174.73 156.4,176.39 150.61,176.39 145.12,181.88 139.51,181.88 v3(135.4,177.76)
+PBATT_IN_SS: length 7.7
  TOP w0.508: PD501.2 139.4,162.37 134.61,162.37 134.38,162.6 134.38,163.49
  vias: v1(131.02,171.02)
+PCH_ASATA3PLL: length 32.3
  TOP w0.508: CC77.1 155.74,104.11 LC2.2 v3(156.44,106.25) ; v3(162.2,88.18) 162.32,88.3 162.32,88.35 163.66,89.68 163.82,89.68 v1(164.18,90.04) 164.18,90.67 CC49.1 165.6,92.09 RC19.2 RC14.1 165.6,93.67 164.52,94.75 164.52,97.51 v3(164.39,97.64)
  IN2 w0.508: v3(156.44,106.25) 156.44,104.44 162.53,98.36 162.57,98.36 162.6,98.34 163.83,98.34 164.39,97.78 v3(164.39,97.64)
  BOTTOM w0.203: 161.92,84.1 161.73,83.91 UC1.B11
  BOTTOM w0.381: 161.92,84.1 161.96,84.1 162.24,84.37 162.24,85.2 162.65,85.62 162.65,86.73 162.7,86.78 162.7,87.67 v3(162.2,88.18)
+PCH_AUSB3PLL: length 34.1
  TOP w0.508: RC163.1 147.59,93.23 147.46,93.36 v3(147.46,94.02) ; v3(151.76,97.4) 151.83,97.32 RC161.1
  IN2 w0.508: v3(147.46,94.02) 147.46,96.96 149.06,98.56 150.59,98.56 v3(151.76,97.4) 153.05,98.69 153.05,100.44 v3(153.36,100.75)
  BOTTOM w0.254: UC1.B18 157.27,84.28 157.01,84.54 157.01,85.73 156.98,85.77 156.98,86.26 157.52,86.81
  BOTTOM w0.508: 157.52,86.81 157.52,91.43 157.24,91.71 157.24,93.31 158.13,94.19 158.13,98.84 156.42,100.55 v3(155.59,100.55)
  vias: v1(153.44,101.64)
+PCH_DCPSUS: length 51.1
  TOP w0.241: 160.36,83.02 159.91,82.56 159.91,80.14 160.36,79.69 v2(160.36,79.66)
  TOP w0.381: CC61.1 167.4,92.65 v1(168.27,91.78) 169.05,90.99 169.05,89.95 168.24,89.14 163.92,89.14 163.21,88.43 163.21,86.65 160.42,83.86 160.42,83.07 160.36,83.02 ; v2(160.47,69.38) 160.42,69.43 CC66.1
  TOP w0.508: CC61.1 167.26,96.35 166.96,96.05 v3(166.72,96.05) ; RC276.2 172.74,102.02 CC62.1 172.99,101.76 172.99,100.39 v3(172.81,100.21)
  IN2 w0.254: v2(160.36,79.66) 160.16,79.47 160.16,78.14 159.55,77.53 159.55,76.41 158.61,75.48 v3(158.41,75.48)
  IN2 w0.508: v3(169.66,96.1) 172.81,99.25 v3(172.81,100.21)
  IN3 w0.254: v3(158.41,75.48) 158.92,75.48 159.15,75.25 159.15,73.11 159.4,72.86 160.32,72.86 160.82,72.35 160.82,71.11 160.47,70.75 v2(160.47,69.38)
  IN3 w0.508: v3(166.72,96.05) 166.77,96.1 v3(169.66,96.1)
  BOTTOM w0.254: v2(160.47,69.38) 160.48,69.36 160.5,69.38 160.56,69.38 UC1.AH13 ; UC1.J13 160.68,79.33 v2(160.36,79.66)
+PCH_DCPSUS1: length 1.4
  BOTTOM w0.254: v2(163.75,72.03) 163.56,71.84 163.56,71.6 163.55,71.59 UC1.AD8 UC1.AD10
  vias: v1(167.66,71.73)
+PCH_DCPSUS4: length 39.3
  TOP w0.508: LC4.2 168.87,99.15 CC75.1 167.66,100.37 v3(167.66,100.67) ; v2(163.73,72.98) 163.68,72.92 163.67,72.92 163.45,72.7 CC53.1
  IN2 w0.508: 162.88,84.39 166.89,84.39 168.04,85.53 168.04,89.08 169.15,90.19 169.15,93.1 167.74,94.51 167.74,95.71 170.63,98.59 170.63,100.85 169.87,101.61 168.04,101.61 167.66,101.23 v3(167.66,100.67) ; v2(163.73,72.98) 163.38,72.98 163.1,73.26 163.1,78.29 162.84,78.55 162.82,78.55
  BOTTOM w0.254: UC1.AB8 163.55,72.8 v2(163.73,72.98)
+PCH_RTC_VCCSUS3_3: length 50.2
  TOP w0.127: v3(188.99,53.5) v1(188.23,53.5)
  TOP w0.457: CC30.1 160.72,57.39 v3(161.32,57.99)
  TOP w0.508: RC261.2 RC264.2 189.2,53.3 v3(188.99,53.5)
  IN2 w0.508: v3(188.99,53.5) 188.41,54.09 185.84,54.09 183.48,51.73 175.14,51.73 173.13,53.73 169.87,53.73 168.11,55.49 168.11,56.7 167.43,57.39 165.57,57.39 165.27,57.7 161.62,57.7 v3(161.32,57.99) 160.5,57.99 159.99,58.51 159.99,62.19 160.59,62.8 160.59,64.24 160.35,64.48 160.35,67.59 161.26,68.5 v2(161.26,68.77)
  BOTTOM w0.305: v2(161.26,68.77) 161.35,68.77 161.67,69.08 UC1.AH11
+PCH_VCC1P05: length 23.9
  TOP w0.508: LC3.2 162.79,95.38 163.17,94.99 CC79.1 162.65,93.76 v3(162.22,94.19)
  IN2 w0.508: v3(157.57,86.02) 157.78,86.02 158.03,85.76 159.25,85.76 159.64,86.16 159.64,86.94 160.82,88.12 160.82,89.88 161.56,90.61 161.9,90.61 162.22,90.93 v3(162.22,94.19)
  IN3 w0.254: v2(157.52,79.66) 157.52,79.68 157.08,80.13 157.08,83.74 157.23,83.89 157.23,84.35 156.89,84.7 156.89,85.47 157.43,86.02 v3(157.57,86.02)
  BOTTOM w0.254: UC1.K19 157.44,79.58 v2(157.52,79.66) 157.6,79.66 UC1.J18
  vias: v1(158.42,83.43)
+PCH_VCCACLKPLL: length 14.5
  TOP w0.508: RC45.2 156.76,92.14 ; 156.76,92.14 157.04,91.86 157.04,91.86 157.27,91.64 157.27,91.63 157.67,91.22 CC58.1 157.88,90.41 157.85,90.38 v1(157.85,89.8) 157.85,87.49 157.14,86.78 v3(156.48,86.78) ; 156.76,92.14 156.78,92.14 157.46,92.81 157.46,93.28 157.86,93.69 159.1,93.69 CC78.1 159.17,94.89 LC6.2
  BOTTOM w0.254: 156.48,85.74 156.48,85.1 156.62,84.96 UC1.A20
  BOTTOM w0.381: 156.48,85.74 v3(156.48,86.78)
+PCH_VCCDSW: length 17.7
  TOP w0.241: v2(157.21,69.39) 156.81,69 156.81,68.5 156.47,68.16 156.47,64.25 155.96,63.74 v1(155.96,62.33) 155.96,61.13
  TOP w0.508: C413.2 RC275.2 156.28,60.81 155.96,61.13
  BOTTOM w0.254: UC1.AG20 156.83,69.76 v2(157.21,69.39) 157.58,69.76 UC1.AG19
+PCH_VCCDSW3_3: length 218.7
  TOP w0.305: v3(226.08,75.37) 225.86,75.59 JAPS1.7 ; JAPS1.3 v3(226.08,73.59)
  TOP w0.381: v2(194.45,64.05) 193.95,64.05 192.22,65.77 CC32.1
  TOP w0.457: RC197.2 172.74,56.98 v3(172.74,55.66)
  TOP w0.508: v3(177.44,56.22) 176.93,56.22 RC206.2 ; C413.1 157.19,51.24 164.01,44.42 v3(209.21,44.42)
  TOP w1.016: v3(210.02,68.39) v3(210.02,69.38) 209.13,69.38 207.23,67.47 197.78,67.47 196.51,68.74 192.46,68.74 191.82,68.1
  IN1 w0.508: v3(184.8,54.9) 184.8,57.31 183.56,58.56 183.56,60.1 181.91,61.75 181.91,62.78 182.16,63.03 v3(182.16,63.77) 183.3,63.77 184.34,62.72 186.86,62.72 187.26,62.32 190.01,62.32 190.34,61.99 192.4,61.99 v2(194.45,64.05)
  IN2 w0.508: 176.88,55.66 v3(172.74,55.66) 172.23,55.66 171.01,56.88 169.13,56.88 167.96,58.05 165.95,58.05 165.17,58.84 162.88,58.84 162.3,59.42 162.3,63.36 162.13,63.52 162.13,63.74 ; 176.88,55.66 176.88,55.08 178.83,53.12 183.79,53.12 184.8,54.14 v3(184.8,54.9) 185.6,55.7 187.79,55.7 192.58,50.91 198.94,50.91 205.43,44.42 v3(209.21,44.42) ; 176.88,55.66 v3(177.44,56.22) ; 162.17,65.09 162.17,67.8 162.42,68.05 v2(162.92,68.05)
  IN2 w1.016: 210.91,69.23 211.39,69.71 211.39,75.04 211.37,75.07
  IN3 w0.381: v2(194.45,64.05) 194.21,64.29 190.41,64.29 190.26,64.44 190.26,65.89 v3(191.4,67.03) 192.01,67.64 192.01,71.06 190.52,72.55 v3(185.49,72.55)
  BOTTOM w0.254: RP14.1 194.44,64.03 v2(194.45,64.05)
  BOTTOM w0.305: UC1.AH10 162.92,68.65 v2(162.92,68.05)
  BOTTOM w1.016: 225.03,74.89 224.98,74.89 222.95,76.92 222.95,77.74 221.76,78.93 215.33,78.93 212.84,76.44
  vias: v1(225.95,74.43) v3(210.86,76.24) v3(211.73,76.24)
+PCH_VCCDSW_R: length 2.2
  TOP w0.102: v1(158.13,53.38) CC65.1
  TOP w0.508: CC65.1 158.02,54.46 RC275.1
+PECI_VREF: length 6.3
  TOP w0.279: 161.67,128.78 161.67,128.76 U38.B51
  TOP w0.508: C360.1 R374.1 158.61,131.39 v1(159.22,130.77) 159.68,130.77 161.67,128.78
+PNVVDD: length 36.7
  TOP w0.102: v2(46.56,55.4) v6(46.56,56.22)
  IN1 w0.254: v2(46.56,55.4) 45,53.83 45,48.06 43.94,47 43.94,34.11 48.78,29.27 v2(48.78,25.61)
  BOTTOM w0.254: PR620.1 48.89,23.28 48.33,23.84 48.33,25.16 v2(48.78,25.61)
+PWR_SRC:
  vias: v2(40.28,28.99) v2(40.91,28.99) v2(41.55,28.99) v2(42.18,28.99) v2(70.53,67.35) v2(71.11,67.35) v2(71.14,66.71) v2(71.72,67.35) v2(71.72,66.71) v2(72.83,29.19) v2(72.83,28.56) v2(73.47,29.19) v2(73.47,28.56) v2(74.1,29.19) v2(74.1,28.56) v2(74.74,29.19) v2(74.74,28.56) v2(75.37,29.19) v2(75.37,28.56) v2(96.64,113.02) v2(96.64,112.13) v2(96.64,111.37) v2(96.64,110.48) v2(97.28,113.02) v2(97.28,112.13) v2(97.28,111.37) v2(97.28,110.48) v3(40.17,20.99) v3(40.5,20.38) v3(40.83,20.99) v3(41.24,20.36) v3(41.52,21.02) v3(83.28,127.52) v3(83.91,127.55) v3(84.65,127.52) v3(84.69,142.33) v3(84.9,141.64) v3(84.95,140.93) v3(84.98,140.19) v3(84.95,139.48) v3(85.32,142.35) v3(85.36,127.49) v3(85.54,141.67) v3(85.59,140.96) v3(85.61,140.23) v3(85.59,139.46) v3(85.96,142.35) v3(86.15,127.49) v3(86.25,140.22) v3(86.22,139.49) v3(86.27,141.64) v3(86.33,140.93) v3(86.78,127.49) v3(87.57,127.49) v3(88.33,127.47) v3(89.04,127.47) v3(92.64,158.61) v3(93.31,158.48) v3(93.64,159.04) v3(93.95,158.48) v3(125.62,178.85) v3(125.62,177.58) v3(125.62,176.31) v3(125.87,176.95) v3(126,179.49) v3(126,178.22) v3(126.25,178.85) v3(126.25,176.31) v3(126.38,177.58) v3(126.64,178.22) v3(126.64,176.95) v3(126.76,179.49) v3(127.02,178.85) v3(127.02,177.58) v3(127.02,176.31) v3(127.4,179.49) v3(127.4,178.22) v3(127.4,176.95) v3(127.65,178.85) v3(127.78,177.58) v3(127.78,176.31) v3(128.03,179.49) v3(128.03,178.22) v3(128.03,176.95) v3(214.01,166.38) v3(214.01,165.75) v3(214.01,165.11) v3(214.01,164.48) v3(214.48,166.88) v3(214.65,165.75) v3(214.65,165.11) v3(214.65,164.48) v3(214.96,167.31) v3(214.98,166.39) v3(215.28,165.75) v3(215.28,165.11) v3(215.28,164.48) v3(215.92,165.75) v3(215.92,165.11) v3(215.92,164.48) v3(216.55,165.75) v3(216.58,165.11) v6(69.89,68.41)
+PWR_SRC_AC: length 39.2
  TOP w0.508: v2(137.38,154.64) 136.98,154.25 PR558.2
  IN2 w0.508: v3(161,174.51) 161.31,174.2 161.31,171.56 160.42,170.67 160.42,168.55 154.21,162.34 145.71,162.34 138.01,154.64 v2(137.38,154.64)
  BOTTOM w0.508: v3(161,174.51) 160.9,174.61 158.05,174.61
  vias: v1(156.84,174.18) v2(153.99,174.44) v2(153.99,173.81) v2(153.99,173.17) v2(153.99,172.55) v2(153.99,171.91) v2(153.99,171.28) v2(153.99,170.64) v2(154.62,174.44) v2(154.62,173.81) v2(154.62,173.17) v2(154.62,172.55) v2(154.62,171.91) v2(154.62,171.28) v2(154.62,170.64) v2(155.26,174.44) v2(155.26,173.81) v2(155.26,173.17) v2(155.26,172.55) v2(155.26,171.91) v2(155.26,171.28) v2(155.26,170.64) v3(105.58,180.1) v3(105.58,179.46) v3(105.81,178.68) v3(105.76,177.96) v3(106.21,180.1) v3(106.21,179.46) v3(106.49,178.65) v3(106.47,177.99) v3(107.03,181.62) v3(107.13,182.64) v3(107.59,182.08) v3(107.81,182.69) v3(108.41,182.46)
+RSVD_VCC3P3_1: length 3.2
  TOP w0.203: U21.1 196.91,145.63 196.11,144.83 v1(195.7,144.83) 195.12,144.83 194.7,144.41 R178.2
+RTC_CELL: length 615.1
  TOP w0.102: v3(36.21,20.92) v6(36.21,21.54)
  TOP w0.381: v2(163.38,69.2) 163.2,69.38 CC39.1
  TOP w0.508: v2(153.64,121.74) R332.1 ; RC73.2 v3(189.02,58.89) ; v2(159.07,116.9) 158.91,116.9 158.56,116.56 158.56,116.53 158.44,116.41 R328.1 ; v3(166.64,58.99) 166.03,58.38 RC7.1 165.71,58.29 CC38.1 CC35.1 RC1.1 ; v3(158.89,112.89) 160.23,112.89 R327.1
  IN1 w0.508: v3(232.81,59.75) 232.81,56.58 232.22,55.99 226.56,55.99 216.63,46.06 v3(216.63,42.71)
  IN2 w0.508: v2(153.64,121.74) 152.42,120.51 152.42,118.88 153.26,118.05 156.84,118.05 157.24,117.64 157.24,117 157.79,116.46 158.63,116.46 v2(159.07,116.9) ; 158.03,83.45 161.56,86.98 161.56,88.72 162.86,90.01 162.86,95.52 161.05,97.32 161.05,98.86 154.45,105.46 v3(154.45,106.37) ; 157.24,78.83 156.78,78.37 156.78,73.06 157.27,72.58 161.1,72.58 161.33,72.81 161.79,72.81 162.6,72 162.6,69.76 162.83,69.53 ; 168.38,59.09 168.17,59.31 168.17,60.43 168.16,60.44 168.16,60.9 167,62.06 165.62,62.06 165.07,62.62 165.07,63.93 164.75,64.25 164.25,64.25 ; 168.38,59.09 166.74,59.09 v3(166.64,58.99) ; 168.38,59.09 173.63,59.09 173.8,59.27 175.5,59.27 177.36,57.42 178.91,57.42 179.47,56.86 179.47,56.5 179.47,55.51 180.18,54.8 182.67,54.8 183.76,55.89 183.76,58.25 184.39,58.89 v3(189.02,58.89) v3(190.39,58.89) 190.49,58.89 191.99,57.39 193.15,57.39 194.5,58.74 194.87,58.74 194.88,58.75 195.36,58.75 195.38,58.74 195.51,58.74 197.36,56.88 203.44,56.88 207.94,52.38 207.94,51.18 216.41,42.71 v3(216.63,42.71) 216.98,42.71 226.97,32.73 226.97,29.42 227.3,29.09 227.3,26.27 227.49,26.08 227.49,24.33 226.3,23.15 226.3,21.98 228.08,20.2 228.08,16.32 228.06,16.29 228.06,16.24 226.46,14.64 203.88,14.64 202.81,13.58 152.08,13.58 150.11,11.6 145.95,11.6 145.64,11.29 140.92,11.29 138.55,13.65 118.76,13.65 116.7,15.71 116.09,15.71 115.56,16.24 107.54,16.24 106.19,17.59 90.8,17.59 90.64,17.74 86.52,17.74 79.64,24.62 76.29,24.62 75.2,23.53 65.47,23.53 64.66,22.72 54.7,22.72 54.6,22.82 43.53,22.82 42.97,23.38 39.26,23.38 36.8,20.92 v3(36.21,20.92) ; v2(297.88,152.79) 295.29,152.79 292.4,149.9 290.29,149.9 289.17,148.78 288.36,148.78 286.83,147.26 275.45,147.26 251.81,123.61 232.32,123.61 231.76,124.18 230.88,124.18 228.29,121.59 228.29,113.99 227.37,113.08 227.37,102.93 234.56,95.74 234.56,92.11 235.37,91.3 235.37,80.7 233.21,78.55 233.04,78.4 232.95,78.28 230.5,75.83 230.5,69.38 229,67.88 229,63.59 232.81,59.78 v3(232.81,59.75)
  BOTTOM w0.254: UC1.AG10 162.81,69.76 v2(163.38,69.2)
  BOTTOM w0.508: v3(190.39,58.89) 191.86,58.89 192.4,59.42 195.95,59.42 196.21,59.68 RC8.1 197.25,59.9 198.19,60.84 201.97,60.84 202.28,60.54 202.53,60.54 202.54,60.53 RC6.1 ; v3(36.21,20.92) 32.45,20.92 28.69,17.16 15.33,17.16 14.51,17.98 C50.1 11.68,17.03 RTCD1.1 ; v3(158.89,112.89) 158.89,116.72 v2(159.07,116.9) ; v2(153.64,121.74) 153.59,121.74 152.24,120.38 152.24,117.49 153,116.72 153,114.06 152.75,113.8 152.75,112.53 153.76,111.52 153.76,107.06 v3(154.45,106.37) ; R208.1 298.39,151.55 297.88,152.06 v2(297.88,152.79)
+RTC_CELL_VBAT: length 11.7
  TOP w0.305: U38.B64 162.54,121.64 v3(162.98,121.2)
  TOP w0.508: C345.1 R332.2 155.57,121.74 155.68,121.63 v2(156.02,121.63)
  IN3 w0.508: v2(156.02,121.63) 156.45,121.63 156.61,121.78 158.71,121.78 159.41,121.08 159.7,121.08 159.71,121.07 161.39,121.07 161.96,121.64 162.03,121.64 162.04,121.65 162.53,121.65 162.54,121.64 162.59,121.64 162.98,121.25 v3(162.98,121.2)
  BOTTOM w0.102: v2(156.02,121.63) v1(155.4,121.63)
+SD_IO_LDO: length 0.5
  TOP w0.102: v2(19.83,30.38) v1(19.83,29.83)
+SDC_IN: length 74.3
  TOP w0.406: PU401.3 124.82,147.91 PC406.1
  TOP w0.508: PR421.1 122.87,157.29 122.37,156.78 v3(121.96,156.78) 121.76,156.58 PR422.1 119.88,155.97 120.22,155.62 PC400.1 ; PC406.1 124.84,148.39 124.6,148.63 v2(123.92,148.63) ; v2(132.1,147.38) 132.1,148.17 PR542.1
  IN2 w0.508: v2(123.92,148.63) 130.85,148.63 v2(132.1,147.38)
  IN3 w0.508: v3(100.3,182.51) 102.58,180.22 102.58,174.74 100.68,172.83 100.68,170.27 103.03,167.92 103.03,162.58 106.59,159.02 107.86,159.02 111.17,155.71 114.67,155.71 115.87,154.52 119.65,154.52 119.98,154.85 119.98,156.35 120.41,156.78 v3(121.96,156.78) 122.22,156.78 122.67,156.32 122.67,149.87 v2(123.92,148.63)
  vias: v1(101.27,183.31)
+SIM_PWR: length 57.2
  TOP w0.508: U28.5 v2(254.79,181.39) 254.79,180.82 254.54,180.58 C263.1 254.54,177.58 v1(250.04,173.07) 248.43,171.46 248.43,165.39 247.92,164.88 247.92,157.11 245.63,154.82 245.63,149.73 244.81,148.91 244.81,147.14 245.51,146.44 245.51,145.15 245.05,144.69 240.78,144.69 v3(240.63,144.84)
  BOTTOM w0.508: JMINI2.8 241.37,144.1 v3(240.63,144.84) ; v2(254.79,181.39) 254.79,182.28 255.3,182.79 257.71,182.79 258.99,184.07 JSIM1.1
+SM_VREF_CA: length 130
  TOP w0.102: v6(102.78,15.07) CC67.1
  TOP w0.508: CC67.1 102.58,13.98 101.65,13.05 RC68.2 101.4,12.87 101.77,12.51 v3(101.77,12.31)
  IN1 w0.508: v3(73.09,19.72) 73.14,19.72 80.08,12.79 86.44,12.79 v3(86.83,13.18) ; v3(74.88,26.24) 74.87,26.25 75.81,26.25 77.94,28.38 81.5,28.38 v3(83.12,30.01)
  IN2 w0.508: v2(137.94,65.39) 137.94,64.3 137.07,63.44 137.07,61.86 136.45,61.24 136.45,58.3 129.2,51.05 117.78,51.05 106.39,39.66 106.39,36.87 104.93,35.41 v3(102.57,35.41)
  IN3 w0.508: v3(101.77,12.31) 100.83,13.25 94.56,13.25 93.11,14.69 88.34,14.69 v3(86.83,13.18) ; v3(74.88,26.24) 74.87,26.22 73.42,26.22 73.09,25.89 v3(73.09,19.72)
  BOTTOM w0.254: UC1.AP49 138.08,65.39 v2(137.94,65.39)
  BOTTOM w0.508: v3(83.12,30.01) 85.87,32.75 99.91,32.75 v3(102.57,35.41)
+SM_VREF_CA_DIMM: length 115.9
  TOP w0.508: RD13.2 203.99,15.9 v6(202.63,14.54) 200.27,12.18 149.06,12.18 148.38,11.49 139.48,11.49 138.83,12.14 137.09,12.14 v3(133.01,16.22) ; RC67.2 RC69.1 101.24,13.96 101.24,13.96 RC68.1 101.4,15.65 102.12,16.37 v3(102.12,16.84)
  IN1 w0.508: v3(102.12,16.84) 102.12,17.16 102.86,17.89 131.33,17.89 v3(133.01,16.22)
  BOTTOM w0.508: v3(133.01,16.22) 132.02,15.23 RD12.2
+SM_VREF_CA_DIMMA: length 6.4
  BOTTOM w0.102: RD12.1 130.27,14.31 130.37,14.41 v1(130.57,14.41)
  BOTTOM w0.356: 128.49,15.79 128.49,16.6 127.88,17.21 JDIMM1.126
  BOTTOM w0.508: RD12.1 129.51,14.26 CD13.1 CD12.1 128.49,15.79
+SM_VREF_CA_DIMMB: length 6.1
  TOP w0.102: RD13.1 204.03,16.84 204.73,16.14 v1(205.04,16.14)
  TOP w0.508: RD13.1 CD43.1 CD44.1 202.84,17.76 202.27,17.19 v2(202.27,16.77)
  BOTTOM w0.356: JDIMM2.126 202.38,16.88 v2(202.27,16.77)
+SM_VREF_DQ0: length 77.9
  TOP w0.508: v3(86.68,27.19) 86.68,28.97 v6(87.14,29.42) 91.08,33.36 99.13,33.36 116.49,50.73 v2(116.49,53.17)
  IN2 w0.508: v2(136.99,64.71) 136.99,64.44 134.53,61.98 134.53,60.07 127.62,53.17 v2(116.49,53.17)
  BOTTOM w0.254: v2(136.99,64.71) 137.06,64.71 UC1.AR51
  BOTTOM w0.508: RC173.2 80.99,24.55 CC70.1 81.02,24.57 84.06,24.57 v3(86.68,27.19)
+SM_VREF_DQ0_DIMM1: length 5.2
  BOTTOM w0.102: RC173.1 80.56,26.05 81.85,26.05 v6(82.01,25.89)
  BOTTOM w0.508: RD1.1 RC217.2 RC221.1 RC173.1
+SM_VREF_DQ1: length 117.4
  TOP w0.102: v3(104.26,37.04) v1(104.26,36.37)
  TOP w0.508: v2(155.8,27.62) 155.61,27.43 CC69.1 155.62,25.84 RC126.2
  IN2 w0.508: v3(104.26,37.04) 101.73,39.57 101.73,43.69 114.24,56.19 125.41,56.19 131.2,61.99 131.59,61.99 133.32,63.71 135.01,63.71 136.65,65.36 v2(136.99,65.36)
  BOTTOM w0.254: UC1.AP51 137.32,65.69 v2(136.99,65.36)
  BOTTOM w0.508: v2(155.8,27.62) 155.8,36.06 153.37,38.49 105.7,38.49 v3(104.26,37.04)
+SM_VREF_DQ1_DIMM2: length 4.6
  TOP w0.508: RD7.1 v6(159.75,25.59) 159.42,25.92 RC130.2 158.33,25.84 RC126.1 157.4,25.01 RC132.1
+SWR_LX:
  vias: v1(123.73,117.12) v3(122.42,123.18) v3(122.85,123.67) v3(122.93,116.37) v3(123.16,123.1) v3(123.49,123.66) v3(123.56,116.37) v3(124.2,116.4) v3(124.78,116.8)
+SWR_V12: length 2.9
  TOP w0.203: C434.1 120.92,119.16 120.16,119.92 U52.11
  vias: v1(113.54,124.01) v3(111.34,125.16) v3(111.98,125.18) v3(124.36,118.43) v3(124.91,124.24) v3(124.91,123.61) v3(125,118.43) v3(125.31,117.84) v3(125.63,118.43)
+V_DDR_REF: length 4.1
  TOP w0.127: v2(39.72,11.11) v6(39.72,10.27)
  BOTTOM w0.203: PC112.1 39.75,11.11 v2(39.72,11.11) 38.65,11.11 38.01,11.75 PU100.4
+VCHGR: length 0.8
  TOP w0.127: v3(127.46,169.51) v6(127.46,168.71)
+VHDMI_VCC: length 1.6
  TOP w0.102: HDMIU1.3 14.25,97.4 v6(14.49,97.15)
  vias: v2(12.64,98.77) v2(12.67,99.38) v3(12.39,106.87)
+VLDOIN_1.35V:
  vias: v1(41.33,12.95)
+VR_CAP: length 9.2
  TOP w0.102: v2(169.15,116.28) 169.63,116.75 v1(169.94,116.75)
  TOP w0.305: U38.B12 167.69,120.07 168.03,120.41 168.15,120.53 v3(168.34,120.53)
  TOP w0.508: v2(169.15,116.28) 169.31,116.13 C366.1
  IN3 w0.508: v2(169.15,116.28) 168.44,116.28 168.06,116.66 168.06,118.35 167.75,118.66 167.75,120.07 168.21,120.53 v3(168.34,120.53)
+VREFC_UV5: length 25
  TOP w0.102: v1(31.08,115.33) 31.28,115.12 31.61,115.12
  TOP w0.254: v2(31.76,103.39) 31.76,103.41 31.52,103.65 31.52,104.3 UV5.M8
  TOP w0.508: CV2902.1 31.63,112.99 v2(31.63,112.35)
  IN1 w0.508: v2(31.63,112.35) 31.63,110.78 v2(30.74,109.89) 30.74,109.28 30.25,108.79 25.09,108.79 24.09,107.79 24.09,106.49 25.54,105.04 30.82,105.04 31.76,104.1 v2(31.76,103.39)
  BOTTOM w0.254: UV4.M8 31.12,109.52 v2(30.74,109.89)
+VREFC_UV7: length 26
  TOP w0.127: v1(31.18,82.49) RV2713.2
  TOP w0.254: 31.53,87.71 31.53,88.55 UV7.M8
  TOP w0.508: RV2713.2 RV2714.1 CV2942.1 30.99,85.42 30.99,86.36 31.53,86.91 v2(31.53,87.07) 31.53,87.71
  IN1 w0.508: v2(31.53,87.07) 26.68,87.07 24.13,89.63 24.13,92.14 24.9,92.91 29.6,92.91 30.76,94.07 v2(30.76,94.14)
  BOTTOM w0.254: UV6.M8 31.13,93.77 v2(30.76,94.14)
+VREFD_UV5: length 29.2
  TOP w0.127: RV2711.2 33.6,114.93 34.29,114.93 34.62,115.26 v6(34.65,115.26)
  IN2 w0.508: v2(33.28,111.9) 33.28,113.07 32.83,113.52 26.94,113.52 24.55,111.14 24.55,108.37 23.92,107.73 23.92,106.36 24.91,105.37 30.83,105.37 32.75,103.44 v3(33.94,103.44)
  BOTTOM w0.254: v3(33.94,103.44) 34.32,103.82 UV4.H1
+VREFD_UV7: length 33.4
  TOP w0.254: UV7.H1 34.33,95.08 v2(34.25,95.16)
  IN2 w0.508: v3(33.6,87.45) 33.8,87.26 33.8,85.74 33.34,85.28 26.68,85.28 25.64,86.32 25.64,87.95 23.08,90.51 23.08,94.73 23.89,95.54 30.88,95.54 31.26,95.16 v2(34.25,95.16)
  BOTTOM w0.254: v3(33.6,87.45) 34.3,88.15 UV6.H1
  vias: v1(32.46,98.22)
+VREFOUT: length 18.1
  TOP w0.127: v1(316.73,148.13) 316.14,147.54 v2(316.14,147.52)
  IN2 w0.508: v2(310.87,145.92) 310.96,146.01 310.96,146.26 311.42,146.72 315.56,146.72 316.14,147.3 v2(316.14,147.52) 316.14,148.56 315.56,149.14 313.25,149.14 312.66,149.72 312.66,150.5 v2(312.89,150.73)
  BOTTOM w0.254: U17.23 v2(312.89,150.73)
  BOTTOM w0.381: v2(310.87,145.92) 310.58,145.92 310.32,146.17 R187.2
  BOTTOM w0.508: v2(316.14,147.52) 316.14,146.92 315.46,146.25 C131.1 ; R187.2 R197.2
-DCIN_JACK:
  vias: v1(98.94,150.91)
A_DE_0B: length 2.6
  TOP w0.102: U83.16 299.15,167.75 298.26,168.65 R2636.2
A_DE_1B: length 3.4
  TOP w0.102: R2637.2 v1(296.48,168.29) 296.83,167.94 297.51,167.94 298.15,167.31 U83.18
A_EQ_0B: length 2.8
  TOP w0.102: R2634.2 297.37,168.67 v1(297.82,168.22) 298.65,167.39 U83.17
A_EQ_1B: length 2.5
  TOP w0.102: U83.15 299.65,167.75 v1(299.11,168.29) 299.11,169.17 R2635.2
A_ON: length 318.9
  TOP w0.102: RP18.6 174.42,119.67 174.01,120.08 v2(174.01,120.43) ; v3(185.79,111.04) 185.79,110.27 186.31,109.76 186.31,108 187.16,107.15 195.47,107.15 R424.1 ; v2(169.54,122.21) 169.91,122.59 170.38,122.59 170.43,122.64 U38.B24
  IN1 w0.097: v3(84.34,120.81) 84.32,120.81 83.29,119.78 81.68,119.78 78.03,116.14 78.03,104.51 77.31,103.78 77.31,99.07 76.34,98.1 76.34,83.65 71.57,78.88 67.4,78.88 v3(66.95,79.34) ; v2(169.54,122.21) 169.54,121.96 169.85,121.64 171.05,121.64 171.82,120.86 173.57,120.86 v2(174.01,120.43)
  IN2 w0.102: v3(185.79,111.04) 185.79,115.82 182.52,119.1 182.52,121.19 182.19,121.51 178.05,121.51 177.44,120.89 175.96,120.89 175.5,120.43 v2(174.01,120.43)
  IN3 w0.102: v3(34.77,24.83) 35.3,24.29 36.59,24.29 37.71,25.41 47.89,25.41 49.79,23.51 53.48,23.51 54.59,22.4 63.5,22.4 66.79,25.69 66.79,28.64 66.79,28.85 68.92,30.97 76.77,30.97 77.82,29.93 81.27,29.93 81.91,30.57 82.55,30.57 83.19,31.21 83.19,48.06 84.09,48.96 84.09,55.22 78.07,61.24 78.07,63.57 76.37,65.27 76.37,71.98 v3(76.13,72.22) ; v2(169.54,122.21) 168.95,122.21 168.86,122.31 164.18,122.31 163.96,122.08 161.79,122.08 161.22,121.51 159.59,121.51 158.89,122.21 156.76,122.21 156.23,122.74 155.41,122.74 154.93,122.27 154.93,121.07 154.93,119.42 154.56,119.06 154.56,114.98 153.9,114.32 151.74,114.32 151.53,114.54 148.05,114.54 147.41,113.9 147.41,113.49 146.52,112.6 144.1,112.6 143.93,112.43 140.24,112.43 139.84,112.83 136.31,112.83 136.04,112.56 128.26,112.56 127.75,112.05 119.88,112.05 116.88,109.05 114.74,109.05 113.76,110.03 110.53,110.03 110.04,110.51 105.78,110.51 103.2,113.09 101.34,113.09 93.97,120.46 87.9,120.46 86.92,121.44 84.97,121.44 v3(84.34,120.81)
  BOTTOM w0.102: v3(76.13,72.22) 74.27,74.08 v1(72.82,74.08) 72.2,74.08 v3(66.95,79.34)
  BOTTOM w0.254: PR703.1 v3(34.77,24.83) ; PR154.1 80.03,72.4 80.52,72.9 80.52,73.49 80.09,73.93 77.83,73.93 v3(76.13,72.22)
AC_DIS: length 125.6
  TOP w0.102: v3(129.84,134.89) 130.09,134.89 130.99,133.98 v1(131.03,133.98) ; U37.B12 190.59,127.91 v2(190.9,127.6)
  TOP w0.254: v3(141.91,133.3) 141.44,133.77 PR525.1 ; PQ5.5 131.8,142.17 v3(132.21,142.58)
  IN1 w0.097: v3(129.84,134.89) 130.42,134.3 132.22,134.3 133.06,133.46 138.26,133.46 138.9,132.83 139.4,132.83 139.93,133.36 141.85,133.36 v3(141.91,133.3) 141.91,133.15 139.86,131.1 139.86,125.31 150.94,114.23 150.94,113.32 154.96,109.31 164.37,109.31 164.65,109.03 170.53,109.03 171.01,109.51 175.73,109.51 178.56,112.34 180.08,112.34 182.75,115.01 189.7,115.01 190.16,115.47 191.63,115.47 192.28,116.12 193.06,116.12 193.17,116.12 193.77,116.72 193.77,117.82 194.43,118.48 196.79,118.48 197.03,118.72 197.03,125.35 196.05,126.33 192.18,126.33 191.69,126.81 191.69,127.18 191.28,127.6 v2(190.9,127.6)
  BOTTOM w0.102: v3(132.21,142.58) 133,141.79 133,137.4 134.08,136.32 138.89,136.32 v3(141.91,133.3)
AC_PRESENT: length 123.3
  TOP w0.102: v2(160.01,124.95) 160.01,124.95 160.07,124.89 U38.A54
  IN1 w0.076: v2(164.1,69.18) 164.66,68.61 165.3,68.61 166.3,67.61 167.09,67.61 168.65,66.05 169.21,66.05
  IN1 w0.097: 169.21,66.05 170.93,66.05 171.87,65.11 171.87,62.85 173.37,61.35 178.28,61.35 180.3,63.38 180.3,63.85 180.49,64.04 180.49,64.54 180.99,65.04 v3(180.99,65.77)
  IN2 w0.102: v3(190.8,63.51) 189.96,64.35 189.96,70.62 190.58,71.24 190.58,73.3 192.26,74.98 192.26,76.9 191.99,77.16 191.99,82.17 191.46,82.7 191.46,86.62 191.79,86.95 191.79,92.76 188.96,95.58 186.45,95.58 184.94,97.08 184.94,99.03 184.55,99.42 184.55,100.58 183.87,101.25 183.87,101.48 182.15,103.21 181.11,103.21 180.52,103.8 180.52,105.64 176.86,109.3 173.39,109.3 172.06,110.63 169.05,110.63 168.61,111.07 168.61,112.05 167.36,113.3 167.36,113.61 165.55,115.43 162.14,115.43 160.82,116.75 160.82,124.14 160.01,124.95 v2(160.01,124.95)
  IN3 w0.102: v3(180.99,65.77) 181.07,65.77 183.38,63.46 189.36,63.46 189.72,63.11 190.23,63.11 190.63,63.51 v3(190.8,63.51)
  BOTTOM w0.076: v2(164.1,69.18) 163.62,68.69 UC1.AJ8
  BOTTOM w0.102: v3(190.8,63.51) 190.8,63.79 v1(191.07,64.07) 191.66,64.07 191.7,64.03 RP14.8
ACAV_DOCK_SRC#: length 76.3
  TOP w0.102: v1(172.49,179.15) 172.15,178.8 v3(171.31,178.8)
  TOP w0.254: PR541.1 PR538.2 129.45,147.41 v3(129.99,147.41)
  IN1 w0.097: v3(139.72,160.44) 140.27,161 156.66,161 159.91,164.25 159.91,168.06 162.68,170.83 162.68,172.96 163.34,173.62 165.14,173.62 165.34,173.42 166.56,173.42 166.89,173.75 166.89,174.79 169.05,176.95 169.66,176.95 170.34,177.62 170.34,177.83 v3(171.31,178.8)
  BOTTOM w0.102: JDOCK1.42 176.95,183.6 177.03,183.53 177.03,181.52 176.12,180.61 174.19,180.61 172.46,178.88 171.39,178.88 v3(171.31,178.8) ; v3(129.99,147.41) 130.98,148.4 133.62,148.4 135.8,150.58 135.8,158.51 137.73,160.44 v3(139.72,160.44)
ACAV_IN: length 177.6
  TOP w0.102: v3(117.62,167.04) 117.52,166.94 PR427.1 ; v2(160.06,119.65) 160.31,119.89 U38.A64 ; v3(122.99,132.17) v6(124.54,132.17) 134.04,132.17 PQ411.2 135.48,132.86 137.2,134.58 v3(137.2,138.75)
  TOP w0.254: PR548.1 v2(133.79,147.56) ; v2(147,151.33) 147.24,151.33 148.01,152.09 PQ521.2
  IN1 w0.097: v2(160.06,119.65) 160.06,120.27 159.23,121.1 159.23,121.24 159.23,121.24 159.23,121.43 159.23,121.43 159.23,121.62 157.88,122.97 157.88,123.04 157.88,123.04 157.88,123.38 157.42,123.84 157.42,125.46 157.42,125.83 157.42,126.02 157.42,126.1 157.76,126.43 157.76,131.79 157.76,133.86 151.4,140.22 142.61,140.22 141.49,139.1 137.56,139.1 v3(137.2,138.75) ; v2(133.79,147.56) 133.49,147.87 123.61,147.87 119.5,151.98 119.5,153.55 119.95,154.01 119.95,157.11 120.46,157.62 120.46,163.41 121.28,164.22 121.28,166.81 121.05,167.04 v3(117.62,167.04)
  IN2 w0.102: v3(122.99,132.17) 122.66,132.5 118.88,132.5 118.67,132.29 104.74,132.29 103.47,131.02 98.58,131.02 90.82,123.27 83.75,123.27 80.97,120.48 78.04,120.48 v3(77.59,120.03) ; v2(133.79,147.56) 133.79,147.76 134.43,148.4 142.15,148.4 145.08,151.33 v2(147,151.33)
  BOTTOM w0.102: v2(133.79,147.56) 133.79,146.47 135.19,145.07 135.19,140.75 v3(137.2,138.75) ; v3(77.59,120.03) 77.49,119.93 R344.2
ACAV_IN#: length 16.5
  TOP w0.102: v3(158.23,155.41) 158.08,155.56 PR519.2
  TOP w0.254: v2(149.72,155.41) 149.72,155.25 148.96,154.49 PQ521.1 ; PQ521.1 148.66,155.2 v1(148.28,155.57) 147.89,155.97 PQ516.5 ; PQ521.1 147.87,154.49 147.55,154.82 146.82,154.82 PR532.2
  IN1 w0.097: v2(149.72,155.41) 149.88,155.56 154.75,155.56 155.69,156.5 157.14,156.5 v3(158.23,155.41)
ACAV_IN_NB: length 123.7
  TOP w0.102: v3(110.84,136.04) 110.43,136.04 v6(110.14,135.75) ; U38.B20 170.35,120.64 v2(170.11,120.4)
  TOP w0.254: v3(110.84,136.04) 110.84,135.85 111.17,135.52 PR450.2 ; v2(130.04,160.08) 130.5,160.55 PR545.2
  IN1 w0.097: v3(114.65,148.3) 114.65,147.81 120.41,142.05 129.14,142.05 129.86,141.34 133.34,141.34 134.97,139.71 134.97,139.24 136.23,137.97 141.31,137.97 143.05,139.72 149.6,139.72 149.82,139.72 157.31,132.23 157.31,131.97 157.31,126.62 156.97,126.28 156.97,125.83 156.97,123.31 157.44,122.85 157.44,122.48 157.44,122.29 157.44,120.94 159.29,119.08 159.29,118.3 161.01,116.58 161.54,116.58 162.08,117.12 163.12,117.12 163.92,116.32 166.89,116.32 167.02,116.45 167.81,116.45 168.19,116.83 168.19,117.94 168.75,118.5 169.23,118.5 169.59,118.86 169.59,120 169.99,120.4 v2(170.11,120.4)
  BOTTOM w0.254: v3(110.84,136.04) 110.85,136.05 112.77,136.05 114.65,137.93 v3(114.65,148.3) 114.65,153.4 118,156.76 119.6,156.76 123.63,160.78 129.34,160.78 v2(130.04,160.08)
ACAVDK_SRC: length 2.9
  TOP w0.254: v3(130,150.81) 130.15,150.96 PU701.4 ; PR541.2 129.3,149.91 v3(129.18,150.04)
  IN2 w0.254: v3(129.18,150.04) 129.95,150.81 v3(130,150.81)
ACAVIN: length 3.4
  TOP w0.254: PU701.8 132.15,151.01 v1(132.84,150.32) 133.26,149.9 133.49,149.9 133.79,149.6 PR548.2
ALW_PWRGD_3V_5V: length 95
  TOP w0.102: v1(169.68,148.51) 169.54,148.37 167.38,148.37 v3(167.3,148.3) ; PR60.1 v3(211.89,150.95) ; v2(161.94,118.05) 162.15,117.84 162.32,117.84 162.44,117.96 U38.A1
  IN1 w0.097: v2(161.94,118.05) 162.22,118.32 162.65,118.32 163.91,119.59 163.91,120.19 163.77,120.33 163.77,121.91 163.79,121.94 163.79,122.52 164.84,123.57 164.84,125.61 164.43,126.02 164.43,126.58 163.85,127.16 163.85,128.31 163.26,128.9 163.26,131.83 162.88,132.2 162.88,134.79 163.18,135.08 163.18,136.17 164.56,137.55 164.56,141.86 164.53,141.88 164.53,142.2 164.56,142.22 164.56,144.27 166.89,146.6 166.89,147.89 v3(167.3,148.3)
  BOTTOM w0.102: v3(211.89,150.95) 209.35,153.48 209.35,154.94 204.94,159.35 196.55,159.35 193.54,156.34 193.54,155.79 192.8,155.05 192.8,152.06 190.81,150.07 179.36,150.07 176.6,147.31 169.33,147.31 168.34,148.3 v3(167.3,148.3)
ALWON: length 88.9
  TOP w0.102: PR65.1 209.56,161.42 209.13,161 209.13,159.65 208.5,159.02 208.5,158.46 v1(208.07,158.03) 207.74,157.69 v3(207.51,157.69) ; v2(159.83,121.89) U38.A60
  IN1 w0.097: v3(166.64,148.3) 166.64,147.48 164,144.85 164,137.62 162.95,136.57 162.95,135.17 162.66,134.88 162.66,132.11 162.95,131.82 162.95,126.8 163.94,125.81 163.94,123.45 163.74,123.24 163.74,123.21 162.92,122.39 160.33,122.39 v2(159.83,121.89)
  BOTTOM w0.102: v3(166.64,148.3) 167.12,148.78 168.34,148.78 169.31,147.81 176.77,147.81 179.29,150.33 183.73,150.33 184.41,151 184.41,151.4 184.78,151.78 187.06,151.78 188.51,150.33 189.96,150.33 190.74,150.33 192.55,152.13 192.55,156 196.2,159.65 205.55,159.65 v3(207.51,157.69)
AUD_HP_NB_SENSE: length 198.6
  TOP w0.254: v2(337.89,162.14) 337.89,162.32 338.42,162.85 338.85,162.85 339.18,163.18 v6(339.18,163.87) 339.18,165.65 338.98,165.85 325.29,165.85 320.13,160.69 316.96,160.69 v2(316.32,161.33) 314.06,161.33 311.47,158.74 306.29,158.74 305.17,157.62 300.92,157.62 300.37,157.06 290.62,157.06 289.63,158.05 278.33,158.05 255.53,135.24 254.14,135.24 253.58,135.8 235.07,135.8 234.75,136.12 232.11,136.12 225.42,129.43 225.42,125.09 225.62,124.89 225.62,115.84 223.99,114.21 208.87,114.21 206.89,116.19 202.11,116.19 199.75,113.83 193.1,113.83 192.47,114.46 192.47,115.03 192.17,115.34 192.17,117.33 192.33,117.5 U37.A41
  BOTTOM w0.254: Q20.2 318.8,156.01 317.06,157.75 C137.1 317.06,159.41 C408.1 316.93,160.32 R163.1 v2(316.32,161.33) ; JIO1.68 338.37,161.45 337.89,161.94 v2(337.89,162.14)
AUD_HP_OUT_L: length 29.4
  TOP w0.254: v3(319.93,148.83) 319.93,149.31 319.6,149.64 R162.2
  IN1 w0.254: v2(337.89,159.07) 337.43,159.07 327.19,148.83 v3(319.93,148.83)
  BOTTOM w0.254: v2(337.89,159.07) 338.27,159.45 JIO1.76
AUD_HP_OUT_R: length 29.6
  TOP w0.254: v2(319.09,148.86) 318.81,149.14 315.76,149.14 R166.2
  IN1 w0.254: v2(337.42,160.31) 336.85,159.74 336.85,159.35 327.02,149.52 319.75,149.52 v2(319.09,148.86)
  BOTTOM w0.254: v2(337.42,160.31) 337.56,160.45 JIO1.72
AUD_NB_MUTE#: length 151
  TOP w0.102: v3(299.35,156.01) 298.95,155.61 295.75,155.61 294.94,156.42 290.59,156.42 289.4,157.62 278.51,157.62 255.58,134.68 v1(253.97,134.68) 253.28,135.37 234.89,135.37 234.57,135.69 232.29,135.69 225.85,129.25 225.85,125.31 226.05,125.11 226.05,115.66 224.17,113.78 208.69,113.78 206.71,115.76 202.54,115.76 200.18,113.4 192.92,113.4 192.01,114.31 192.01,114.88 191.74,115.16 191.74,116.93 191.51,117.15 191.49,117.15 191.31,117.33 191.31,117.7 191.33,117.73 U37.A39
  BOTTOM w0.254: v3(299.35,156.01) 299.35,156.01 R153.1 300.22,155.86 301.21,155.86 301.9,156.56 C410.1 302.19,156.5 R150.2 302.63,155.33 303.5,156.2 303.95,156.2 304.23,155.92 304.23,155.57 304.57,155.23 U17.47
AUD_OUT_L: length 8.7
  TOP w0.254: v2(307.09,148.6) 308.13,149.64 v6(309.01,149.64) R162.1
  BOTTOM w0.254: U17.33 307.23,148.74 v2(307.09,148.6)
AUD_OUT_R: length 9.8
  TOP w0.254: v2(307.09,148.01) 307.63,148.01 v6(307.86,148.25) 308.75,149.14 314.09,149.14 R166.1
  BOTTOM w0.254: v2(307.09,148.01) 307.28,148.01 307.73,148.47 U17.32
AUD_PC_BEEP: length 8.2
  BOTTOM w0.254: v6(313.22,161.33) C133.2 C143.2 312.89,160.44 313.12,160.21 313.12,157.32 312.97,157.17 311.47,157.17 311.23,156.94 U17.12
AUD_SENSE_A: length 3.8
  BOTTOM w0.254: U17.13 312.43,155.73 313.71,157.01 v6(313.71,157.47) R152.1
AUD_SENSE_B: length 6.2
  BOTTOM w0.254: U17.14 312.72,155.23 313.2,155.71 v6(314.09,155.71) 314.6,156.22 R156.1 R157.1
AUX_EN_WOWL: length 101.7
  TOP w0.102: v3(197.91,129.04) 198.59,129.73 RC189.1 ; U37.B67 196.33,127.14 v2(196.06,126.88)
  IN2 w0.102: v3(197.91,129.04) 197.91,128.72 v2(196.06,126.88)
  IN3 w0.102: v3(192.09,134.58) 192.09,132.42 192.73,131.79 192.73,129.45 194,128.18 195.9,128.18 196.4,127.67 196.4,127.22 v2(196.06,126.88)
  BOTTOM w0.102: v3(192.09,134.58) 192.94,135.43 194.95,135.43 195.2,135.69 209.2,135.69 209.91,136.4 211.83,136.4 215.1,139.67 231.33,139.67 232.55,138.45 232.55,137.17 232.84,136.89 239.68,136.89 239.81,137.02 243.75,140.96 259.27,140.96 261.99,143.67 v1(261.99,146.56) 261.99,149.88 261.74,150.13 261.74,151.13 261.74,151.14 U51.3
B-RAMP: length 4.8
  BOTTOM w0.203: PU300.11 83.68,93.21 82.97,93.92 v1(82.79,93.92) 82.41,93.92 81.42,94.91 PR307.1
  BOTTOM w0.254: PR307.1 PR302.2
B_DE_0B: length 1.8
  TOP w0.102: R2630.2 299.15,161.45 U83.3
B_DE_1B: length 4.4
  TOP w0.102: v1(302.28,159.35) 302.28,160.77 R2631.2 300.65,162.39 U83.6
B_EQ_0B: length 2
  TOP w0.102: U83.2 298.65,161.84 R2628.2
B_EQ_1B: length 1.8
  TOP w0.102: R2629.2 299.65,161.49 U83.4
BAT1_LED#: length 109.4
  TOP w0.102: U37.B64 196.34,125.64 196.2,125.5 195.66,125.5 195.19,125.03 v2(195.19,125.03) ; v3(227.47,35.85) 227.47,35.85 v1(227.47,35.28) 227.15,34.96 R433.1
  IN2 w0.102: v3(227.47,35.85) 227.47,36.07 224.04,39.5 224.04,40.77 223.55,41.26 220.74,41.26 220.23,41.77 220.23,44.09 218.87,45.45 218.34,45.45 218.11,45.68 216.99,46.8 216.97,46.82 216.94,46.85 214.47,49.32 214.47,51 211.6,53.87 211.6,57.4 209.22,59.78 209.22,81.51 206.7,84.02 206.7,87.03 205.73,88 205.73,97.32 205.53,97.53 204.26,98.79 202.96,98.79 202.95,98.79 202.77,98.79 201.51,100.04 201.51,102.6 201.03,103.08 201.03,104.14 201.01,104.16 200.74,104.43 200.6,104.56 198.24,106.93 198.24,111.41 197.96,111.69 196.89,112.76 196.89,117.72 194.94,119.67 194.94,122.19 194.74,122.38 194.74,124.57 v2(195.19,125.03)
BAT2_LED#: length 126.7
  TOP w0.102: v3(229.28,38.21) 229.28,37.65 229,37.38 228.31,37.38 v1(227.7,36.77) 226.79,35.85 R429.1 ; v2(192.34,130.45) 191.84,129.94 U37.A9
  IN2 w0.102: v3(229.28,38.21) 229.1,38.04 228.26,38.04 227.96,38.34 227.96,45.18 229.07,46.3 229.07,49.32 230.83,51.08 230.83,55.8 218.09,68.54 215.58,68.54 215.58,68.54 215.39,68.54 214.85,69.08 214.85,70.48 214.98,70.62 214.98,70.62 215.03,70.66 215.18,70.81 215.45,71.08 215.45,71.08 215.56,71.19 215.56,80.57 211.17,84.96 211.17,91.08 210.18,92.07 210.18,101.16 207.1,104.23 207.1,126.49 203.6,130 203.6,131.22 203.31,131.51 193.4,131.51 v2(192.34,130.45)
BATDRV#: length 20.4
  TOP w0.102: v3(123.49,164.63) 123.84,164.63 v1(124.1,164.88)
  TOP w0.254: v3(123.49,164.63) 123.48,164.63 PR432.2
  IN1 w0.254: v3(131.84,175.09) 130.52,175.09 125.14,169.71 125.14,166.94 123.49,165.29 v3(123.49,164.63)
  BOTTOM w0.254: v3(131.84,175.09) 131.03,174.28 PQ504.4
BATT_WHITE_LED#: length 9.9
  TOP w0.102: JLED1.6 217.86,34.53 v1(218.41,35.08) 218.77,35.44 220.59,35.44 220.91,35.13 221.19,35.13 221.96,34.35 223.59,34.35 225.09,35.85 R429.2
BATT_YELLOW_LED#: length 9
  TOP w0.102: JLED1.7 218.36,34.34 219.24,35.22 220.03,35.22 220.22,35.03 220.49,35.03 v1(220.56,34.96) 220.68,34.84 221.15,34.84 221.96,34.02 223.79,34.02 224.73,34.96 R433.2
