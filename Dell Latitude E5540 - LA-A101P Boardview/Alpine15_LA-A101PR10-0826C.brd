# Allegro board Alpine15_LA-A101PR10-0826C.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
FBA_D48: length 17.7
  TOP w0.102: v2(34.67,88.56) 34.66,88.56 34.33,88.88 UV7.H8
  IN3 w0.114: v5(48.43,91.15) 45.14,91.15 41.25,87.26 36.18,87.26 34.89,88.56 v2(34.67,88.56)
  BOTTOM w0.122: v5(48.43,91.15) 48.83,91.54 49.53,91.54 UV1.AD27
FBA_D49: length 20.1
  TOP w0.102: UV7.F7 35.96,89.75 v2(36.36,90.14)
  IN3 w0.114: v2(36.36,90.14) 36.75,89.75 39.8,89.75 39.92,89.87 39.92,90.3 40.04,90.43 40.29,90.43 40.41,90.3 40.41,89.87 40.53,89.75 40.78,89.75 40.9,89.87 40.9,90.3 41.02,90.43 41.26,90.43 41.39,90.3 41.39,89.87 41.51,89.75 42.25,89.75 44.92,92.42 48.88,92.42 49.69,91.61 50.1,91.61 50.35,91.86 50.35,92.24 50.72,92.61 v5(50.72,92.83)
  BOTTOM w0.122: v5(50.72,92.83) 51.13,93.24 UV1.AB25
FBA_D50: length 17.5
  TOP w0.102: UV7.F8 35.95,88.95 v2(36.36,88.54)
  IN3 w0.114: v2(36.36,88.54) 36.75,88.15 38.32,88.15 38.45,88.27 38.45,88.67 38.57,88.79 38.81,88.79 38.93,88.67 38.93,88.27 39.06,88.15 41.64,88.15 45.04,91.55 48.59,91.55 v5(49.04,91.1)
  BOTTOM w0.122: v5(49.04,91.1) 49.08,91.13 49.93,91.13 50.33,91.53 UV1.AD26
FBA_D51: length 19.2
  TOP w0.102: v2(34.73,89.34) 34.33,89.74 UV7.H7
  IN3 w0.114: v5(50.8,91.93) 50.2,91.33 49.46,91.33 48.8,91.99 44.98,91.99 42.27,89.27 38.16,89.27 37.83,88.94 37.3,88.94 37.29,88.94 36.97,88.94 36.97,88.94 35.14,88.94 v2(34.73,89.34)
  BOTTOM w0.122: v5(50.8,91.93) 50.8,92.04 51.13,92.37 UV1.AC25
FBA_D52: length 19.3
  TOP w0.102: v2(37.3,91.83) 37.26,91.83 36.73,92.36 UV7.E3
  IN3 w0.114: v5(48.47,94.35) 48.31,94.19 48.31,93.79 48.18,93.66 47.96,93.66 47.83,93.79 47.83,94.41 47.71,94.53 47.46,94.53 47.34,94.41 47.34,93.8 47.22,93.68 46.97,93.68 46.85,93.8 46.85,94.41 46.73,94.53 46.49,94.53 46.37,94.41 46.37,93.8 46.24,93.68 46,93.68 45.88,93.8 45.88,94.41 45.76,94.53 45.51,94.53 45.39,94.41 45.39,93.8 45.27,93.68 42.87,93.68 41.02,91.83 v2(37.3,91.83)
  BOTTOM w0.122: UV1.AA27 49.52,94.05 48.77,94.05 v5(48.47,94.35)
FBA_D53: length 19.2
  TOP w0.102: UV7.F2 35.96,93.75 v2(36.36,94.14)
  IN3 w0.114: v2(49.86,94.5) 49.48,94.88 45.04,94.88 44.92,94.76 44.92,94.15 44.8,94.03 44.55,94.03 44.43,94.15 44.43,94.89 44.3,95.02 44.07,95.02 43.94,94.89 43.94,94.15 43.82,94.03 43.58,94.03 43.45,94.15 43.45,94.87 43.33,95 43.09,95 42.96,94.87 42.96,94.13 42.87,94.03 42.72,94.03 42.43,93.74 37.3,93.74 37.29,93.74 36.97,93.74 36.97,93.74 36.94,93.74 36.54,94.14 v2(36.36,94.14)
  BOTTOM w0.102: UV1.AA26 50.32,94.04 v2(49.86,94.5)
FBA_D54: length 20.3
  TOP w0.102: UV7.H3 34.62,92.95 v2(35.15,92.42)
  IN3 w0.114: v5(50.72,96.12) 50.32,95.72 35.74,95.72 35.13,95.1 35.13,92.44 v2(35.15,92.42)
  BOTTOM w0.122: v5(50.72,96.12) 50.7,96.12 50.33,95.75 UV1.W26
FBA_D55: length 21.6
  TOP w0.102: UV7.G2 35.15,93.75 v2(35.56,93.34)
  IN3 w0.114: v5(50.73,94.48) 49.84,95.37 42.61,95.37 42.49,95.24 42.49,94.52 42.37,94.4 42.13,94.4 42,94.52 42,95.24 41.88,95.37 41.64,95.37 41.52,95.24 41.52,94.52 41.39,94.4 41.15,94.4 41.03,94.52 41.03,95.25 40.9,95.38 40.46,95.38 40.33,95.25 40.33,94.69 40.2,94.56 36.05,94.56 35.93,94.43 35.93,93.71 v2(35.56,93.34)
  BOTTOM w0.122: v5(50.73,94.48) UV1.Y25
FBA_D56: length 19
  BOTTOM w0.122: 45.6,97.85 v1(45.6,97.87) ; 45.6,97.85 47.06,99.3 49.03,99.3 49.15,99.42 49.91,99.42 UV1.R26 ; 45.6,97.85 43.74,95.99 43.74,94.34 43.62,94.21 40.9,94.21 40.78,94.34 40.78,95.29 40.65,95.41 39.25,95.41 39,95.16 39,94.95 38.74,94.69 38.74,93.55 38.55,93.36 38.17,93.36 37.76,92.95 UV6.D7
FBA_D57: length 19.4
  BOTTOM w0.122: UV1.T25 50.74,98.59 48.95,98.59 48.78,98.42 47.42,98.42 45.25,96.25 v1(45.25,95.39) 45.25,93.23 44.17,92.15 42.08,92.15 41.96,92.27 41.96,92.89 41.84,93.02 41.59,93.02 41.47,92.89 41.47,92.27 41.35,92.15 41.11,92.15 40.98,92.27 40.98,92.89 40.86,93.02 40.62,93.02 40.5,92.89 40.5,92.27 40.37,92.15 40.12,92.15 39.93,92.34 UV6.A7
FBA_D58: length 19.3
  BOTTOM w0.122: UV1.N27 49.32,100.47 47.58,100.47 v1(47.1,99.99) 43.01,95.9 42.71,95.9 42.59,95.78 42.59,94.91 42.46,94.78 42.23,94.78 42.1,94.91 42.1,95.78 41.98,95.9 41.73,95.9 41.61,95.78 41.61,94.87 41.48,94.74 41.25,94.74 41.12,94.87 41.12,95.78 41,95.9 38.77,95.9 38,95.13 38,94.08 UV6.C8
FBA_D59: length 19.3
  BOTTOM w0.122: UV6.B8 39.37,93.75 39.7,93.42 40.07,93.42 40.11,93.46 42.4,93.46 42.52,93.33 42.52,92.71 42.65,92.59 42.88,92.59 43.01,92.71 v1(43.01,93.11) 43.01,93.33 43.13,93.46 43.37,93.46 43.5,93.33 43.5,92.71 43.62,92.59 43.86,92.59 43.98,92.71 43.98,93.33 44.11,93.46 44.67,93.46 44.79,93.58 44.79,93.9 44.67,94.03 44.3,94.03 44.18,94.15 44.18,94.39 44.3,94.52 44.68,94.52 44.81,94.64 44.81,94.88 44.68,95 44.3,95 44.18,95.13 44.18,95.37 44.3,95.49 44.68,95.49 44.81,95.62 44.81,96.43 47.24,98.86 49.39,98.86 UV1.R27
FBA_D60: length 17.3
  BOTTOM w0.122: UV1.V26 50.33,96.52 49.94,96.13 47.87,96.13 47.17,95.43 v1(47.17,94.44) 47.17,92.21 45.17,90.2 40.57,90.2 40.1,90.67 38.88,90.67 38.33,90.12 UV6.C3
FBA_D61: length 17.8
  BOTTOM w0.122: UV6.C2 38.33,88.95 37.92,89.36 37.92,90.06 38.81,90.95 40.27,90.95 40.57,90.64 44.98,90.64 v1(45.86,91.52) 46.73,92.39 46.73,95.63 47.7,96.6 49.45,96.6 UV1.V27
FBA_D62: length 16.3
  BOTTOM w0.122: UV1.W27 48.16,95.72 47.61,95.18 47.61,92.01 45.35,89.75 45.22,89.75 45.1,89.62 45.1,89.52 44.97,89.4 v1(44.78,89.4) 44.59,89.4 44.46,89.52 44.46,89.62 44.33,89.75 44.04,89.75 43.91,89.63 43.91,89.52 43.79,89.4 43.55,89.4 43.43,89.52 43.43,89.63 43.3,89.75 43.06,89.75 42.94,89.63 42.94,89.52 42.82,89.4 42.57,89.4 42.45,89.52 42.45,89.63 42.33,89.75 42.09,89.75 41.96,89.63 41.96,89.52 41.84,89.4 41.6,89.4 41.48,89.52 41.48,89.63 41.35,89.75 41.11,89.75 40.98,89.62 40.98,89.42 40.86,89.3 40.06,89.3 39.93,89.42 UV6.A3
FBA_D63: length 15.8
  BOTTOM w0.122: UV6.A2 v1(42.81,88.95) 45.19,88.95 46.52,90.29 46.53,90.29 48.09,91.85 48.09,94.99 48.39,95.29 50.7,95.29 UV1.W25
FFS_INT2: length 103.6
  TOP w0.102: U15.9 213.6,125.01 v3(213.55,125.06)
  IN2 w0.102: v3(217.52,112.15) 214.65,115.02 214.65,118.81 213.02,120.43 213.02,124.62 213.45,125.06 v3(213.55,125.06)
  IN3 w0.102: v3(217.52,112.15) 211.5,106.13 211.5,103.3 210.3,102.1 210.3,99.4 209.29,98.39 204.55,98.39 203.98,97.81 203.98,97.43 199.3,92.75 199.3,91.27 200.54,90.03 200.54,88.54 199.7,87.69 191.41,87.69 190.8,87.08 v3(190.45,87.08)
  BOTTOM w0.076: 170.77,81.34 169.87,81.34 169.16,80.62 168.04,80.62 167.75,80.33 UC1.G2
  BOTTOM w0.102: v3(190.45,87.08) 190.64,86.89 190.64,84.7 189.58,83.63 186.06,83.63 185.72,83.29 181.27,83.29 179.98,81.99 179.98,81.8 v1(179.33,81.16) 178.59,80.42 RC183.2 175.18,80.42 174.89,80.71 174.89,80.71 174.49,81.11 173.55,81.11 173.12,81.55 171.05,81.55 170.9,81.4 170.83,81.4 170.77,81.34 ; Q19.2 222.44,105.8 221.33,104.69 217.97,104.69 216.81,105.85 216.81,111.44 v3(217.52,112.15)
FFS_INT2_Q: length 6.3
  BOTTOM w0.102: Q19.3 223.08,107.5 R125.2 v1(223,108.78) 221.45,110.33 JSATA1.18
FMCCLK_REQ#: length 278.5
  TOP w0.102: R168.2 108.42,115.35 108.54,115.24 U93.1 109.34,115.64 v3(109.34,115.85) R485.1
  IN1 w0.097: v3(113.48,111.45) 112.41,112.52 110.81,112.52 109.17,114.16 109.17,115.68 v3(109.34,115.85) ; v3(180.36,79.36) 179.55,80.17 175.08,80.17 174.6,80.64 172.79,80.64 172.52,80.37 171.82,80.37 171.57,80.62 170.55,80.62 170.09,80.16 v3(170.09,79.86)
  IN2 w0.102: v3(113.48,111.45) 113.74,111.72 114.89,111.72 115.42,112.25 117.57,112.25 119.7,114.39 120.27,114.39 123.29,117.41 125.5,117.41 128.72,120.63 128.72,123.61 133.47,128.36 146.71,128.36 147.62,127.45 150.17,124.9 150.17,118.25 153.17,115.25 153.17,112.91 153.98,112.09 154.7,112.09 155.29,112.67 156.87,112.67 157.45,112.1 157.45,110.02 158.54,108.93 166.84,108.93 167.9,107.86 170.44,107.86 171.12,107.18 171.12,104.32 174.74,100.7 174.74,95.33 173.82,94.4 173.82,91.9 170.18,88.26 170.18,79.95 v3(170.09,79.86)
  IN3 w0.102: v2(256.3,145.79) 256.3,145.44 247.77,136.9 241.38,136.9 239.79,135.32 235.7,135.32 228.32,127.93 227.36,127.93 225.12,125.7 225.12,118.36 220.36,113.6 215.9,113.6 209.62,107.32 209.62,106.24 205.29,101.92 204.41,101.92 203.42,100.93 203.42,99.54 196.95,93.06 187.85,93.06 187.03,92.24 183.96,92.24 182.11,90.39 182.11,86.84 182.78,86.17 182.78,85.68 183,85.47 183,81.18 181.99,80.17 181.17,80.17 v3(180.36,79.36)
  BOTTOM w0.102: v2(256.3,145.79) v1(253.18,145.79) 250.84,145.79 248.56,148.07 246.72,148.07 246.26,148.54 246.26,148.78 245.89,149.15 237.14,149.15 236.36,148.37 236.36,144.18 235.88,143.7 JMINI2.7
FPR_DET#: length 83.2
  TOP w0.102: R481.1 187.25,130.88 187.25,130.8 v1(187.8,130.25) 188.2,129.85 v2(188.33,129.85) U37.A16 ; JBIO1.5 205.85,89.1 207.97,86.98 211.27,86.98 v3(212.77,88.48)
  IN2 w0.102: v3(212.77,88.48) 212.77,89.5 212.54,89.72 212.54,92.37 211.7,93.2 211.7,103.55 209.11,106.15 209.11,127.36 208.75,127.72 208.75,127.72 206.04,130.44 206.04,131.1 203.7,133.44 202.1,133.44 201.64,133.9 196.53,133.9 195.36,135.06 192.51,135.06 192.35,135.22 191.79,135.22 191.13,134.56 189.78,134.56 188.89,133.67 188.89,131.86 187.85,130.82 187.85,130.34 v2(188.33,129.85)
FWP#: length 11.9
  TOP w0.102: U38.B65 162.22,121.14 162.29,121.08 v2(162.29,121.07) ; v2(161.79,114.01) 162.63,113.17 162.63,112.28 162.18,111.83 R399.2 R393.2
  BOTTOM w0.102: v2(161.79,114.01) 161.79,117.61 161.46,117.94 161.46,118.66 v1(161.79,118.99) 161.79,120.57 v2(162.29,121.07)
GFB: length 4
  BOTTOM w0.203: PR335.2 88.89,90.56 v1(88.36,90.56) 87.87,90.08 87.87,89.55 87.45,89.13 87.01,89.13 86.82,89.32 PU300.23
GPIO8_THERMATRIP#: length 27.7
  IN3 w0.102: v3(76.93,113.58) 76.55,113.96 73.04,113.96 72.76,113.68 v2(68.4,113.68)
  BOTTOM w0.102: UV1.A6 67.02,110.54 67.66,111.18 67.66,111.57 68.4,112.3 v2(68.4,113.68) 68.16,113.92 RV48.1 ; QC6.1 76.1,100.61 77.46,101.97 77.46,111.95 v1(76.93,112.48) v3(76.93,113.58)
GPIO09_GPUHOT#: length 13.7
  TOP w0.102: QC11.1 68.27,97.62 v2(68.13,97.76) v1(67.38,97.76) ; RV34.1 66.48,106.14 v5(65.61,107.01)
  IN2 w0.102: v5(65.61,107.01) 65.99,106.63 65.99,102.76 68.13,100.62 v2(68.13,97.76)
  BOTTOM w0.102: v5(65.61,107.01) 65.19,106.59 UV1.F8
GPIO11_NVVDD_VID: length 295.1
  TOP w0.102: v3(198.42,119.31) 198.37,119.31 197.79,119.89 U37.A49
  IN1 w0.097: v3(198.42,119.31) 198.77,118.96 198.77,118.52 197.7,117.45 197.7,116.97 196.42,115.68 195.5,115.68 194.55,114.74 194.55,114.55 194.06,114.06 192.22,114.06 191.58,113.41 190.34,113.41 188.54,111.62 187.09,111.62 186.25,112.45 183.94,112.45 177.43,105.93 173.63,105.93 171.82,104.13 166.34,104.13 165.71,104.76 161.34,104.76 160.96,104.38 154.16,104.38 151.48,107.06 151.19,107.06 150.02,108.23 148.51,108.23 147.68,107.4 144.66,107.4 144.66,107.4 143.35,107.4 143.34,107.4 125.74,107.4 123.37,109.77 119.29,109.77 116.49,106.96 116.49,106.42 115.15,105.09 108.29,105.09 105.1,108.28 105.1,119.11 102.03,122.17 82.48,122.17 80.41,120.1 79.1,120.1 74.63,115.63 74.63,100.94 75.84,99.73 v3(75.84,99.61) 75.67,99.61 72.89,96.82 72.89,96.2 74.78,94.31 74.78,94.3 74.81,94.27 74.81,91.15 75.26,90.7 75.26,86.88 69.02,80.64 61.25,80.64 v3(60.44,81.44) ; v2(61.22,25.97) 61.68,25.97 62.52,25.13 68.72,25.13 70.15,26.55 70.15,29.03 72.39,31.27 73.62,31.27 78.07,35.72 78.07,36.72 82.79,41.44 82.79,50.56 82.21,51.14 82.08,51.14 v3(82.06,51.17)
  IN3 w0.102: v3(82.06,51.17) 81.22,52.01 81.22,52.66 76.09,57.79 76.09,62.75 74.36,64.47 74.36,65.48 74.37,65.48 74.37,68.6 71.94,71.03 65.68,71.03 60.29,76.42 60.29,80.9 60.44,81.05 v3(60.44,81.44)
  BOTTOM w0.102: QC6.3 74.38,100.08 74.7,99.76 75.68,99.76 v3(75.84,99.61)
  BOTTOM w0.254: PU600.5 59.81,28.09 60.04,27.87 60.04,27.62 v1(60.72,26.93) PR600.2 PR602.1 61.76,25.97 v2(61.22,25.97)
GPIO11_NVVDD_VID_R: length 11.5
  IN3 w0.102: v2(73.69,105.04) 73.11,105.62 67.73,105.62 66.43,106.92 v5(66.43,106.88)
  BOTTOM w0.102: QC6.4 v1(74.38,104.06) 74.38,104.35 v2(73.69,105.04)
  BOTTOM w0.111: UV1.E7 66.43,106.94 v5(66.43,106.88)
GPIO12_AC_DETECT: length 14.2
  BOTTOM w0.102: UV1.D7 66.44,108.55 67.81,108.55 68.14,108.88 68.14,111.26 69.85,112.98 69.85,114.58 70.17,114.9 v1(70.17,116.23) 70.17,116.64 70.45,116.92 RV35.1 72.28,116.92 72.33,116.87 QC8.1
GPIO13_NVVDD_PSI: length 141.4
  IN1 w0.097: v3(59.74,82.16) 61.09,83.5 65.23,83.5 66.98,85.25 71.25,85.25 73.57,87.58 73.57,90 71.96,91.61 ; v3(82.06,50.48) 82.24,50.48 82.57,50.15 82.57,41.53 77.85,36.81 77.85,36.62 77.85,35.82 73.53,31.5 72.48,31.5 72.29,31.5 69.92,29.12 69.92,26.65 68.81,25.54 v3(65.34,25.54) ; 71.96,101.75 72,101.71 72,100.21 71.96,100.18 ; v3(71.95,119.44) 72.89,118.5 72.89,116.22 69.28,112.61 69.28,111.48
  IN1 w0.102: 69.28,111.48 69.28,104.43 71.96,101.75 ; 71.96,91.61 71.8,91.78 71.8,93.15 71.06,93.89 71.06,93.91 71.03,93.93 71.03,95.77 70.73,96.07 70.73,98.94 71.96,100.18
  IN3 w0.102: v3(82.06,50.48) 80.98,51.56 80.98,52.58 75.86,57.69 75.86,62.65 74.14,64.38 74.14,65.71 74.14,65.71 74.14,68.51 71.84,70.8 65.59,70.8 60.06,76.32 60.06,78.34 58.03,80.37 58.03,80.91 58.32,81.2 58.79,81.2 v3(59.74,82.16)
  BOTTOM w0.102: v3(71.95,119.44) v1(72.76,119.44) 73,119.44 73.23,119.21 QC8.3
  BOTTOM w0.254: v3(65.34,25.54) 65.32,25.54 64.48,26.38 64.48,28.05 63.82,28.71 PR634.1
GPIO13_NVVDD_PSI_R: length 14.7
  IN1 w0.097: v2(70.88,113.23) 75.69,118.05 v2(75.94,118.05)
  BOTTOM w0.102: QC8.4 75.81,118.17 v2(75.94,118.05) v1(75.94,119.65) ; UV1.B4 68.98,110.19 68.98,110.78 70.88,112.68 v2(70.88,113.23) RV2446.1
GPIO_PSID_SELECT: length 107.3
  TOP w0.102: v3(131.89,133.34) 131.89,133.93 132.85,134.89 132.85,135.76 PU1.6 132.92,136.22 133.16,136.46 133.8,136.46 v1(134.13,136.13) ; U37.A6 193.33,129.57 v2(193.61,129.84)
  IN1 w0.097: v2(193.61,129.84) 194.48,128.98 196.54,128.98 197.06,128.46 198.03,128.46 198.69,127.81 198.69,126.27 199.72,125.24 199.72,123.01 198.83,122.12 198.81,122.12 197.76,121.08 197.76,118.5 197.07,117.81 195.41,117.81 195.14,117.54 195.14,116.52 194.07,115.45 193.45,115.45 192.56,115.45 191.91,114.8 190.44,114.8 190.1,114.46 190.1,114.15 189.13,113.18 182.38,113.18 178.05,108.84 171.29,108.84 170.81,108.36 164.37,108.36 164.11,108.62 154.7,108.62 150.27,113.04 150.27,113.39 150.27,113.95 141.13,123.09 136.23,123.09 131.89,127.43 v3(131.89,133.34)
GPIOA6: length 158.3
  TOP w0.102: v2(200.61,119.21) 201.5,118.32 R296.2 201.62,116.7 200.65,115.73 199.99,115.73 199.22,116.51 v2(199.22,116.64) ; v2(195.95,121.22) 196.03,121.14 U37.B55
  IN2 w0.102: v2(177.19,122.71) 180.23,122.71 v2(181.82,124.29)
  IN3 w0.102: v2(94.25,116.62) 94.39,116.62 96.68,114.34 96.93,114.34 98.01,113.26 98.01,109.28 98.94,108.34 109.2,108.34 109.62,107.92 112.68,107.92 113.87,106.73 118.96,106.73 120.22,107.99 130.84,107.99 132.18,109.33 146.23,109.33 147.11,108.46 150.08,108.46 150.88,109.26 165.76,109.26 169.61,113.11 169.61,113.44 175.73,119.56 175.73,120.05 177.19,121.51 v2(177.19,122.71) ; v2(199.22,116.64) 199.22,116.06 197.75,114.59 194.83,114.59 194.18,115.24 186.49,115.24 182.82,118.91 182.82,121.96 181.7,123.07 181.7,124.18 v2(181.82,124.29)
  BOTTOM w0.102: R339.2 R348.2 v1(81.94,116.94) 92.85,116.94 93.17,116.62 v2(94.25,116.62) ; v2(200.61,119.21) 199.69,118.29 197.92,118.29 197.17,119.04 197.17,120 v2(195.95,121.22)
GPIOA7: length 176.9
  TOP w0.102: v2(198.31,121.09) 198.01,121.39 U37.A52 ; v2(73.96,96.56) v1(73.17,95.77) 72.42,95.77 72.32,95.67 71.52,95.67 71.11,95.26 R389.2
  IN1 w0.097: v2(198.31,121.09) 198.99,120.41 198.99,118.42 197.93,117.36 197.93,116.88 196.51,115.46 195.59,115.46 194.78,114.65 194.78,114.46 194.15,113.83 192.31,113.83 191.67,113.19 190.43,113.19 188.63,111.39 187,111.39 186.16,112.23 184.04,112.23 177.52,105.71 175.22,105.71 173.41,103.9 171.91,103.9 166.24,103.9 165.61,104.53 161.43,104.53 161.05,104.15 154.05,104.15 151.37,106.83 151.1,106.83 149.93,108 148.6,108 147.77,107.17 125.64,107.17 123.28,109.54 119.38,109.54 116.72,106.87 116.72,106.3 115.28,104.87 108,104.87 102.9,109.96 102.9,112.48 101.92,113.46 101.6,113.46 97.11,117.95 97.11,118.52 93.69,121.94 82.57,121.94 80.15,119.53 v2(80.13,119.53) 77.35,116.75 77.35,106.03 75.68,104.36 75.68,102.27 76.46,101.48 76.46,99.34 76,98.89 75.59,98.89 73.96,97.25 v2(73.96,96.56)
  BOTTOM w0.102: v2(80.13,119.53) R350.2 R355.2
GPU_B+: length 28.1
  TOP w0.102: v2(61.51,39.43) v6(61.51,40.05)
  IN2 w0.254: v3(55.95,25.03) 55.95,25.41 56.28,25.74 60.26,25.74 61,26.47 63.75,26.47 63.78,26.5 63.82,26.5 64.74,27.42 64.74,36.21 v2(61.51,39.43)
  BOTTOM w0.254: 56.45,22.12 55.85,22.72 55.85,24.93 v3(55.95,25.03) ; 56.45,22.12 PR614.1 ; 56.45,22.12 PC619.1
GPU_COMP: length 4.8
  BOTTOM w0.254: PU600.12 55.96,26.44 55.82,26.3 54.26,26.3 v1(54.09,26.47) 53.76,26.47 53.59,26.3 53.01,26.3 PC623.2 PC622.2
GPU_DSBL/ISEN1: length 5.4
  BOTTOM w0.254: PU600.15 54.32,28.59 53.7,29.21 53.6,29.21 52.87,29.93 52.87,29.95 PC626.1 52.84,29.93 52.24,29.32 51.35,29.32 PR636.1
GPU_EN: length 7.9
  BOTTOM w0.254: PD601.2 62.78,32.27 PR627.1 62.75,32.07 62.23,31.56 61.56,31.56 v1(61.15,31.15) 61.15,29.5 60.81,29.15 60.2,29.15 60.13,29.09 PU600.3
GPU_FB: length 6.6
  BOTTOM w0.254: PU600.11 56.46,26.05 56.3,25.89 54.7,25.89 v1(53.81,25) 53.43,24.62 53,24.62 52.77,24.39 PC620.2 52.75,23.95 51.95,23.95 PR621.2
GPU_FBRTN: length 13.4
  IN1 w0.254: v2(58.5,21.25) 58.5,23.04 56.71,24.83 v2(56.71,25.28)
  BOTTOM w0.254: PC616.2 59.07,21.18 PR611.2 ; PC616.2 58.53,21.22 v2(58.5,21.25) ; PC616.2 59.12,21.23 PC617.2 ; PU600.10 56.96,25.54 v2(56.71,25.28) 56.47,25.51 55.49,25.51 v1(55.34,25.36) 54.98,25.36 54.54,24.93 PR615.2 PR616.2
GPU_JTAG_TCK: length 7.7
  BOTTOM w0.102: T186.1 71.66,85.65 68.95,88.35 68.95,90.18 68.77,90.36 68.06,90.36 UV1.AE5
GPU_JTAG_TDI: length 6.6
  BOTTOM w0.102: T188.1 68.06,84.91 68.06,87.39 67.55,87.9 67.55,89.5 67.19,89.86 67.19,90.38 UV1.AE6
GPU_JTAG_TDO: length 3.6
  BOTTOM w0.102: UV1.AF6 66.83,89.87 67.32,89.37 67.32,87.59 67.36,87.55 T189.1
GPU_JTAG_TMS: length 1.1
  TOP w0.102: T187.1 66.43,91.64 v5(66.43,91.13)
  BOTTOM w0.102: v5(66.43,91.13) 66.43,91.14 UV1.AD6
GPU_JTAG_TRST#: length 5.5
  BOTTOM w0.102: UV1.AG4 68.53,88.01 70.03,86.51 T190.1 69.88,85.37 RV88.2
GPU_PGOOD: length 27.2
  IN3 w0.102: v3(35.58,24.83) 36.85,26.1 44.87,26.1 47.08,28.31 52.43,28.31 v2(53.78,29.66)
  BOTTOM w0.102: v1(52.35,33.72) 52.84,33.22 PR633.1
  BOTTOM w0.254: v3(35.58,24.83) 35.66,24.91 PR704.1 ; PU600.16 54.36,29.09 v2(53.78,29.66) 53.78,29.99 PC625.1 PR626.2 PR633.1
GPU_PLLVDD: length 12.1
  TOP w0.508: v3(71.77,102.55) 70.64,103.68 CV3064.1 68.27,103.68 v2(67.33,102.75) 67.33,102.57 66.86,102.11 CV236.1
  BOTTOM w0.254: UV1.L6 66.9,102.32 v2(67.33,102.75)
  BOTTOM w0.508: v3(71.77,102.55) 72.71,101.61 72.71,100.39 v1(73.59,99.51) 73.86,99.24 L73.2
GPU_PVCC: length 17.3
  TOP w0.102: v2(50.02,31.76) v1(50.02,32.52)
  IN3 w0.508: v2(50.02,31.76) 50.02,32.44 52.62,35.04 v2(57.12,35.04)
  BOTTOM w0.102: v2(50.02,31.76) 50.94,30.84 PR630.1 50.61,30.35 50.27,30.35 49.89,29.97 49.89,29.13 49.98,29.04 PR636.2
  BOTTOM w0.254: PU600.21 56.96,33.09 ; 57.59,33.73 57.12,34.2 v2(57.12,35.04)
GPU_PWR_LEVEL: length 3.2
  BOTTOM w0.102: v1(78.35,119.99) R355.1 R339.1 77.93,117.44 R345.2
GPU_REFADJ: length 4.5
  BOTTOM w0.254: PR608.2 60.77,24.76 v1(60.77,25.11) 60.02,25.86 60.02,26.75 PU600.6
GPU_REFIN: length 11.9
  IN1 w0.254: v2(58.69,24.75) 58.69,24.09 60.63,22.15 v2(60.63,21.22)
  BOTTOM w0.254: PU600.7 58.46,26.35 v1(59.12,25.69) 59.12,25.18 v2(58.69,24.75) ; PR610.1 60.4,19.25 60.63,19.48 v2(60.63,21.22) 60.63,21.22 PC616.1 60.02,22.14 PR607.1
GPU_SMBCLK: length 140.3
  TOP w0.102: v2(163.38,127.54) 163.38,127.77 163.19,127.96 U38.B49 ; v3(174.26,137.27) 174.08,137.1 173.83,137.1 173.75,137.18 173.75,137.53 173.88,137.67 RP7.2
  IN3 w0.102: v3(174.26,137.27) 173.78,136.79 172.9,136.79 171.06,134.96 171.06,133.33 169.77,132.04 164.51,132.04 164.23,131.76 164.23,130.99 164.12,130.88 163.82,130.88 v2(163.67,131.03) 163.45,130.82 163.22,130.82 162.96,130.56 162.96,129.12 163.37,128.71 163.72,128.36 163.97,128.11 163.97,127.46 163.84,127.34 163.59,127.34 v2(163.38,127.54) 163.19,127.34 162.98,127.34 162.93,127.39 162.93,128.03 161.15,129.81 160.06,129.81 159.63,129.37 155.06,129.37 154.17,128.47 154.17,126.97 151.6,124.4 151.6,120.45 148.82,117.66 129.58,117.66 125.59,113.68 118.33,113.68 117.26,112.61 115.17,112.61 114.77,112.22 111.18,112.22 106.62,116.78 106.62,120.18 103.42,123.38 83.05,123.38 80.69,121.02 74.29,121.02 72.13,123.18 68,123.18 v2(66.94,124.23)
  BOTTOM w0.102: QC9.6 67.22,123.95 v2(66.94,124.23)
GPU_SMBDAT: length 141.9
  TOP w0.102: v3(174.23,136.59) 173.98,136.84 173.76,136.84 173.52,137.08 173.52,137.53 173.38,137.67 RP7.1 ; v2(163.39,126.96) 163.76,127.33 163.76,127.72 163.69,127.8 U38.B48
  IN3 w0.102: v2(65.92,122.44) 66.43,122.95 72.03,122.95 74.19,120.79 80.78,120.79 83.14,123.15 103.32,123.15 106.39,120.08 106.39,116.68 111.08,111.99 114.87,111.99 115.26,112.38 117.36,112.38 118.42,113.45 125.69,113.45 129.68,117.44 148.91,117.44 151.83,120.36 151.83,124.31 154.4,126.87 154.4,128.38 155.16,129.14 159.72,129.14 160.16,129.58 161.06,129.58 162.7,127.93 162.7,127.3 162.89,127.11 163.23,127.11 v2(163.39,126.96) 163.54,127.11 163.93,127.11 164.2,127.37 164.2,128.2 163.88,128.52 163.53,128.87 163.19,129.21 163.19,130.46 163.32,130.59 163.55,130.59 v2(163.69,130.45) 163.89,130.65 164.21,130.65 164.46,130.9 164.46,131.67 164.6,131.81 169.87,131.81 171.29,133.23 171.29,134.86 172.99,136.56 174.21,136.56 v3(174.23,136.59)
  BOTTOM w0.102: QC9.3 v2(65.92,122.44)
GPU_TALERT/ISEN2: length 7.4
  BOTTOM w0.102: PR628.1 52.54,28.28 51.42,28.28 51.34,28.36 48.73,28.36 PR637.1
  BOTTOM w0.254: PU600.14 54.19,28.09 v1(53.98,28.29) 53.48,28.79 PR628.1
GPU_TESTMODE: length 5.5
  TOP w0.102: RV2435.1 67.9,90.33 67.28,90.33 v1(67.07,90.54) 66.82,90.79 66.82,91.95 66.48,92.29 65.22,92.29 v5(64.86,91.93)
  BOTTOM w0.102: v5(64.86,91.93) 64.47,91.54 UV1.AD9
GPU_TON: length 3.5
  BOTTOM w0.254: PR614.2 56.45,24.37 56.66,24.58 56.95,24.58 v1(57.46,25.1) PU600.9
GPU_TSNS/ISEN3: length 30.1
  IN1 w0.254: v2(44.83,46.62) 44.39,46.17 44.39,34.23 49.42,29.2 v2(49.42,27.83)
  BOTTOM w0.102: v2(49.42,27.83) 49.42,27.49 v1(49.1,27.18)
  BOTTOM w0.254: v2(49.42,27.83) PR623.2 PR625.1 PR624.1 PC624.1 53.01,27.59 PU600.13 ; PH302.1 46.43,46.23 45.81,46.85 45.06,46.85 v2(44.83,46.62)
GPU_VREF: length 15
  IN1 w0.254: v2(58,24.75) 56.99,25.77 54.01,25.77 53.68,26.1 50.3,26.1 v2(50.1,26.3)
  BOTTOM w0.102: v2(50.1,26.3) 48.53,26.3 v1(48.27,26.04)
  BOTTOM w0.254: PU600.8 57.96,24.79 v2(58,24.75) 58.23,24.53 PR604.1 PC613.1 ; PR623.1 v2(50.1,26.3)
GPUHOT#: length 167.7
  TOP w0.102: v3(73.3,96.58) v1(72.72,97.15) 72.26,97.62 QC11.6
  IN1 w0.097: v3(59.03,82.1) 59.03,82.09 59.39,81.74 59.57,81.74 60.95,80.35 69.08,80.35 75.61,86.88 75.61,91.05 75.3,91.35 75.3,94.45 73.3,96.46 v3(73.3,96.58) 73.3,96.91 75.49,99.11 75.91,99.11 76.24,99.44 76.24,101.39 75.45,102.18 75.45,104.05 74.88,104.62 74.88,114.35 76.29,115.76 76.29,116.41 v3(79.44,119.56)
  IN3 w0.102: v3(47.56,27.39) 54.8,27.39 55.39,26.81 63.62,26.81 64.46,27.65 64.46,29.55 67.87,32.97 78.01,32.97 78.86,32.12 80.43,32.12 81.17,32.85 81.17,49.39 80.42,50.14 80.42,52.49 75.4,57.5 75.4,62.46 73.68,64.19 73.68,66.17 73.68,66.17 73.68,68.32 71.66,70.34 65.4,70.34 59.6,76.14 59.6,78.12 57.56,80.16 57.56,81.24 58.42,82.1 v3(59.03,82.1)
  BOTTOM w0.102: v3(79.44,119.56) 79.84,119.95 80.43,119.95 80.62,119.76 80.62,118.34 80.13,117.84 R350.1 79.29,117.8 R348.1 ; PR637.2 v3(47.56,27.39)
GREEN_CRT: length 160.6
  IN1 w0.097: v2(187.7,171.84) 187.7,171.33 188.23,170.8 190.43,170.8 190.53,170.7 191.02,170.7 192.48,169.24 195.05,169.24 195.98,168.31 201.66,168.31 212.63,168.31 215.85,171.54 222.84,171.54 225.44,168.94 225.8,168.58 249.16,168.58 249.86,167.88 249.96,167.78 261.72,167.78 262.59,166.91 280.02,166.91 280.12,167 280.12,167.09 280.25,167.22 280.6,167.22 280.73,167.09 280.73,167 280.82,166.91 283.58,166.91 284.95,168.28 307.7,168.28 308.14,167.84 317.01,167.84 317.28,167.58 330.44,167.58 331.4,168.54 337.05,168.54 v3(337.28,168.77)
  BOTTOM w0.102: v3(337.28,168.77) 337.28,169.02 337.7,169.45 JIO1.36 ; U39.25 187.52,171.17 187.7,171.34 v2(187.7,171.84)
GREEN_DOCK: length 8
  IN3 w0.102: v2(183.94,174.05) 186.02,174.05 186.68,173.39 186.68,172.83 187.21,172.3 v3(187.21,171.44)
  BOTTOM w0.102: v2(183.94,174.05) 183.94,173.42 183.45,172.93 L69.1 ; v3(187.21,171.44) 187.13,171.35 U39.24
GREEN_DOCK_PI: length 2.9
  BOTTOM w0.102: JDOCK1.59 182.45,175.59 182.57,175.47 182.57,174.18 L69.2
H_CATERR#: length 13.1
  BOTTOM w0.076: 127.09,78.4 127.3,78.4 127.66,78.76 129.1,78.76 129.28,78.58 129.63,78.58 129.81,78.75 129.81,78.93 130.04,79.16 130.56,79.16 UC1.K61
  BOTTOM w0.102: RC113.2 119.79,77.95 v1(119.93,78.09) 120.11,78.09 120.62,77.58 122.42,77.58 123.23,78.4 127.09,78.4
H_CPU_SVIDALRT#: length 5.4
  BOTTOM w0.076: 127.09,77.2 127.13,77.24 127.66,77.24 128.25,77.83 129.63,77.83 129.93,78.12 UC1.L62
  BOTTOM w0.102: RC248.1 125.49,77.05 v1(126.23,77.05) 126.38,77.2 127.09,77.2
H_CPUPWRGD: length 70.9
  TOP w0.076: v2(130,85.41) 130,83.03 130.27,82.76 131.97,82.76 132.25,82.49 132.25,81.47 131.94,81.16 131.94,80.61 132.27,80.28 132.27,79.82 131.94,79.49 130.06,79.49 128.97,78.4 127.75,78.4
  TOP w0.102: v3(119.55,72.02) 119.76,72.24 119.76,73.42 RC115.1 119.43,74.2 120.02,74.2 121.03,75.21 121.03,75.91 120.18,76.76 120.18,77.28 120.41,77.51 121.4,77.51 121.91,78.02 122.74,78.02 123.12,78.4 127.75,78.4 ; RC106.1 v6(103.32,44.61) 104.99,46.29 104.99,47.18 120.67,62.85 120.67,65.47 118.33,67.8 v3(116.48,67.8)
  IN1 w0.097: v3(119.55,72.02) 119.55,70.62 116.73,67.8 v3(116.48,67.8)
  BOTTOM w0.076: v2(130,85.41) 130.46,85.41 131.09,84.78 131.09,84.42 131.16,84.35 131.16,83.76 131.14,83.74 UC1.C61
H_PROCHOT#: length 276.9
  TOP w0.102: v2(120.58,78.19) 119.44,78.19 119.31,78.05 117.19,78.05 117.15,78.09 Q9.1 116.61,78.09 115.64,77.11 115.01,77.11 114.65,76.75 RC114.2 114.32,75.81 114.32,73.62 114.32,72.73 113.2,71.61 111.77,71.61 111.59,71.79 111.59,73.55 106.32,78.83 106.32,81.16 105.1,82.38 105.1,82.76 103.44,84.42 101.51,84.42 101.18,84.09 92.93,84.09 v3(91.33,85.69) ; PR442.2 120.92,133.06 121.67,132.31 122.04,132.31 122.74,131.61 133.19,131.61 135.79,129.01 146.65,129.01 152.09,134.44 152.09,149.64 151.53,150.2 150.36,150.2 149.3,149.14 PQ502.3 149.3,148.73 150,148.03 v2(150,147.94) ; R334.2 161.81,135.89 v2(161.81,135.9)
  IN1 w0.097: v2(161.81,135.9) 162.04,136.13 162.04,139.12 160.3,140.85 156.26,140.85 153.88,143.24 153.33,143.24 149.93,146.64 149.93,147.87 v2(150,147.94)
  IN2 w0.102: v3(127.74,117.47) 131.4,113.82 135.72,113.82 140.88,108.65 145.99,108.65 147.84,106.79 151.5,106.79 152.85,105.45 152.85,103.2 153.41,102.64 154.33,102.64 155.18,101.79 155.18,97.85 156.07,96.96 156.07,95.39 156.63,94.83 156.63,91.65 155.03,90.05 155.03,85.38 153.56,83.91 153.56,81.77 153.81,81.52 153.81,80.29 153.28,79.75 153.28,76.92 148.56,72.2 136.93,72.2 135.68,70.95 131.2,70.95 129.76,72.4 129.76,73.29 129.4,73.65 129.4,74.5 128.94,74.97 128.56,74.97 128.33,75.2 122.9,75.2 121.53,76.57 121.53,77.24 v2(120.58,78.19)
  IN3 w0.102: v2(161.81,135.9) 161.2,135.29 159.4,135.29 158.89,134.78 157.92,134.78 155.11,131.98 154.52,131.98 149.95,127.4 149.95,126.61 149.75,126.41 149.75,122.93 145.61,118.78 129.07,118.78 127.77,117.47 v3(127.74,117.47)
  BOTTOM w0.102: v3(91.33,85.69) 91.33,85.1 90.34,84.11 v1(89.73,84.11) 89.3,83.68 86.45,83.68 85.76,82.99 84.75,82.99 84.17,83.58 84.17,84.93 PC317.1 PR326.2 ; RC117.1 121.12,78.19 v2(120.58,78.19)
H_PROCHOT#_R: length 8.5
  BOTTOM w0.076: 127.09,78.62 127.27,78.62 127.64,79 129.39,79 UC1.K63
  BOTTOM w0.102: RC117.2 122.14,78.55 122.22,78.62 122.82,78.62 123.1,78.9 123.61,78.9 v1(123.78,78.74) 123.89,78.62 124.35,78.62 124.58,78.85 125.06,78.85 125.29,78.62 127.09,78.62
H_THERMTRIP#: length 170.1
  TOP w0.102: v3(174.3,135.7) 174.15,135.85 Q12.3
  IN2 w0.102: v2(127.49,114.25) 128.91,112.83 135.92,112.83 141.64,107.1 146.04,107.1 146.93,106.21 151.3,106.21 152.29,105.22 152.29,102.67 152.87,102.08 154.1,102.08 154.63,101.56 154.63,97.62 155.24,97.01 155.24,95.29 155.97,94.55 155.97,92.24 154.45,90.72 154.45,85.97 153.18,84.7 153.18,84.69 152.95,84.47 152.95,84.47 152.37,83.88 152.37,81.91 152.48,81.8 152.48,77.39 148.41,73.32 137.25,73.32 135.45,71.51 131.44,71.51 130.39,72.55 130.39,73.47 130.06,73.8 130.06,74.63 129.17,75.53 128.79,75.53 128.56,75.76 123.13,75.76 122.17,76.72 122.17,82.62 v2(124.17,84.62)
  IN3 w0.102: v3(174.3,135.7) 172.99,134.39 172.99,131.51 168.82,127.35 168.82,126.07 167.81,125.06 164.91,125.06 163.62,123.76 162.07,123.76 161.64,123.33 157.95,123.33 156.68,124.6 154.93,124.6 153.1,122.77 153.1,117.51 151.37,115.78 149.62,115.78 148.53,116.88 130.34,116.88 127.71,114.25 v2(127.49,114.25)
  BOTTOM w0.102: RC172.1 v2(124.17,84.62) R24.2
H_THERMTRIP#_R: length 7.3
  BOTTOM w0.076: 129.67,84.36 129.88,84.16 130.3,84.16 130.49,83.97 130.49,83.76 130.83,83.42 130.83,83.21 131.29,82.75 UC1.D60
  BOTTOM w0.102: RC172.2 126.03,84.62 v1(126.61,84.03) 126.89,84.31 128.48,84.31 128.85,84.69 129.35,84.69 129.67,84.36
H_VCCST_PWRGD: length 333.4
  TOP w0.102: v3(91.62,37.25) 91.82,37.04 97.04,37.04 v6(100.77,40.77) 102.07,42.07 RC105.1 103.93,43.7 106.06,45.83 106.06,47.46 121.23,62.62 121.23,65.7 118.55,68.38 115.6,68.38 114.77,67.55 114.77,62.72 113.17,61.12 107.97,61.12 103.65,65.44 103.65,75.07 v3(102.91,75.81) ; v2(187.19,54.8) 187.19,55.46 187.06,55.59 UC4.4
  IN3 w0.102: v3(157.45,15.38) 157.14,15.07 152.7,15.07 151.91,15.86 135.35,15.86 133.98,17.23 125.24,17.23 124.68,16.67 124.68,16.67 124.46,16.45 124.45,16.45 123.31,15.3 119.78,15.3 118.71,16.37 118.71,17.21 117.14,18.78 108.19,18.78 107.86,19.11 107.86,25.01 96.99,35.88 92.99,35.88 v3(91.62,37.25) ; v3(121.1,85.61) 121.25,85.46 121.25,83.65 120.39,82.79 119.32,82.79 114.98,78.45 110.99,78.45 109.95,77.41 104.51,77.41 v3(102.91,75.81)
  BOTTOM w0.102: v3(157.45,15.38) 158.61,14.21 193.79,14.21 195.36,15.78 197.79,15.78 198.1,15.46 225.41,15.46 226.43,16.49 226.43,18.83 226.58,18.99 226.58,30.21 223.69,33.11 220.23,33.11 214.04,39.29 214.04,43.76 215.41,45.12 215.41,49.77 215.08,50.1 214.51,50.1 212.84,51.76 210.67,51.76 210.29,52.15 208.62,52.15 207.26,53.5 205.82,53.5 205.27,52.96 188.97,52.96 187.4,54.52 187.4,54.59 v2(187.19,54.8) ; RC243.1 RC245.1 119.45,85.41 119.7,85.15 120.64,85.15 120.67,85.18 120.69,85.18 120.79,85.28 120.79,85.3 v3(121.1,85.61)
H_VCCST_PWRGD_XDP: length 13.8
  TOP w0.102: JXDP1.39 96.15,46.86 96.61,46.4 96.61,44 96.92,43.7 97.21,43.7 97.31,43.6 97.31,43.01 97.44,42.89 97.79,42.89 97.92,43.01 97.92,43.6 98.02,43.7 98.43,43.7 98.53,43.6 98.53,43.01 98.66,42.89 99.01,42.89 99.14,43.01 99.14,43.6 99.24,43.7 99.65,43.7 99.75,43.6 v6(99.75,43.32) 99.75,42.94 99.88,42.81 100.23,42.81 100.36,42.94 100.36,43.6 100.46,43.7 RC105.2 RC106.2
H_VR_EN: length 55.3
  TOP w0.102: v3(85.82,96.63) 86.35,96.1 86.5,96.1 96.15,86.45 101.92,86.45 102.38,86.91 105.43,86.91 106.44,85.89 106.44,84.29 107.13,83.6 107.13,83.22 109,81.35 114.48,81.35 115.21,82.08 115.72,82.08 115.74,82.1 v3(115.74,82.08)
  BOTTOM w0.102: PR312.2 77.36,93.63 77.03,93.96 77.03,97.52 v1(77.64,98.13) 82.31,98.13 83.81,96.63 v3(85.82,96.63) ; RC256.2 RC246.1 115.81,82.16 v3(115.74,82.08)
H_VR_READY: length 83
  IN3 w0.102: v3(128.3,92.09) 128.02,91.8 107.62,91.8 102.28,86.46 91.88,86.46 91.79,86.37 79.04,86.37 78.37,87.04 v2(78.37,89.44)
  BOTTOM w0.102: RC247.1 119.19,84.37 v1(118.52,84.37) 118,84.37 117.82,84.19 RC255.2 RC256.1 RC259.2 114.93,84.19 114.77,84.34 114.77,86.87 115.95,88.05 127.72,88.05 128.3,88.62 128.3,91.79 128.3,91.8 v3(128.3,92.09)
  BOTTOM w0.254: PR317.2 78.41,89.4 v2(78.37,89.44) 78.36,89.45 PD300.2
HDD_DET#: length 89
  IN3 w0.102: v3(215.54,114.97) 207.66,107.09 204.76,107.09 203.83,106.16 203.83,105.24 200.9,102.32 200.9,99.15 196.88,95.13 184.67,95.13 180.61,91.07 180.61,83.67 177.89,80.95 177.89,77.86 177.6,77.57 177.6,75.41 176.63,74.45 176.63,72.51 v2(177.79,71.36)
  BOTTOM w0.076: 170.78,75.4 170.32,75.4 170.23,75.31 169.51,75.31 169.34,75.15 168.49,75.15 168.49,75.14 168.19,75.14 168.14,75.09 UC1.U1
  BOTTOM w0.102: JSATA1.12 216.35,117.95 215.54,117.13 v3(215.54,114.97) ; v2(177.79,71.36) 177.79,72.17 177.33,72.63 176.55,72.63 RC11.1 176.09,73.06 v1(175.52,73.63) 174.78,74.37 174.78,74.78 174.59,74.97 173.21,74.97 172.86,75.31 172.3,75.31 172.09,75.09 171.71,75.09 171.4,75.4 170.78,75.4
HDD_DEVSLP: length 81.7
  IN2 w0.102: v3(172.94,78.7) 172.94,78.83 173.24,79.13 174.77,79.13 175.66,80.02 178.17,80.02 180.8,82.65 v2(181.59,82.65)
  IN3 w0.102: v3(222.42,116.88) 222.42,116.04 220.36,113.98 215.71,113.98 209.34,107.61 209.34,106.56 207.06,104.27 204.55,104.27 202.1,101.82 202.1,98.6 201.96,98.47 196.93,93.43 188.39,93.43 188.34,93.38 187.72,93.38 186.85,92.52 183.88,92.52 181.8,90.45 181.8,85.74 182.42,85.12 182.42,83.04 182.03,82.65 v2(181.59,82.65)
  BOTTOM w0.076: UC1.L2 167.77,78.36 168.26,78.36 168.37,78.25 169.77,78.25 170.42,78.91 170.61,78.91 170.78,79.08
  BOTTOM w0.102: R124.2 R52.1 222.96,117.42 v3(222.42,116.88) ; 170.78,79.08 170.88,79.18 171.52,79.18 171.98,78.73 v1(172.38,78.73) 172.91,78.73 v3(172.94,78.7)
HDD_FALL_INT: length 3.8
  TOP w0.102: R76.1 213,122.9 R77.1 213.25,122.66 R73.1 R75.1 v1(214.3,121.11)
HDD_LED#: length 14.4
  TOP w0.102: Q26.3 227.1,37.57 227.1,36.6 226.93,36.42 226,36.42 225.88,36.54 225.25,36.54 223.44,34.73 v1(222.37,34.73) 222.14,34.73 221.48,35.39 220.98,35.39 220.7,35.67 218.42,35.67 217.36,34.62 JLED1.5
HDMI_CEC: length 10.5
  TOP w0.102: v1(12.59,112.28) R473.2 11.52,112.23 v3(11.52,111.44)
  IN3 w0.102: JHDMI1.13 10.22,104.25 10.57,104.59 10.57,108.54 10.3,108.8 10.3,110.83 10.91,111.44 v3(11.52,111.44)
HDMI_HPD_SINK: length 8.9
  BOTTOM w0.102: QZ22.6 15.41,111.29 15.28,111.42 R474.1 v1(13.88,111.42) 13.4,110.93 13.4,109.33 13,108.93 11.29,108.93 9.95,107.58 JHDMI1.19
HDMI_OB: length 24
  TOP w0.102: v3(17.95,97.17) v1(17.95,96.26)
  IN3 w0.508: v3(19.69,108.52) 19.02,107.85 v3(19.02,105.8) 18.84,105.62 v3(18.84,102.55) 18.84,99.91 v3(18.76,99.83) 17.95,99.02 v3(17.95,97.17)
  BOTTOM w0.381: QZ22.3 18.53,109.99 18.63,110.1 19.24,110.1 19.69,109.65 v3(19.69,108.52)
  BOTTOM w0.508: R466.2 17.59,105.22 R462.2 v3(19.02,105.8) ; R465.2 v3(17.95,97.17) ; R464.2 18,102.5 R469.2 v3(18.84,102.55) ; v3(18.76,99.83) R467.2 17.87,100.01 R468.2 ; R463.2 v3(19.69,108.52)
HOST_DEB_TX: length 7.2
  TOP w0.102: JDEG1.8 223.01,95.05 222.47,95.59 222.47,98 v1(222.98,98.51) 222.98,99.71 R400.1
HOST_DEBUG_RX: length 9.4
  TOP w0.102: U38.B46 164.69,127.99 164.68,127.99 164.68,127.64 v2(164.63,127.58) ; RP16.7 162.2,131.36 162.45,131.1 162.7,131.1 163.29,131.69 163.69,131.69 v1(163.88,131.88) 163.88,132.49 v3(163.8,132.57)
  IN1 w0.097: v2(164.63,127.58) 164.61,127.6 164.61,128.51 164.3,128.82 164.3,132.07 v3(163.8,132.57)
HOST_DEBUG_TX: length 95.4
  TOP w0.102: v3(218.2,91.83) 217.82,91.45 v1(217.82,91.25) 217.82,90.46 v3(218.2,90.08) ; v2(165.65,127.58) 165.65,127.59 165.69,127.63 U38.B44 ; v3(220.92,100.95) R396.2 R400.2
  BOTTOM w0.102: v3(218.2,90.08) 217.8,89.67 210.9,89.67 210.47,90.1 210.34,90.23 208.18,90.23 204.9,93.51 204.89,93.51 204.73,93.66 201.09,93.66 200.56,94.19 196.38,98.37 196.38,99.84 196.38,100.03 195.03,101.38 193.37,101.38 192.96,101.79 190.65,101.79 187.88,104.56 185.98,104.56 181.91,108.62 180.97,108.62 178.07,111.53 178.07,117.25 177.66,117.65 177.66,123.46 176.97,124.15 176.75,124.15 173.7,127.2 172.21,127.2 171.46,126.45 169.89,126.45 169.89,126.44 166.79,126.44 v2(165.65,127.58) ; v3(218.2,91.83) 218.43,92.06 220.31,92.06 223.05,94.8 223.05,100.63 222.74,100.95 v3(220.92,100.95)
HS_IND/CFG_SEL1: length 6
  TOP w0.102: v1(216.21,50.04) 216.63,50.46 R2691.1 217.08,51.42 218.45,51.42 218.52,51.36 218.91,50.96 R2695.2 219.18,50.82 U90.25
HSYNC_BUF: length 163.4
  IN1 w0.097: v3(185.28,171.32) 185.28,171.41 186.93,173.06 191.23,173.06 192.39,171.9 195.88,171.9 197.65,170.13 211.67,170.13 214.9,173.36 223.58,173.36 226.55,170.39 258.71,170.39 259.43,169.68 262.5,169.68 263.46,168.72 277.41,168.72 277.99,169.29 283.4,169.29 284.2,170.1 308.52,170.1 308.97,169.65 317.77,169.65 318.01,169.41 329.71,169.41 330.76,170.47 337.32,170.47 338.49,169.3 v2(338.49,168.62)
  BOTTOM w0.102: v2(338.49,168.62) 338.49,168.52 339.06,167.95 JIO1.42 ; U39.20 185.52,170.92 185.28,171.16 v3(185.28,171.32)
HSYNC_DOCK: length 6.9
  BOTTOM w0.102: U39.19 185.13,170.83 185.11,170.85 185.11,170.9 184.88,171.13 184.88,171.49 185.31,171.92 v1(185.31,173.42) 185.31,173.71 184.06,174.95 184.06,175.59 183.95,175.7 JDOCK1.65
HUB_USBP1+: length 69.3
  TOP w0.102: U90.2 227.76,50.32 227.87,50.21 228.12,50.21 228.26,50.08 229.23,50.08 230.6,51.45 v3(230.6,53.1) 230.6,57.09 222.52,65.18 222.52,67.69 222.52,69.49 222.52,69.73 213.96,78.29 213.96,81.52 211.21,84.28 205.86,84.28 203.03,81.44 199.7,81.44 197.7,83.44 197.7,84.26 195.99,85.98 194.52,85.98 194.02,86.48 194.02,87.87 194.29,88.14 194.59,88.14 194.82,88.37 L54.4 195.38,88.37 R742.1
HUB_USBP1-: length 69.4
  TOP w0.102: U90.1 227.7,49.82 227.83,49.95 228.01,49.95 228.15,49.81 229.34,49.81 230.87,51.34 230.87,57.2 222.79,65.29 v3(222.79,66.18) 222.79,67.58 222.79,69.38 222.79,69.38 222.79,69.84 214.23,78.4 214.23,81.63 211.32,84.54 205.75,84.54 202.92,81.71 199.81,81.71 197.97,83.55 197.97,84.37 196.1,86.24 194.63,86.24 194.29,86.59 194.29,87.76 194.4,87.87 194.54,87.87 194.85,87.57 L54.1 195.38,87.57 R741.1
HUB_USBP1_R_D+: length 9.1
  TOP w0.102: 198.69,88.93 197.89,88.93 197.77,88.8 197.77,88.23 197.64,88.1 197.34,88.1 197.07,88.37 L54.3 196.69,88.47 R742.2 ; 198.69,88.93 198.69,88.48 199.09,88.09 199.43,88.09 200.24,87.27 201.34,87.27 201.8,87.73 202.26,87.73 202.36,87.84 202.36,88 202.46,88.1 JBIO1.4 ; 198.69,88.93 D78.2
HUB_USBP1_R_D-: length 9.2
  TOP w0.102: R741.2 196.69,87.46 L54.2 197.02,87.57 197.29,87.83 197.68,87.83 197.81,87.71 197.81,87.13 197.93,87 D78.3 198.7,87.6 198.92,87.82 199.32,87.82 200.13,87.01 201.45,87.01 201.91,87.47 202.26,87.47 202.36,87.37 202.36,87.2 202.46,87.1 JBIO1.3
HUB_USBP2+: length 182.6
  TOP w0.102: v2(94.56,12.63) 94.4,12.79 94.4,13.04 94.69,13.33 L59.1 94.69,13.9 R487.1 ; v2(228.46,51.4) 228.28,51.22 227.65,51.22 227.54,51.32 U90.4
  IN1 w0.097: v2(94.56,12.63) 95.34,13.42 98.73,13.42 99.67,14.36 114.13,14.36 116.1,12.38 138.18,12.38 139.96,10.6 150.74,10.6 152.52,12.38 225.42,12.38 231.79,18.76 231.79,30.37 229.97,32.19 229.97,36.87 229.18,37.66 228.6,37.66 227.63,38.63 227.63,44.72 229.84,46.93 229.84,50.5 228.99,51.35 228.52,51.35 v2(228.46,51.4)
HUB_USBP2+_D: length 3.4
  TOP w0.102: JEXP1.10 95.06,17.11 94.94,16.99 94.94,16.78 v3(94.64,16.47) 94.38,16.21 94.38,15.79 94.69,15.47 L59.2 94.69,14.93 R487.2
HUB_USBP2-: length 182.7
  TOP w0.102: U90.3 227.5,50.82 227.63,50.95 228.3,50.95 v2(228.46,50.79) ; v2(93.93,12.63) 94.14,12.84 94.14,12.98 93.84,13.27 L59.4 93.84,13.87 R486.1
  IN1 w0.097: v2(228.46,50.79) 228.46,50.84 228.71,51.08 228.88,51.08 229.57,50.39 229.57,47.03 227.36,44.82 227.36,38.53 228.49,37.4 229.07,37.4 229.71,36.77 229.71,32.08 231.53,30.26 231.53,18.87 225.31,12.65 152.41,12.65 150.63,10.87 140.07,10.87 138.29,12.65 116.21,12.65 114.24,14.62 99.56,14.62 98.62,13.68 95.24,13.68 94.6,13.04 94.34,13.04 v2(93.93,12.63)
HUB_USBP2-_D: length 3.4
  TOP w0.102: JEXP1.12 94.56,17.11 94.68,16.99 94.68,16.89 94.11,16.32 94.11,15.79 93.84,15.51 L59.3 93.84,14.95 R486.2
HUB_USBP3+: length 199.6
  TOP w0.102: v2(228.03,53.17) 227.83,53.17 227.48,52.82 U90.7
  IN3 w0.102: v2(228.03,53.17) 229,53.17 229.87,54.05 229.87,58.62 218.48,70.02 218.48,87.79 220.89,90.21 220.89,92.69 226.76,98.56 226.76,111.7 228.59,113.53 228.59,121.33 230.61,123.35 230.61,124.18 236.84,130.4 239.62,130.4 241.46,132.24 248.33,132.24 256.52,140.44 257.87,140.44 269.88,152.45 272.45,152.45 279.51,159.51 290.76,159.51 292.09,160.84 293.52,160.84 296.11,163.44 301.36,163.44 303.22,165.3 303.22,167.18 314.49,178.45 319.47,178.45 319.75,178.17 319.75,177.61 v2(319.85,177.51)
  BOTTOM w0.102: JMINI1.38 319.9,178.76 319.7,178.56 319.7,177.66 v2(319.85,177.51)
HUB_USBP3-: length 199.6
  TOP w0.102: U90.6 227.46,52.32 227.78,52.64 227.98,52.64 v2(228.03,52.59)
  IN3 w0.102: v2(228.03,52.59) 228.19,52.75 228.19,52.79 228.3,52.91 229.11,52.91 230.14,53.94 230.14,58.74 218.74,70.13 218.74,87.68 221.16,90.1 221.16,92.58 227.03,98.45 227.03,111.59 228.86,113.42 228.86,121.22 230.88,123.24 230.88,124.07 236.95,130.14 239.73,130.14 241.57,131.98 248.44,131.98 256.63,140.17 257.98,140.17 269.99,152.18 272.56,152.18 279.62,159.24 290.87,159.24 292.2,160.58 293.63,160.58 296.22,163.17 301.47,163.17 303.49,165.19 303.49,167.07 314.6,178.18 319.36,178.18 319.48,178.06 319.48,177.67 319.33,177.52 v2(319.19,177.52)
  BOTTOM w0.102: v2(319.19,177.52) 319.27,177.52 319.43,177.68 319.43,178.54 319.1,178.87 JMINI1.36
HUB_USBP4+: length 142.3
  TOP w0.102: U90.9 227.67,53.82 v2(228.21,54.37)
  IN3 w0.102: v2(228.21,54.37) 228.26,54.32 228.87,54.32 228.97,54.41 228.97,57.9 217.49,69.38 217.49,92.9 225.89,101.29 225.89,112.76 227.71,114.59 227.71,121.8 229.62,123.71 229.62,124.43 236.51,131.32 239.26,131.32 242.17,134.23 247.94,134.23 259.13,145.41 259.57,145.41 259.73,145.25 v4(260.04,145.25)
  BOTTOM w0.102: v4(260.04,145.25) 259.63,145.25 255.91,148.97 254.99,149.88 248.11,156.77 248.11,158.88 247.64,159.35 247.13,159.35 247.01,159.47 L57.4 246.42,159.47 R483.1
HUB_USBP4+_D: length 3
  BOTTOM w0.102: L57.3 244.72,159.47 244.45,159.21 244,159.21 243.81,159.02 243.5,159.02 243.22,159.3 JMINI2.38
HUB_USBP4-: length 142.3
  TOP w0.102: v2(228.21,53.78) 228.1,53.78 227.64,53.32 U90.8
  IN3 w0.102: v4(259.5,144.69) 259.65,144.84 259.65,144.95 259.46,145.15 259.24,145.15 248.05,133.96 242.28,133.96 239.37,131.05 236.62,131.05 229.89,124.32 229.89,123.6 227.98,121.69 227.98,114.48 226.15,112.65 226.15,101.18 217.76,92.79 217.76,69.49 229.24,58.01 229.24,54.3 228.98,54.05 228.48,54.05 v2(228.21,53.78)
  BOTTOM w0.102: v4(259.5,144.69) 259.5,145 254.81,149.7 247.84,156.66 247.84,158.77 247.53,159.08 247.22,159.08 247.13,158.99 247.13,158.86 246.89,158.62 L57.1 246.42,158.62 R482.1
HUB_USBP4-_D: length 3
  BOTTOM w0.102: JMINI2.36 243.16,158.5 243.41,158.75 243.92,158.75 244.11,158.94 244.44,158.94 244.76,158.62 L57.2
HW_GPS_DISABLE#: length 96.5
  TOP w0.102: R282.2 184.04,118.35 v1(184.83,118.35) v3(185.84,118.35) 185.84,119.37 186.05,119.57 187,119.57 187.06,119.64 U37.B34
  IN3 w0.102: v3(185.84,118.35) 185.84,118.22 187.74,116.33 191.62,116.33 191.94,116.65 191.94,117.13 192.4,117.59 192.93,117.59 194.86,115.66 195.92,115.66 196.48,116.22 197.7,116.22 198.6,117.12 200.76,117.12 202.48,118.83 202.48,121.41 204.94,123.88 204.94,127.41 204.94,134.16 204.94,134.23 209.54,138.82 216.14,138.82 217.8,140.47 226.15,140.47 232.15,146.47 232.86,146.47 233.52,147.13 234.4,147.13 235.02,147.74 235.02,151.17 234.48,151.71 234.48,163.5 v3(235.48,164.5)
  BOTTOM w0.102: JMINI2.51 v3(235.48,164.5)
I2C0_SCL: length 22.8
  BOTTOM w0.076: 169.75,82.22 169.04,81.5 168.01,81.5 167.78,81.28 167.78,80.98 167.61,80.8 167.38,80.8 167.13,81.04 UC1.F3
  BOTTOM w0.102: RP8.7 182.27,85.12 182.16,85.23 181.8,85.23 181.32,85.71 181.32,86.35 178.25,89.42 175.37,89.42 172.58,86.63 172.58,84.8 v3(171.67,83.88) 170.43,82.64 170.18,82.64 169.75,82.22
I2C0_SDA: length 22
  BOTTOM w0.076: 169.59,82.38 169.58,82.36 169.58,82.35 169.54,82.31 169.54,82.29 168.96,81.71 167.91,81.71 167.49,81.29 UC1.F2
  BOTTOM w0.102: RP8.8 182.25,85.62 182.08,85.46 181.9,85.46 181.55,85.81 181.55,86.45 178.35,89.65 175.28,89.65 172.36,86.73 v3(172.36,85.13) 172.36,84.89 170.33,82.87 170.08,82.87 169.59,82.38
I2C1_SCL_TCH_PAD: length 82.3
  TOP w0.102: v3(147.27,104.66) 147.27,105.02 R449.1 ; RC176.2 181.95,84.87 v3(181.7,84.62) 181.55,84.47 181.22,84.47 181.02,84.67 181.02,89.49 182.6,91.08 182.6,100.5 184.72,102.62 184.72,103.72 v3(184.95,103.95)
  IN1 w0.097: v3(184.95,103.95) 184.8,103.79 184.8,103.42 184.52,103.14 184.24,103.14 183.46,103.14 181.83,101.5 167.86,101.5 167.52,101.15 165.65,101.15 165.03,100.54 164.4,100.54 164.36,100.5 162.2,100.5 161.54,101.16 151.64,101.16 150.23,102.57 150.23,102.58 149.98,102.83 148.11,102.83 147.49,103.45 147.49,104.44 v3(147.27,104.66)
  BOTTOM w0.076: 170.78,82.35 170.76,82.33 170.69,82.33 170.68,82.32 170.33,82.32 169.13,81.12 UC1.F1
  BOTTOM w0.102: RP8.6 v3(181.7,84.62) 181.5,84.42 181.07,84.42 180.6,83.95 180.6,83.76 180.6,83.62 178.32,81.34 175.26,81.34 174.78,81.82 174.32,81.82 173.61,82.54 v3(171.59,82.54) 170.96,82.54 170.78,82.35
I2C1_SCL_VMM: length 152.2
  TOP w0.102: v3(185.86,103.29) 186.05,103.1 186.05,102.68 185.94,102.58 185.4,102.58 183.13,100.3 183.13,100.05 183.13,90.45 182.18,89.51 v3(182.18,88.14) 182.18,86.76 183.45,85.5 184.12,85.5 184.19,85.42 184.19,84.64 184.1,84.54 183.94,84.54 RC176.1 ; U6.A2 175.43,155.38 174.41,155.38 171.11,152.08 171.11,151.4 v3(170.88,151.17)
  IN1 w0.097: v3(136.87,104.99) 136.64,105.22 136.64,105.37 136.74,105.47 141.65,105.47 142.48,104.63 144.68,104.63 145.37,105.33 150.35,105.33 150.44,105.24 150.64,105.24 151.3,104.58 151.3,102.74 152.17,101.87 161.95,101.87 162.23,102.15 162.87,102.15 163.25,101.77 164.85,101.77 164.94,101.86 167.22,101.86 167.6,102.23 181.53,102.23 183.76,104.46 185.59,104.46 185.86,104.19 185.97,104.08 185.97,103.4 v3(185.86,103.29)
  BOTTOM w0.102: v3(170.88,151.17) 171.09,151.37 171.09,151.95 170.5,152.54 167.71,152.54 166.82,151.65 163.07,151.65 159.64,148.22 159.64,145.82 158.87,145.05 158.87,142.17 144.34,127.65 144.34,123.76 137.43,116.85 137.43,106.75 136.67,105.99 136.67,105.19 v3(136.87,104.99)
I2C1_SDA_TCH_PAD: length 84.3
  TOP w0.102: v3(147.91,104.63) 147.89,104.63 147.87,104.63 147.58,104.34 R450.1 ; v3(184.32,103.95) 184.5,103.77 184.5,102.72 182.38,100.6 182.38,91.17 180.79,89.59 180.79,84.58 181.12,84.24 181.43,84.24 v3(181.68,83.99) 181.68,83.98 RC174.2
  IN1 w0.097: v3(147.91,104.63) 147.72,104.44 147.72,103.54 148.2,103.05 150.07,103.05 150.46,102.67 150.46,102.66 151.73,101.38 161.63,101.38 162.3,100.72 164.26,100.72 164.3,100.76 164.94,100.76 165.56,101.38 167.42,101.38 167.77,101.73 181.73,101.73 183.37,103.36 184.33,103.36 184.43,103.36 184.57,103.51 184.57,103.69 v3(184.32,103.95)
  BOTTOM w0.076: UC1.G4 166.58,80.76 167.19,80.76 167.31,80.64 167.82,80.64 167.97,80.79 168.74,80.79 168.86,80.92 169.21,80.92 170.42,82.12 170.78,82.12
  BOTTOM w0.102: 170.78,82.12 170.93,82.12 171.12,82.31 173.51,82.31 174.23,81.59 174.69,81.59 175.16,81.11 v3(175.75,81.11) 178.42,81.11 180.83,83.52 180.83,83.85 181.16,84.19 181.48,84.19 v3(181.68,83.99) 181.81,84.12 RP8.5
I2C1_SDA_VMM: length 153.6
  TOP w0.102: v4(186.49,103.29) 186.27,103.07 186.27,102.58 186.04,102.35 185.5,102.35 183.36,100.21 183.36,99.96 183.36,90.36 182.41,89.42 182.41,86.85 183.54,85.72 184.22,85.72 184.42,85.52 184.42,84.55 184.19,84.31 183.94,84.31 RC174.1 ; v3(171.52,151.17) 171.34,151.34 171.34,151.99 174.51,155.15 175.43,155.15 U6.A1
  IN1 w0.097: v3(136.24,105.04) 136.41,105.22 136.41,105.46 136.65,105.7 141.74,105.7 142.58,104.86 144.59,104.86 145.28,105.55 150.44,105.55 150.53,105.46 150.74,105.46 151.52,104.68 151.52,102.83 152.27,102.09 161.86,102.09 162.14,102.37 162.96,102.37 163.34,101.99 164.76,101.99 164.85,102.08 167.13,102.08 167.5,102.45 181.44,102.45 183.67,104.68 185.68,104.68 186.08,104.28 186.08,104.28 186.19,104.17 186.19,103.59 v4(186.49,103.29)
  BOTTOM w0.102: v3(136.24,105.04) 136.44,105.24 136.44,106.08 137.2,106.84 137.2,116.95 144.11,123.86 144.11,127.74 158.64,142.27 158.64,145.14 159.41,145.91 159.41,148.31 162.98,151.88 166.72,151.88 167.61,152.77 170.6,152.77 171.31,152.05 171.31,151.37 v3(171.52,151.17)
I2CC_SCL: length 5.7
  BOTTOM w0.102: RV45.2 60.75,114.18 61.64,113.3 v1(61.64,112.74) 61.64,112.57 62.91,111.29 63.77,111.29 64.35,110.71 UV1.A9
I2CC_SDA: length 8.9
  BOTTOM w0.102: UV1.B9 64.38,109.74 64.79,110.15 64.79,111.04 64.33,111.49 63.14,111.49 62.5,112.13 62.5,112.94 61.61,113.83 RV46.2 62.12,114.69 v1(62.12,116.24)
I2CS_SCL: length 20.1
  IN2 w0.102: v5(64.77,107.74) 66.03,109 68.29,109 68.85,109.56 68.85,114.16 v3(66.39,116.62)
  BOTTOM w0.1: UV1.D9 64.37,108.14 v5(64.77,107.74)
  BOTTOM w0.102: RV49.2 67.23,121.73 QC9.1 67.22,121.38 v2(66.89,121.05) 66.3,120.46 v1(66.3,120.01) 66.3,116.71 v3(66.39,116.62)
I2CS_SDA: length 21.3
  TOP w0.102: v5(64.77,108.54) 65.33,108.54 v1(65.34,108.52)
  IN2 w0.102: v5(64.77,108.54) 64.96,108.54 67.83,111.42 67.83,114.39 v3(66.36,115.86)
  BOTTOM w0.1: UV1.D8 65.17,108.14 v5(64.77,108.54)
  BOTTOM w0.102: v3(66.36,115.86) 65.88,116.34 65.88,119.82 65.29,120.41 65.29,122.67 65.92,123.3 QC9.4 65.92,124.19 66.59,124.86 RV50.2
I2S_BCLK: length 143.8
  TOP w0.102: v3(278.63,154.6) 279.72,155.69 289.32,155.69 290.03,154.98 294.28,154.98 295.16,154.09 299.57,154.09 300.03,154.55 302.35,154.55 302.63,154.82 304.46,154.82 305.17,155.54 v1(305.97,155.54) 306.97,155.54 307.27,155.23 312.24,155.23 v2(313.25,154.23)
  BOTTOM w0.102: U17.16 v2(313.25,154.23) ; v3(278.63,154.6) 278.25,154.22 271.02,154.22 269.49,155.74 268.88,156.36 268.88,161.35 259.25,170.98 258.95,170.98 226.74,170.98 226.71,171 225.69,172.02 212.44,172.02 211.39,170.98 209.29,170.98 205.3,166.99 201.79,166.99 199.1,169.68 192.47,169.68 191.93,170.22 190.36,170.22 189.65,170.93 189.65,171.47 189.15,171.97 189.15,171.97 189.1,172.02 188.82,172.02 188.19,172.65 R139.2
I2S_DI#: length 146.6
  IN3 w0.102: v2(283.02,154.52) 283.38,154.88 290.41,154.88 291.15,155.61 291.15,155.61 293.51,157.97 297.4,157.97 298.01,158.58 301.96,158.58 302.47,158.08 306.05,158.08 306.48,158.51 306.89,158.91 310.94,158.91 311.91,157.94 311.91,156.72 313.76,154.88 313.76,150.7 v2(313.44,150.38)
  BOTTOM w0.102: R144.2 190.5,172.02 190.88,172.02 191.11,171.79 192.47,171.79 192.59,171.91 192.6,171.89 194.09,171.89 194.9,171.08 v1(200.85,171.08) 201.37,171.08 202.08,171.8 211.21,171.8 212.19,172.78 225.94,172.78 226.46,172.26 226.46,172.26 226.93,171.8 259.44,171.8 269.59,161.65 269.59,156.65 271.11,155.13 282.41,155.13 v2(283.02,154.52) ; U17.24 313.29,150.23 v2(313.44,150.38)
I2S_DO: length 140.7
  TOP w0.102: v2(284.39,156.78) 284.78,156.4 289.02,156.4 289.61,156.4 290.32,155.69 294.57,155.69 295.46,154.8 299.27,154.8 300.34,155.87 303.24,155.87 303.65,156.27 307.24,156.27 307.42,156.09 v1(312.11,156.09) 313.27,156.09 314.52,154.85 v2(314.52,154.65)
  BOTTOM w0.102: v2(314.52,154.65) 313.6,153.73 U17.17 ; v2(284.39,156.78) 283.18,155.56 271.56,155.56 271.56,155.56 271.27,155.56 271.27,155.56 270.35,156.48 269.94,156.89 269.94,161.79 259.56,172.18 227.05,172.18 227.03,172.2 226.09,173.14 212.05,173.14 211.08,172.18 201.92,172.18 201.32,171.57 194.96,171.57 194.25,172.27 192.45,172.27 192.32,172.15 191.26,172.15 R141.2
