# Allegro board Alpine15_LA-A101PR10-0826C.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_A_DQS#1: length 73.1
  IN1 w0.076: v2(128.13,65.75) 127.96,65.57 127.96,64.69 127.96,64.55 126.33,62.93 125.59,62.93 125.38,62.72 125.31,62.72
  IN1 w0.097: v2(90.11,20.18) 90.32,20.39 90.62,20.39 90.87,20.64 90.87,31.74 117.72,58.58 120.89,58.58 125.03,62.72 125.31,62.72
  BOTTOM w0.076: v2(128.13,65.75) 128.24,65.65 128.24,65.49 127.75,65.01 127.59,65.01 127.43,65.17 127.43,65.81 128,66.39 129.61,66.39 129.66,66.41 ; UC1.AN62 130.54,66.22 130.54,66.33 130.48,66.39 130.06,66.39 130.01,66.41 129.92,66.45 129.9,66.46 129.77,66.46 129.72,66.44 129.66,66.41 ; 129.66,66.41 129.66,66.41 129.66,66.41
  BOTTOM w0.102: JDIMM1.10 90.68,19.36 90.76,19.44 90.99,19.44 91.06,19.51 91.06,20.24 90.85,20.46 90.39,20.46 v2(90.11,20.18)
DDR_A_DQS#2: length 62.5
  IN3 w0.076: v2(132.28,66.66) 132.09,66.47 131.6,66.47 131.23,66.1 131.23,65.59 131.02,65.38 130.51,65.38 129.81,64.68 129.81,63.68 129.81,63.41 126.87,60.48 126.64,60.48 126.62,60.49 126.53,60.49
  IN3 w0.102: v2(135.87,20.74) 135.87,20.9 135.63,21.14 135.23,21.14 134.95,21.41 134.95,21.97 135.17,22.19 135.17,22.89 135.01,23.05 135.01,23.68 135.12,23.79 135.12,24.37 135.01,24.48 135.01,24.97 132.63,27.35 132.63,28.88 122.96,38.55 122.96,57.23 125.32,59.59 125.32,59.74 125.22,59.83 125.22,60.15 125.57,60.49 126.53,60.49
  BOTTOM w0.076: UC1.AM58 132.61,66.99 v2(132.28,66.66)
  BOTTOM w0.102: v2(135.87,20.74) 135.87,21.25 136.04,21.42 136.44,21.42 136.61,21.25 136.61,20.34 135.93,19.65 135.93,19.47 135.68,19.22 JDIMM1.152
DDR_A_DQS#3: length 70.1
  IN1 w0.076: v2(134.15,67.27) 134.34,67.08 134.58,67.08 134.77,66.88 134.77,64.39 133.44,63.05 131.94,63.05 131.38,62.5 130.34,62.5 129.39,61.55 129.39,61.52 129.35,61.48 129.35,61.47
  IN1 w0.097: 129.35,61.47 127.14,59.25 126.91,59.25 122.46,54.8 120.85,54.8 117.32,51.28 116.5,51.28 112.69,47.47 104.31,39.08 102.54,37.31 100.26,35.03 100.26,34.87 100.47,34.66 100.47,34.3 100.21,34.05 99.85,34.05 99.67,34.23 99.49,34.23 99.33,34.07 99.33,33.89 99.91,33.3 99.91,33.01 99.59,32.69 99.3,32.69 98.71,33.27 98.53,33.27 98.37,33.11 98.37,32.93 98.96,32.35 98.96,32.05 98.64,31.73 98.34,31.73 97.74,32.33 97.56,32.33 97.4,32.17 97.4,31.99 98,31.39 98,31.09 97.68,30.77 97.39,30.77 96.91,31.25 96.59,31.25 96.46,31.13 96.46,29.27 95.96,28.77 95.68,28.77 v2(95.32,28.41)
  BOTTOM w0.076: v2(134.15,67.27) 134.44,66.99 UC1.AM55
  BOTTOM w0.102: JDIMM1.27 95.78,27.65 96,27.88 96,29.02 95.9,29.12 95.34,29.12 95.24,29.02 95.24,28.49 v2(95.32,28.41)
DDR_A_DQS#4: length 55.3
  IN3 w0.076: v2(130.19,59.4) 130.19,59.17 130.35,59.01 130.35,58.41 128.65,56.71 128.65,56.68 128.59,56.62
  IN3 w0.102: v2(141.02,24.07) 141.02,23.41 140.86,23.25 140.53,23.25 140.38,23.41 140.38,24.88 140.55,25.06 140.55,25.5 138.47,27.59 138.47,28.8 133.29,33.98 133.29,34.6 127.62,40.27 127.62,55.65 128.59,56.62
  BOTTOM w0.076: UC1.AV57 133.38,63.4 133.3,63.32 133.15,63.32 133.06,63.23 133,63.17 132.92,63 132.92,62.8 132.95,62.74 133,62.64 133,62.51 132.92,62.35 132.92,62.15 132.95,62.1 132.95,62.1 133,61.99 133,61.8 132.67,61.48 132.67,60.94 130.56,58.83 130.29,58.83 130.09,59.03 130.09,59.3 v2(130.19,59.4)
  BOTTOM w0.102: v2(141.02,24.07) 141.02,23.71 141.19,23.53 141.41,23.53 141.54,23.67 141.54,24.84 141.17,25.21 141.17,25.22 140.86,25.22 140.78,25.3 JDIMM1.169
DDR_A_DQS#5: length 62.2
  IN1 w0.076: 129.31,55.46 129.49,55.46 133.08,59.05 134.27,59.05 134.36,58.97 134.36,58.76 v2(134.23,58.64)
  IN1 w0.097: 129.31,55.46 128.8,55.46 112.69,39.36 104.31,30.97 101.77,28.43 101.77,27.22 101.02,26.48 101.02,23.28 101.15,23.15 101.48,23.15 101.62,23.28 101.62,23.68 v2(101.49,23.8)
  BOTTOM w0.076: v2(134.23,58.64) 134.23,59.54 134.93,60.24 134.93,61.21 135.17,61.45 135.17,61.53 135.43,61.78 135.43,61.99 135.38,62.09 135.35,62.15 135.35,62.35 135.43,62.51 135.43,63.02 135.52,63.11 135.52,63.26 UC1.AV53
  BOTTOM w0.102: v2(101.49,23.8) 101.49,23.52 101.63,23.38 101.87,23.38 102.01,23.52 102.01,24.38 102.01,24.46 101.4,25.07 101.4,25.24 101.18,25.46 JDIMM1.45
DDR_A_DQS#6: length 69.1
  IN1 w0.076: 133.54,55.91 133.55,55.91 133.6,55.96 133.61,55.96 137.06,59.41 137.06,59.84 137.06,59.84 137.06,59.91 137.06,60.05 137.53,60.52 137.53,63.69 138.06,64.22 138.98,64.22 139.25,64.49 140,64.49 140.25,64.74 140.25,65.69 140.57,66.01 141.28,66.01 141.57,66.31 141.9,66.31 142.16,66.57 142.16,67.03 v2(141.75,67.44)
  IN1 w0.097: 133.54,55.91 133.54,55.91 133.42,55.79 133.42,54.64 113.75,34.96 113.47,34.96 107.04,28.53 107.04,23.34 105.53,21.83 105.53,20.99 105.87,20.65 106.15,20.65 106.26,20.53 v2(106.26,20.17)
  BOTTOM w0.076: UC1.AL43 142.05,67.44 v2(141.75,67.44)
  BOTTOM w0.102: JDIMM1.62 106.28,19.17 106.67,19.57 106.67,19.71 106.72,19.76 106.72,20.69 106.6,20.82 106.39,20.82 106.26,20.68 v2(106.26,20.17)
DDR_A_DQS#7: length 64.9
  IN3 w0.076: v2(138.9,67.31) 138.72,67.31 138.47,67.07 138.47,66.55 138.13,66.2 137.55,66.2 137.2,65.85 136.97,65.85 136.04,64.92 136.04,62.85 136.02,62.82 136.02,59.33 133.74,57.05 133.74,57.03 133.72,57.01 133.72,56.96 133.71,56.96
  IN3 w0.102: v2(147.39,21.65) 147.39,20.97 147.21,20.79 145.89,20.79 145.79,20.89 145.79,21.27 145.89,21.37 146.58,21.37 146.81,21.6 146.81,22.06 146.58,22.29 146.35,22.29 146.24,22.39 146.24,22.69 146.35,22.79 146.48,22.79 146.71,23.01 146.71,24.97 144.95,26.72 144.95,28.34 131.68,41.61 131.68,54.92 133.71,56.96
  BOTTOM w0.076: UC1.AL48 139.14,67.64 138.9,67.39 v2(138.9,67.31)
  BOTTOM w0.102: JDIMM1.186 145.88,19.22 146.08,19.42 146.08,20.7 146.68,21.3 147.06,21.3 147.39,21.63 v2(147.39,21.65)
DDR_A_MA0: length 59.6
  IN1 w0.076: 143.28,54.06 143.28,54.92 145.46,57.09 145.46,57.77 145.77,58.08 145.77,63.2 v2(146.15,63.58)
  IN1 w0.14: v2(119.19,22.41) 118.98,22.62 118.98,26.04 120.53,27.58 120.53,28.08 120.53,28.47 129.42,37.36 133.2,37.36 138.76,42.92 138.76,44.29 143.28,48.82 143.28,54.06
  BOTTOM w0.076: UC1.AU36 146.29,63.58 v2(146.15,63.58)
  BOTTOM w0.152: JDIMM1.98 119.48,22.13 v2(119.19,22.41)
DDR_A_MA1: length 59.7
  IN1 w0.076: 143.7,54.7 143.7,54.92 145.66,56.88 145.66,57.72 145.94,57.99 145.94,60.5 v2(146.32,60.89)
  IN1 w0.14: v2(119.4,24.9) 119.4,25.72 120.95,27.26 120.95,28.26 129.63,36.94 133.49,36.94 140,43.45 140,43.65 139.47,44.18 139.47,44.37 139.67,44.57 139.87,44.57 140.4,44.04 140.59,44.04 140.79,44.24 140.79,44.44 140.27,44.97 140.27,45.16 140.44,45.33 140.63,45.33 141.16,44.81 141.36,44.81 141.56,45 141.56,45.2 141.03,45.73 141.03,45.93 141.23,46.13 141.42,46.13 141.95,45.6 142.15,45.6 142.35,45.8 142.35,45.99 141.82,46.52 141.82,46.72 142.02,46.92 142.22,46.92 142.74,46.39 142.94,46.39 143.14,46.59 143.14,46.78 142.61,47.31 142.61,47.51 143.7,48.6 143.7,54.7
  BOTTOM w0.076: UC1.AY37 145.72,61.5 v2(146.32,60.89)
  BOTTOM w0.152: v2(119.4,24.9) 119.4,24.9 119.4,24.88 119.18,25.1 JDIMM1.97
DDR_A_MA2: length 61.6
  IN1 w0.076: v2(145.12,64.71) 145.19,64.64 145.19,58.26 144.82,57.88 144.82,57.27 141.77,54.23 141.77,53.84
  IN1 w0.14: 141.77,53.84 141.77,49.08 134.2,41.51 134.2,41.31 134.64,40.88 134.64,40.68 132.58,38.62 128.89,38.62 118.65,28.37 118.65,28.28 118.65,28.27 118.65,27.94 118.65,27.93 118.65,27.92 118.65,27.48 117.47,26.3 117.47,22.29 118.28,21.48 v2(118.28,21.31)
  BOTTOM w0.076: v2(145.12,64.71) 145.44,65.04 UC1.AR38
  BOTTOM w0.152: JDIMM1.96 118.88,20.71 v2(118.28,21.31)
DDR_A_MA3: length 60.8
  IN1 w0.076: v2(146.07,65.51) 146.42,65.16 146.42,64.66 145.59,63.83 145.59,58.15 145.26,57.82 145.26,57.21 142.61,54.56
  IN1 w0.089: 142.61,54.56 142.23,54.18 142.23,53.11 142.78,52.56
  IN1 w0.14: v2(117.98,23.34) 118.12,23.34 118.4,23.61 118.4,26.05 119.73,27.38 119.73,28.27 129.24,37.78 133.03,37.78 138.34,43.1 138.34,44.47 142.78,48.9 142.78,52.56
  BOTTOM w0.076: UC1.AP36 146.24,65.69 v2(146.07,65.51)
  BOTTOM w0.152: JDIMM1.95 118.58,23.94 v2(117.98,23.34)
DDR_A_MA4: length 61.2
  IN1 w0.076: 141.54,54.25 144.64,57.34 144.64,57.95 145.03,58.34 145.03,63.12 v2(144.57,63.58)
  IN1 w0.089: 141.54,54.25 141.54,53.63
  IN1 w0.14: v2(118.28,19.79) 118.14,19.79 117.53,20.4 117.53,21.61 117.05,22.1 117.05,26.47 117.72,27.15 117.72,28.23 128.53,39.04 132.31,39.04 133.9,40.63 133.9,40.82 133.41,41.31 133.41,41.51 141.28,49.38 141.28,52.53 141.54,52.79 141.54,53.63
  BOTTOM w0.076: UC1.AU39 144.72,63.58 v2(144.57,63.58)
  BOTTOM w0.152: JDIMM1.92 117.68,19.19 v2(118.28,19.79)
DDR_A_MA5: length 61.1
  IN1 w0.076: v2(146.07,64.86) 145.42,64.21 145.42,58.23 144.99,57.81 144.99,57.2 142.05,54.26
  IN1 w0.089: 142.05,52.34 142.05,54.26
  IN1 w0.14: 142.05,52.34 142.26,52.13 142.26,48.98 137.29,44.01 137.29,43.81 137.73,43.38 137.73,43.18 137.53,42.98 137.33,42.98 136.9,43.42 136.7,43.42 136.5,43.22 136.5,43.02 136.93,42.59 136.93,42.39 136.74,42.19 136.54,42.19 136.11,42.63 135.91,42.63 135.71,42.43 135.71,42.23 136.14,41.8 136.14,41.6 135.95,41.4 135.75,41.4 135.32,41.84 135.12,41.84 134.92,41.64 134.92,41.44 135.35,41.01 135.35,40.8 132.75,38.2 129.07,38.2 119.07,28.2 119.07,27.76 119.07,27.76 119.07,27.31 117.98,26.22 v2(117.98,24.86)
  BOTTOM w0.076: UC1.AR36 146.24,65.04 v2(146.07,64.86)
  BOTTOM w0.152: JDIMM1.91 117.38,25.46 v2(117.98,24.86)
DDR_A_MA6: length 62
  IN1 w0.076: v2(144.53,60.26) 144.86,59.93 144.86,58.43 144.46,58.03 144.46,57.42 141.24,54.2 141.24,53.81
  IN1 w0.14: v2(116.48,19.79) 116.91,20.22 116.91,21.65 116.63,21.93 116.63,26.65 117.3,27.32 117.3,28.4 128.4,39.51 132.19,39.51 132.44,39.76 132.44,39.96 131.96,40.45 131.96,40.65 132.13,40.82 132.32,40.82 132.81,40.33 133.01,40.33 133.21,40.53 133.21,40.73 132.72,41.21 132.72,41.41 140.83,49.52 140.83,52.46 141.24,52.87 141.24,53.81
  BOTTOM w0.076: v2(144.53,60.26) 143.85,60.94 143.85,62.93 UC1.AV40
  BOTTOM w0.152: v2(116.48,19.79) 117.08,19.19 JDIMM1.90
DDR_A_MA7: length 60.6
  IN1 w0.076: 143.93,61.65 143.93,57.73 142.04,55.84 141.4,55.84 139.65,54.09
  IN1 w0.089: v2(144.56,62.28) 143.93,61.65
  IN1 w0.14: v2(116.48,21.31) 115.6,22.19 115.6,22.2 115.52,22.28 115.52,22.42 114.89,23.05 114.89,27.02 115.5,27.63 115.5,28.44 130.86,43.8 131.47,43.8 131.61,43.94 131.61,44.28 131.75,44.42 132.6,44.42 132.73,44.3 132.73,43.94 132.87,43.8 133.15,43.8 133.29,43.94 133.29,44.19 133.43,44.33 133.81,44.33 139.44,49.96 139.44,51.9 139.65,52.12 139.65,54.09
  BOTTOM w0.076: UC1.AW39 144.86,62.58 v2(144.56,62.28)
  BOTTOM w0.152: JDIMM1.86 115.88,20.71 v2(116.48,21.31)
DDR_A_MA8: length 59.6
  IN1 w0.076: 140.02,54.06 141.39,55.43 141.86,55.43 144.1,57.67 144.1,61.12
  IN1 w0.089: v2(144.56,61.58) 144.1,61.12
  IN1 w0.14: v2(116.1,23.34) 115.52,23.34 115.33,23.53 115.33,25.28 115.68,25.64 115.68,26.03 115.33,26.38 115.33,26.83 115.92,27.42 115.92,28.26 130.9,43.24 131.15,43.24 132.14,42.26 132.33,42.26 132.53,42.46 132.53,42.66 131.93,43.26 131.93,43.46 132.13,43.65 132.32,43.65 132.93,43.05 133.12,43.05 139.94,49.87 139.94,51.8 140.02,51.88 140.02,54.06
  BOTTOM w0.076: v2(144.56,61.58) 144.91,61.93 UC1.AY39
  BOTTOM w0.152: v2(116.1,23.34) 116.78,24.02 JDIMM1.89
DDR_A_MA9: length 61.6
  IN1 w0.076: 141.92,55.13 144.28,57.49 144.28,58.5 v2(144.51,58.72)
  IN1 w0.089: 140.57,54.06 141.63,55.13 141.92,55.13
  IN1 w0.14: v2(116.1,24.86) 116.1,26.72 116.88,27.5 116.88,28.23 116.88,28.58 129.27,40.96 129.48,40.96 130.48,39.96 130.68,39.96 130.88,40.16 130.88,40.36 129.88,41.36 129.88,41.56 130.07,41.75 130.27,41.75 131.27,40.75 131.47,40.75 131.67,40.95 131.67,41.15 130.67,42.15 130.67,42.35 130.86,42.54 131.06,42.54 132.06,41.54 132.26,41.54 140.41,49.7 140.41,53.91 140.57,54.06
  BOTTOM w0.076: v2(144.51,58.72) 143.69,59.54 143.69,63.4 143.95,63.67 143.95,63.73 UC1.AU40
  BOTTOM w0.152: JDIMM1.85 115.58,25.39 v2(116.1,24.86)
DDR_A_MA10: length 62
  IN1 w0.076: v2(147.02,65.36) 146.66,65 146.66,62.83 147.35,62.14 147.35,58.48 147.21,58.34 147.21,56.12 146.82,55.73
  IN1 w0.14: v2(123.12,23.34) 123.52,22.94 123.52,22.17 123.38,22.03 123.12,22.03 122.65,22.51 122.65,25.36 123.38,26.09 123.38,26.72 124.04,27.39 124.04,27.83 130.82,34.61 134.24,34.61 145.93,46.3 145.93,54.84 146.82,55.73
  BOTTOM w0.076: UC1.AP35 147.35,65.69 v2(147.02,65.36)
  BOTTOM w0.152: JDIMM1.107 122.18,24.29 v2(123.12,23.34)
DDR_A_MA11: length 60.9
  IN1 w0.076: 138.95,53.68 138.95,54.06 141.29,56.4 142.09,56.4 143.53,57.84 143.53,61.73 v2(142.98,62.28)
  IN1 w0.14: v2(114.68,19.79) 115.1,20.21 115.1,22.24 113.68,23.66 113.68,27.81 131.15,45.27 133.57,45.27 137.15,48.86 137.15,49.11 136.17,50.09 136.17,50.29 138.95,53.08 138.95,53.68
  BOTTOM w0.076: UC1.AW41 143.28,62.58 v2(142.98,62.28)
  BOTTOM w0.152: v2(114.68,19.79) 115.28,19.19 JDIMM1.84
DDR_A_MA12: length 61.1
  IN1 w0.076: 143.71,57.76 142.05,56.09 141.26,56.09 139.34,54.17
  IN1 w0.089: v2(143,63.58) 143.71,62.86 143.71,57.76
  IN1 w0.14: v2(114.2,24.86) 114.2,27.73 131.31,44.84 133.73,44.84 137.85,48.97 137.85,49.2 136.86,50.19 136.86,50.39 137.06,50.59 137.25,50.59 138.24,49.61 138.43,49.61 138.63,49.8 138.63,50 137.65,50.98 137.65,51.18 137.85,51.38 138.04,51.38 138.56,50.87 138.75,50.87 138.95,51.06 138.95,51.26 138.44,51.77 138.44,51.97 139.34,52.87 139.34,54.17
  BOTTOM w0.076: UC1.AU41 143.14,63.58 v2(143,63.58)
  BOTTOM w0.152: JDIMM1.83 114.98,25.64 114.6,25.26 v2(114.2,24.86)
DDR_A_MA13: length 62.5
  IN1 w0.076: v2(147.02,64.71) 147.42,64.31 147.49,64.31 148.91,62.89 148.91,54.53 148.44,54.06
  IN1 w0.14: 148.44,54.06 148.44,44.02 143.5,39.08 143.31,39.08 142.95,39.44 142.75,39.44 132.74,29.43 132.74,27.27 132.01,26.53 127.54,26.53 125.64,24.63 125.64,23.04 125.62,23.02 125.62,22.26 v2(125.18,21.82)
  BOTTOM w0.076: v2(147.02,64.71) 147.35,65.04 UC1.AR35
  BOTTOM w0.152: v2(125.18,21.82) 125.78,22.41 JDIMM1.119
DDR_A_MA14: length 61.3
  IN1 w0.076: v2(143,60.27) 143.35,59.92 143.35,59.29 142.79,58.73 142.79,58.39 139.79,55.4
  IN1 w0.14: v2(114.68,21.31) 113.13,22.85 113.13,27.85 131.01,45.73 133.34,45.73 133.39,45.78 133.39,45.78 136.44,48.83 136.44,49.03 135.47,50 135.47,50.19 137.71,52.43 137.71,53.67 137.97,53.93 138.33,53.93 139.79,55.4
  BOTTOM w0.076: v2(143,60.27) 142.59,60.68 142.59,61.26 142.28,61.58 142.28,62.93 UC1.AV42
  BOTTOM w0.152: v2(114.68,21.31) 114.08,20.71 JDIMM1.80
DDR_A_MA15: length 61.8
  IN1 w0.14: v2(112.28,21.31) 112.72,21.75 112.72,28.03 130.88,46.19 133.2,46.19 133.46,46.44 135.7,48.68 135.7,48.88 134.73,49.85 134.73,50.05 137.29,52.6 137.29,53.77 137.86,54.34 138.14,54.34 139.72,55.92 139.88,55.92 142.56,58.6 142.56,59.19 v2(143,59.62)
  BOTTOM w0.076: v2(143,59.62) 142.64,59.98 142.42,60.2 142.42,61.12 142.11,61.44 142.11,63.4 142.38,63.67 142.38,63.73 UC1.AU42
  BOTTOM w0.152: v2(112.28,21.31) 113.48,20.11 JDIMM1.78
DDR_A_RAS#: length 60.4
  IN1 w0.076: v2(147.72,61.58) 148.4,60.9 148.4,56.17 147.19,54.96 147.19,54.06
  IN1 w0.14: 147.19,54.06 147.19,45.66 131.28,29.76 130.93,29.76 129.53,31.15 129.33,31.15 129.07,30.89 129.07,30.69 129.76,30 129.76,29.81 129.56,29.61 129.36,29.61 128.66,30.31 128.46,30.31 126.42,28.27 126.42,27.3 124.31,25.2 124.31,23.6 124.36,23.55 124.36,23.33 124.43,23.27 124.43,20.08 124.13,19.79 v2(123.68,19.79)
  BOTTOM w0.076: v2(147.72,61.58) 148.07,61.93 UC1.AY34
  BOTTOM w0.152: JDIMM1.110 123.08,19.19 v2(123.68,19.79)
DDR_A_WE#: length 61.9
  IN1 w0.076: 147.61,54.06 147.61,55.1 148.58,56.07 148.58,61.41 v2(147.71,62.28)
  IN1 w0.14: v2(125.18,23.34) 124.73,23.79 124.73,25.02 127.23,27.52 127.65,27.52 127.84,27.71 127.84,28.37 127.61,28.6 127.61,28.8 128.43,29.62 128.63,29.62 128.87,29.37 128.87,29.17 128.46,28.76 128.46,27.58 128.6,27.44 128.88,27.44 129.02,27.58 129.02,28.03 129.3,28.31 129.71,28.31 130.08,27.94 130.28,27.94 130.54,28.2 130.54,28.39 129.86,29.07 129.86,29.27 130.08,29.49 130.28,29.49 130.83,28.94 131.06,28.94 147.61,45.49 147.61,54.06
  BOTTOM w0.076: UC1.AW34 148.01,62.58 v2(147.71,62.28)
  BOTTOM w0.152: JDIMM1.113 123.98,24.54 v2(125.18,23.34)
DDR_B_BS0: length 102.2
  IN3 w0.076: 146.52,57.54 146.52,58.22 146.84,58.54 146.84,63.83 146.67,64.01 146.67,66.96 v2(147.02,67.31)
  IN3 w0.152: v2(197.94,24.86) 197.94,25.07 195.52,27.49 195.52,28.05 193.84,29.73 192.73,29.73 192.23,30.23 192.23,30.44 192.61,30.82 192.61,31.04 192.39,31.25 192.18,31.25 191.8,30.87 191.58,30.87 191.37,31.09 191.37,31.3 192.4,32.33 192.4,32.52 192.15,32.77 191.96,32.77 190.93,31.74 190.72,31.74 190.5,31.95 190.5,32.17 191.46,33.12 191.46,33.34 191.24,33.55 191.03,33.55 190.07,32.6 189.86,32.6 189.64,32.81 189.64,33.03 189.98,33.37 189.98,33.59 189.77,33.79 189.13,33.79 188.98,33.64 188.98,32.6 188.83,32.45 188.52,32.45 188.37,32.6 188.37,33.64 188.22,33.79 187.91,33.79 187.76,33.64 187.76,32.6 187.61,32.45 187.3,32.45 187.15,32.6 187.15,33.64 187,33.79 186.69,33.79 186.54,33.64 186.54,32.6 186.39,32.45 186.08,32.45 185.93,32.6 185.93,33.64 185.78,33.79 185.47,33.79 185.32,33.64 185.32,32.6 185.17,32.45 184.86,32.45 184.71,32.6 184.71,33.64 184.56,33.79 159.53,33.79 146.29,47.03 146.29,56.58 146.52,56.81 146.52,57.54
  BOTTOM w0.076: v2(147.02,67.31) 147.35,67.64 UC1.AL35
  BOTTOM w0.152: JDIMM2.109 197.28,25.3 197.72,24.86 v2(197.94,24.86)
DDR_B_BS1: length 102.4
  IN3 w0.076: v2(146.07,66.81) 146.45,66.43 146.45,63.95 146.68,63.72 146.68,58.8 145.67,57.79
  IN3 w0.152: 145.67,57.79 145.67,47.04 159.35,33.36 177.85,33.36 178,33.21 178,32.09 178.15,31.94 178.46,31.94 178.61,32.09 178.61,33.21 178.76,33.36 179.07,33.36 179.22,33.21 179.22,32.09 179.37,31.94 179.68,31.94 179.83,32.09 179.83,33.21 179.98,33.36 180.29,33.36 180.44,33.21 180.44,32.09 180.59,31.94 180.9,31.94 181.05,32.09 181.05,33.21 181.2,33.36 181.51,33.36 181.66,33.21 181.66,32.09 181.81,31.94 182.12,31.94 182.27,32.09 182.27,33.21 182.42,33.36 182.73,33.36 182.88,33.21 182.88,32.09 183.03,31.94 183.36,31.94 183.52,32.09 183.52,33.21 183.67,33.36 183.97,33.36 184.13,33.21 184.13,32.09 184.28,31.94 189.88,31.94 192.59,29.23 193.73,29.23 194.61,28.35 194.61,27.74 197.08,25.27 197.08,23.68 196.45,23.05 196.45,20.86 v2(196.88,20.43)
  BOTTOM w0.076: v2(146.07,66.81) 146.24,66.99 UC1.AM36
  BOTTOM w0.152: v2(196.88,20.43) 196.98,20.34 JDIMM2.108
DDR_B_BS2: length 97.2
  IN3 w0.076: v2(138.27,63.55) 138.99,63.55 139.51,64.07 140.25,64.07 140.45,63.87 140.45,63.38 140.28,63.22 139.68,63.22 139.23,62.77 139.23,60.45 138.02,59.23 138.02,57.95 137.62,57.54
  IN3 w0.152: 137.62,57.54 137.62,56.84 135.95,55.17 135.95,44.5 141.42,39.03 141.42,38.66 141.42,38.03 162.39,17.06 183.74,17.06 187.14,20.46 187.14,21.2 186.99,21.35 186.07,21.35 185.87,21.55 185.87,22.03 v2(186.48,22.64)
  BOTTOM w0.076: UC1.AU49 138.39,63.55 v2(138.27,63.55)
  BOTTOM w0.152: v2(186.48,22.64) 187.21,23.38 187.21,24.12 188.28,25.18 JDIMM2.79
DDR_B_CAS#: length 103.4
  IN3 w0.076: v2(147.97,66.73) 148.33,66.37 148.33,57.64 148.23,57.54
  IN3 w0.152: v2(199.53,24.86) 199.53,25.97 199.37,26.12 198.92,26.12 198.77,26.28 198.77,26.58 198.92,26.73 199.37,26.73 199.53,26.88 199.53,27.16 199.37,27.32 197.98,27.32 197.83,27.47 197.83,27.82 197.98,27.98 198.76,27.98 199.13,28.35 199.13,28.81 198.92,29.03 198.7,29.03 198.32,28.65 198.11,28.65 197.89,28.86 197.89,29.08 198.28,29.47 198.28,29.68 198.07,29.9 197.85,29.9 197.24,29.29 197.03,29.29 196.81,29.51 196.81,29.72 197.42,30.33 197.42,30.55 197.2,30.76 196.99,30.76 196.11,29.89 195.9,29.89 195.68,30.1 195.68,30.32 196.58,31.22 196.58,31.4 196.34,31.65 196.15,31.65 195.24,30.74 195.02,30.74 194.81,30.95 194.81,31.17 195.72,32.08 195.72,32.27 195.47,32.51 195.29,32.51 194.39,31.61 194.17,31.61 193.96,31.82 193.96,32.05 194.83,32.92 194.83,33.14 194.62,33.35 194.4,33.35 194.01,32.96 193.79,32.96 193.58,33.17 193.58,33.39 194,33.81 194,33.99 193.75,34.24 193.56,34.24 193.15,33.82 192.93,33.82 192.72,34.04 192.72,34.25 193.03,34.57 193.03,34.78 192.81,35 192.6,35 192.28,34.68 192.07,34.68 191.66,35.09 160.07,35.09 147.59,47.57 147.59,55.73 148.23,56.37 148.23,57.54
  BOTTOM w0.076: UC1.AM33 148.24,66.99 v2(147.97,66.73)
  BOTTOM w0.152: JDIMM2.115 199.08,25.31 v2(199.53,24.86)
DDR_B_D0: length 87.3
  IN3 w0.076: 150.36,52.51 150.36,54.27 150.4,54.31 150.4,56.14 v2(149.82,56.72)
  IN3 w0.102: v2(202.75,21.92) 202.75,21.98 203.49,22.71 203.49,26.27 202.9,26.85 202.9,26.86 202.86,26.9 202.86,29.04 193.57,38.34 160.85,38.34 157.95,41.23 157.95,41.38 158.11,41.54 158.11,41.69 157.97,41.83 157.82,41.83 157.66,41.67 157.52,41.67 157.37,41.81 157.37,41.95 157.61,42.19 157.61,42.33 150.36,49.58 150.36,52.51
  BOTTOM w0.076: v2(149.82,56.72) 149.05,57.48 149.05,60.97 149.24,61.15 149.24,61.8 UC1.AY31
  BOTTOM w0.102: JDIMM2.132 204.18,20.5 v2(202.75,21.92)
DDR_B_D1: length 88.3
  IN3 w0.076: 150.05,53.43 150.18,53.55 150.18,55.69 149.82,56.05 v2(149.82,56.07)
  IN3 w0.102: 150.05,53.43 150.05,49.45 154.7,44.81 154.7,44.66 154.46,44.43 154.46,44.29 154.61,44.14 154.75,44.14 154.99,44.38 155.13,44.38 155.27,44.23 155.27,44.09 155.04,43.85 155.04,43.71 155.18,43.57 155.33,43.57 155.56,43.8 155.7,43.8 155.85,43.66 155.85,43.51 155.61,43.28 155.61,43.14 155.76,42.99 155.9,42.99 156.14,43.23 156.28,43.23 156.42,43.08 156.42,42.94 156.19,42.7 156.19,42.56 156.33,42.42 156.48,42.42 156.57,42.51 156.71,42.51 156.86,42.36 156.86,42.22 156.76,42.13 156.76,41.99 160.72,38.03 193.44,38.03 202.48,28.99 202.48,26.64 203.15,25.97 203.15,23.84 v2(202.75,23.45)
  BOTTOM w0.076: v2(149.82,56.07) 148.89,57 148.89,61.03 149.07,61.22 149.07,62 149.17,62.17 149.37,62.37 UC1.AW31
  BOTTOM w0.102: v2(202.75,23.45) 203.61,23.45 203.88,23.71 JDIMM2.131
DDR_B_D2: length 87.5
  IN3 w0.084: 151.86,54.06 151.86,55.65 v2(151.45,56.07)
  IN3 w0.102: v2(205.45,19.81) 206.14,20.5 206.14,24.78 205.53,25.38 205.53,28.15 204.92,28.76 204.92,29.86 194.41,40.37 162.45,40.37 155.86,46.96 155.86,47.35 155.72,47.49 155.57,47.49 155.52,47.44 155.38,47.44 155.24,47.58 155.24,47.73 155.34,47.83 155.34,47.97 155.2,48.12 155.05,48.12 154.95,48.01 154.81,48.01 154.66,48.16 154.66,48.3 154.77,48.41 154.77,48.55 152.66,50.66 152.66,52.86 151.86,53.65 151.86,54.06
  BOTTOM w0.076: v2(151.45,56.07) 150.6,56.91 150.6,60.8 150.72,60.92 UC1.AY29
  BOTTOM w0.102: v2(205.45,19.81) 206.17,19.81 206.58,19.41 JDIMM2.140
DDR_B_D3: length 88.5
  IN3 w0.084: 152.12,54.06 152.12,56.04 151.45,56.71 v2(151.45,56.72)
  IN3 w0.102: v2(207.92,23.34) 207.29,23.98 207.29,24.27 205.84,25.72 205.84,28.28 205.23,28.89 205.23,29.99 194.54,40.68 162.57,40.68 160.44,42.81 160.44,42.96 160.49,43 160.49,43.15 160.34,43.29 160.2,43.29 160.15,43.24 160.01,43.24 159.87,43.39 159.87,43.53 159.97,43.63 159.97,43.78 159.82,43.92 159.68,43.92 159.58,43.82 159.43,43.82 159.29,43.96 159.29,44.11 159.39,44.21 159.39,44.35 159.14,44.6 159,44.6 158.9,44.51 158.76,44.51 158.61,44.65 158.61,44.79 158.71,44.89 158.71,45.04 158.57,45.18 158.42,45.18 158.32,45.08 158.18,45.08 158.04,45.22 158.04,45.37 158.14,45.47 158.14,45.61 157.99,45.75 157.85,45.75 157.75,45.66 157.61,45.66 157.46,45.8 157.46,45.94 157.56,46.04 157.56,46.19 157.42,46.33 157.27,46.33 157.17,46.23 157.03,46.23 156.89,46.37 156.89,46.52 156.99,46.62 156.99,46.76 156.84,46.9 156.7,46.9 156.6,46.81 156.46,46.81 156.31,46.95 156.31,47.09 156.41,47.19 156.41,47.34 152.96,50.78 152.96,52.98 152.12,53.83 152.12,54.06
  BOTTOM w0.076: UC1.AW29 150.72,62.34 151.01,62.05 151.01,61.8 150.88,61.68 150.88,60.82 150.77,60.71 150.77,57.39 v2(151.45,56.72)
  BOTTOM w0.102: v2(207.92,23.34) 206.88,24.38 JDIMM2.141
DDR_B_D4: length 88.7
  IN3 w0.076: v2(149.82,55.42) 149.47,55.06 149.47,54.27 149.75,53.99
  IN3 w0.102: v2(202.75,24.97) 202.75,25.67 202.12,26.3 202.12,28.92 193.32,37.73 160.49,37.73 153.92,44.29 153.92,44.44 154.05,44.57 154.05,44.71 153.9,44.85 153.76,44.85 153.63,44.72 153.49,44.72 153.34,44.87 153.34,45.01 153.63,45.3 153.63,45.44 153.49,45.59 153.34,45.59 153.06,45.3 152.91,45.3 152.77,45.44 152.77,45.59 153.06,45.87 153.06,46.02 152.91,46.16 152.77,46.16 152.48,45.87 152.34,45.87 152.19,46.02 152.19,46.16 152.48,46.45 152.48,46.59 152.34,46.74 152.19,46.74 151.91,46.45 151.76,46.45 151.62,46.59 151.62,46.74 151.91,47.03 151.91,47.17 151.76,47.31 151.62,47.31 151.33,47.03 151.19,47.03 151.04,47.17 151.04,47.31 151.33,47.6 151.33,47.74 151.19,47.89 151.04,47.89 150.76,47.6 150.61,47.6 150.47,47.74 150.47,47.89 150.76,48.18 150.76,48.32 150.61,48.46 150.47,48.46 150.18,48.18 150.04,48.18 149.89,48.32 149.89,48.46 150.18,48.75 150.18,48.89 149.75,49.33 149.75,53.99
  BOTTOM w0.076: v2(149.82,55.42) 148.72,56.51 148.72,61.1 148.91,61.29 148.91,62.04 148.93,62.08 148.98,62.18 148.98,62.84 UC1.AV31
  BOTTOM w0.102: v2(202.75,24.97) 203.28,25.5 JDIMM2.129
DDR_B_D5: length 89.4
  IN3 w0.076: v2(149.82,58.02) 150.65,57.18 150.65,54.16 150.66,54.17 150.66,54.14
  IN3 w0.102: 150.66,54.14 150.66,49.71 158.81,41.56 158.81,41.41 158.58,41.18 158.58,41.03 158.72,40.89 158.87,40.89 158.99,41.01 159.36,41.01 161.73,38.64 193.7,38.64 203.17,29.17 203.17,27.03 203.8,26.39 203.8,21.5 202.75,20.45 v2(202.75,20.4)
  BOTTOM w0.076: v2(149.82,58.02) 150.25,58.44 150.25,60.96 150.36,61.08 150.36,61.49 150.26,61.59 150.26,62.03 150.28,62.08 150.29,62.08 150.33,62.19 150.33,62.32 150.26,62.47 150.26,62.68 150.28,62.73 150.33,62.82 150.33,62.83 150.33,63.02 150.32,63.04 150.32,63.42 150.33,63.43 150.33,63.67 150.13,63.88 UC1.AU31
  BOTTOM w0.102: v2(202.75,20.4) 203.58,19.58 JDIMM2.130
DDR_B_D6: length 89
  IN3 w0.102: v2(151.45,54.77) 151.45,53.48 152.19,52.74 152.19,50.2 152.44,49.95 152.58,49.95 152.69,50.05 152.83,50.05 152.97,49.91 152.97,49.77 152.87,49.66 152.87,49.52 153.01,49.37 153.16,49.37 153.26,49.48 153.41,49.48 153.55,49.33 153.55,49.19 153.45,49.09 153.45,48.94 153.59,48.8 153.73,48.8 153.84,48.9 153.98,48.9 154.12,48.76 154.12,48.26 162.32,40.07 194.29,40.07 204.62,29.74 204.62,28.63 205.23,28.02 205.23,25.25 205.83,24.64 205.83,21.47 v2(205.45,21.08)
  BOTTOM w0.076: UC1.AV29 150.53,63.14 150.53,62.8 150.48,62.75 150.43,62.64 150.43,62.51 150.43,62.49 150.47,62.41 150.5,62.35 150.5,62.15 150.43,61.99 150.43,61.66 150.53,61.56 150.53,60.97 150.43,60.86 150.43,55.79 v2(151.45,54.77)
  BOTTOM w0.102: v2(205.45,21.08) 207.18,19.36 JDIMM2.142
DDR_B_D7: length 89.6
  IN3 w0.076: 152.39,53.82 152.39,56.42 v2(151.45,57.37)
  IN3 w0.102: 152.39,53.82 153.33,52.89 153.33,50.85 161.07,43.11 161.07,42.97 160.96,42.86 160.96,42.72 161.11,42.58 161.25,42.58 161.35,42.68 161.5,42.68 161.64,42.54 161.64,42.39 161.54,42.29 161.54,42.15 161.68,42 161.83,42 161.93,42.1 162.07,42.1 162.22,41.96 162.22,41.82 162.11,41.71 162.11,41.57 162.26,41.43 162.4,41.43 162.5,41.53 162.65,41.53 163.2,40.98 194.67,40.98 205.55,30.1 205.55,28.99 206.01,28.54 206.8,28.54 206.9,28.43 206.9,28.23 206.8,28.13 206.25,28.13 206.14,28.03 206.14,27.28 206.25,27.18 206.8,27.18 206.9,27.08 206.9,26.88 206.8,26.77 206.25,26.77 206.14,26.67 206.14,26.48 206.25,26.38 206.77,26.38 206.87,26.28 206.87,26.05 206.77,25.95 206.57,25.95 206.47,25.84 206.47,25.64 206.57,25.54 206.77,25.54 206.87,25.44 206.87,25.11 207.12,24.86 v2(207.92,24.86)
  BOTTOM w0.076: v2(151.45,57.37) 150.94,57.88 150.94,60.63 151.05,60.74 151.05,61.61 151.17,61.74 151.17,62.12 151.01,62.28 151.01,62.7 150.88,62.82 150.88,63.09 150.9,63.11 150.9,63.35 150.61,63.64 UC1.AU29
  BOTTOM w0.102: JDIMM2.143 207.48,25.26 207.24,25.02 207.24,24.64 207.39,24.5 207.55,24.5 v2(207.92,24.86)
DDR_B_D8: length 55.4
  IN1 w0.076: 150.97,54.7 150.97,54.83 151.09,54.95 151.09,58.31 v2(151.45,58.67)
  IN1 w0.097: 150.97,54.7 150.97,49.33 161.01,39.29 161.01,33.46 161.11,33.37 161.52,33.37 161.64,33.25 161.64,33.09 161.52,32.98 161.11,32.98 161.01,32.89 161.01,32.69 161.11,32.6 161.9,32.6 161.99,32.5 161.99,32.31 161.9,32.21 161.11,32.21 161.01,32.11 161.01,31.92 161.11,31.82 161.9,31.82 161.99,31.73 161.99,31.53 161.9,31.44 161.11,31.44 161.01,31.34 161.01,31.15 161.11,31.05 161.9,31.05 162.02,30.94 162.02,30.78 161.9,30.67 161.11,30.67 161.01,30.57 161.01,30.38 161.11,30.28 161.95,30.28 162.07,30.16 162.07,29.29 161.61,28.84 161.61,27.11 163.97,24.75 163.97,23.79 v2(164.42,23.34)
  BOTTOM w0.076: v2(151.45,58.67) 152.01,59.23 152.01,60.34 151.56,60.79 151.56,61.42 151.67,61.53 151.67,61.8 UC1.AY27
  BOTTOM w0.102: v2(164.42,23.34) 163.68,24.08 JDIMM2.5
DDR_B_D9: length 56.2
  IN1 w0.076: 150.61,54.7 150.61,58.48 v2(151.45,59.32)
  IN1 w0.097: 150.61,54.7 150.61,49.24 160.67,39.18 160.67,25.11 162.33,23.46 163.85,23.46 163.95,23.36 163.95,23.18 163.85,23.07 162.4,23.07 162.3,22.98 162.3,22.74 162.4,22.64 163.85,22.64 163.95,22.54 163.95,22.34 163.85,22.24 162.88,22.24 162.78,22.14 v2(162.78,21.66)
  BOTTOM w0.076: v2(151.45,59.32) 151.84,59.71 151.84,60.27 151.39,60.72 151.39,61.48 151.51,61.6 151.51,62.05 151.8,62.34 UC1.AW27
  BOTTOM w0.102: v2(162.78,21.66) 163.98,20.46 JDIMM2.6
DDR_B_D10: length 55.6
  IN1 w0.076: v2(153.12,55.86) 152.62,55.86 152.47,55.71 152.47,53.81
  IN1 w0.097: 152.47,53.81 152.85,53.43 152.85,50.2 164.63,38.41 164.63,37.93 164.73,37.83 165.21,37.83 165.32,37.72 165.32,37.56 165.21,37.45 164.73,37.45 164.63,37.35 164.63,37.16 164.73,37.06 165.48,37.06 165.57,36.96 165.57,36.77 165.48,36.67 164.73,36.67 164.63,36.58 164.63,36.38 164.73,36.29 165.48,36.29 165.57,36.19 165.57,36 165.48,35.9 164.73,35.9 164.63,35.81 164.63,35.61 164.73,35.52 165.48,35.52 165.57,35.42 165.57,35.23 165.48,35.13 164.73,35.13 164.63,35.03 164.63,34.84 164.73,34.74 165.48,34.74 165.57,34.65 165.57,34.45 165.48,34.36 164.73,34.36 164.63,34.26 164.63,34.07 164.73,33.97 165.45,33.97 165.57,33.84 165.57,30.06 163.87,28.36 163.87,27.44 165.95,25.36 v2(165.95,24.86)
  BOTTOM w0.076: UC1.AY25 153.02,61.8 153.02,61.02 153.45,60.59 153.46,60.59 153.92,60.13 153.92,56.64 153.15,55.86 v2(153.12,55.86)
  BOTTOM w0.102: v2(165.95,24.86) 166.25,24.86 166.68,25.29 JDIMM2.15
DDR_B_D11: length 56.7
  IN1 w0.076: 152.72,53.91 152.72,55.11 152.85,55.24 v2(153.12,55.24)
  IN1 w0.097: 152.72,53.91 153.18,53.45 153.18,50.31 166.28,37.2 166.28,36.93 166.19,36.83 166.03,36.83 165.93,36.74 165.93,36.55 166.03,36.45 166.19,36.45 166.28,36.35 166.28,36.16 166.19,36.06 166.03,36.06 165.93,35.97 165.93,35.77 166.03,35.68 166.19,35.68 166.28,35.58 166.28,35.39 166.19,35.29 166.03,35.29 165.93,35.19 165.93,35 166.03,34.9 166.19,34.9 166.28,34.81 166.28,34.61 166.19,34.52 166.03,34.52 165.93,34.42 165.93,34.23 166.03,34.13 166.19,34.13 166.28,34.04 166.28,33.84 166.19,33.75 166.03,33.75 165.93,33.65 165.93,33.46 166.03,33.36 166.19,33.36 166.28,33.26 166.28,33.07 166.19,32.97 166.03,32.97 165.93,32.88 165.93,32.68 166.03,32.59 166.19,32.59 166.28,32.49 166.28,32.3 166.19,32.2 166.03,32.2 165.93,32.11 165.93,31.91 166.03,31.82 166.45,31.82 166.56,31.7 166.56,31.54 166.45,31.43 166.03,31.43 165.93,31.33 165.93,31.14 166.03,31.04 166.4,31.04 166.51,30.93 166.51,30.77 166.4,30.66 166.03,30.66 165.93,30.56 165.93,30.37 166.03,30.27 166.19,30.27 166.28,30.17 166.28,29.91 164.71,28.33 164.71,27.72 166.39,26.05 166.39,23.77 v2(165.95,23.34)
  BOTTOM w0.076: v2(153.12,55.24) 154.09,56.2 154.09,60.2 153.53,60.76 153.52,60.76 153.19,61.09 153.19,61.55 153.44,61.8 153.44,61.99 153.39,62.09 153.39,62.1 153.37,62.15 153.37,62.36 UC1.AW25
  BOTTOM w0.102: v2(165.95,23.34) 166.59,23.98 166.59,24.51 167.28,25.19 JDIMM2.17
DDR_B_D12: length 56.9
  IN1 w0.076: v2(151.45,59.97) 150.28,58.8 150.28,54.7
  IN1 w0.097: 150.28,54.7 150.28,49.13 160.34,39.07 160.34,38.78 160.24,38.69 160.03,38.69 159.93,38.59 159.93,38.4 160.03,38.3 160.24,38.3 160.34,38.2 160.34,38.01 160.24,37.92 160.03,37.92 159.93,37.82 159.93,37.63 160.03,37.53 160.24,37.53 160.34,37.43 160.34,37.24 160.24,37.14 160.03,37.14 159.93,37.05 159.93,36.85 160.03,36.76 160.24,36.76 160.34,36.66 160.34,36.47 160.24,36.37 160.03,36.37 159.93,36.27 159.93,36.08 160.03,35.98 160.24,35.98 160.34,35.89 160.34,35.7 160.24,35.6 160.03,35.6 159.93,35.5 159.93,35.31 160.03,35.21 160.24,35.21 160.34,35.12 160.34,34.92 160.24,34.83 160.03,34.83 159.93,34.73 159.93,34.54 160.03,34.44 160.24,34.44 160.34,34.34 160.34,34.15 160.24,34.05 160.03,34.05 159.93,33.96 159.93,33.76 160.03,33.67 160.24,33.67 160.34,33.57 160.34,33.38 160.24,33.28 160.03,33.28 159.93,33.19 159.93,32.99 160.03,32.9 160.24,32.9 160.34,32.8 160.34,32.61 160.24,32.51 160.03,32.51 159.93,32.41 159.93,32.22 160.03,32.12 160.24,32.12 160.34,32.03 160.34,25.01 161.99,23.35 161.99,20.69 162.29,20.39 v2(162.78,20.39)
  BOTTOM w0.076: v2(151.45,59.97) 151.45,60.4 151.21,60.63 151.21,61.54 151.34,61.67 151.34,62.12 151.51,62.29 151.51,62.7 151.9,63.1 UC1.AV27
  BOTTOM w0.102: JDIMM2.4 163.38,19.79 v2(162.78,20.39)
DDR_B_D13: length 57.7
  IN1 w0.076: 153.51,58.53 153.51,54.65 153.81,54.34 153.81,54.12
  IN1 w0.084: v2(153.15,58.89) 153.51,58.53
  IN1 w0.097: v2(168.18,21.88) 167.68,21.88 167.15,22.41 167.15,26.43 165.95,27.62 165.95,28.26 167.37,29.68 167.37,34.31 167.47,34.41 167.85,34.41 167.96,34.52 167.96,34.68 167.85,34.8 167.47,34.8 167.37,34.89 167.37,35.09 167.47,35.18 167.85,35.18 167.96,35.3 167.96,35.46 167.85,35.57 167.47,35.57 167.37,35.67 167.37,35.86 167.47,35.95 167.87,35.95 167.99,36.07 167.99,36.23 167.87,36.34 167.47,36.34 167.37,36.44 167.37,37 153.86,50.51 153.86,54.06 153.81,54.12
  BOTTOM w0.076: v2(153.15,58.89) 152.69,59.34 152.69,62.03 152.76,62.19 152.76,62.32 152.69,62.47 152.69,62.68 152.72,62.73 152.76,62.82 152.76,62.83 152.76,63.67 152.56,63.88 UC1.AU27
  BOTTOM w0.102: v2(168.18,21.88) 167.3,21 167.3,20.27 166.98,19.95 JDIMM2.16
DDR_B_D14: length 57.2
  IN1 w0.076: 151.4,54.06 151.4,54.11 151.84,54.56 151.84,58.23 v2(153.15,59.54)
  IN1 w0.097: 151.4,54.06 151.4,49.34 162.37,38.37 162.37,38.06 162.25,37.94 161.55,37.94 161.46,37.85 161.46,37.65 161.55,37.56 162.3,37.56 162.4,37.46 162.4,37.27 162.3,37.17 161.55,37.17 161.46,37.07 161.46,36.88 161.55,36.78 162.3,36.78 162.4,36.69 162.4,36.5 162.3,36.4 161.55,36.4 161.46,36.3 161.46,36.11 161.55,36.01 162.3,36.01 162.4,35.92 162.4,35.72 162.3,35.63 161.55,35.63 161.46,35.53 161.46,35.34 161.55,35.24 162.3,35.24 162.4,35.14 162.4,34.95 162.3,34.85 161.55,34.85 161.46,34.76 161.46,34.56 161.55,34.47 162.3,34.47 162.4,34.37 162.4,34.18 162.3,34.08 161.55,34.08 161.46,33.99 161.46,33.79 161.55,33.7 162.3,33.7 162.4,33.6 162.4,33.41 162.3,33.31 162.08,33.31 161.97,33.2 161.97,33.04 162.08,32.92 162.3,32.92 162.4,32.83 162.4,29.12 162.04,28.76 162.04,27.24 v2(164.42,24.86)
  BOTTOM w0.076: UC1.AV25 153.15,62.99 152.91,62.75 152.86,62.64 152.86,62.51 152.87,62.49 152.91,62.41 152.93,62.35 152.93,62.15 152.86,61.99 152.86,59.83 v2(153.15,59.54)
  BOTTOM w0.102: JDIMM2.7 164.28,25.01 v2(164.42,24.86)
DDR_B_D15: length 58.2
  IN1 w0.097: v2(153.13,54.65) 153.05,54.57 153.05,54.01 153.53,53.53 153.53,50.4 167.02,36.91 167.02,36.73 166.92,36.63 166.71,36.63 166.61,36.53 166.61,36.34 166.71,36.24 166.92,36.24 167.02,36.15 167.02,35.95 166.92,35.86 166.71,35.86 166.61,35.76 166.61,35.57 166.71,35.47 166.92,35.47 167.02,35.37 167.02,35.18 166.92,35.08 166.71,35.08 166.61,34.99 166.61,34.8 166.71,34.7 166.92,34.7 167.02,34.6 167.02,34.41 166.92,34.31 166.71,34.31 166.61,34.22 166.61,34.02 166.71,33.93 166.92,33.93 167.02,33.83 167.02,33.64 166.92,33.54 166.71,33.54 166.61,33.44 166.61,33.25 166.71,33.15 166.92,33.15 167.02,33.06 167.02,32.86 166.92,32.77 166.83,32.77 166.72,32.66 166.72,32.5 166.83,32.38 166.92,32.38 167.02,32.29 167.02,30.16 165.07,28.21 165.07,27.85 166.77,26.15 166.77,22.02 v2(168.18,20.61)
  BOTTOM w0.076: v2(153.13,54.65) 154.25,55.77 154.25,60.27 153.6,60.92 153.58,60.92 153.35,61.15 153.35,61.48 153.47,61.59 153.61,61.73 153.61,62.03 153.58,62.08 153.53,62.19 153.53,63.49 UC1.AU25
  BOTTOM w0.102: JDIMM2.18 167.58,20.01 v2(168.18,20.61)
DDR_B_D16: length 95.2
  IN3 w0.076: 152.75,59.49 149.88,62.36 149.88,66.14 v2(150.4,66.66)
  IN3 w0.084: 152.75,59.49 152.75,54.19 152.87,54.06
  IN3 w0.102: 152.87,54.06 154.14,52.8 154.14,51.19 163.08,42.25 167.09,42.25 167.19,42.15 167.19,41.98 167.29,41.87 167.49,41.87 167.59,41.98 167.59,42.15 167.7,42.25 167.9,42.25 168,42.15 168,41.98 168.1,41.87 168.31,41.87 168.41,41.98 168.41,42.15 168.51,42.25 168.71,42.25 168.81,42.15 168.81,41.98 168.92,41.87 169.12,41.87 169.22,41.98 169.22,42.15 169.32,42.25 169.52,42.25 169.63,42.15 169.63,41.98 169.73,41.87 169.93,41.87 170.03,41.98 170.03,42.15 170.13,42.25 170.34,42.25 170.44,42.15 170.44,41.98 170.54,41.87 170.74,41.87 170.85,41.98 170.85,42.15 170.95,42.25 171.15,42.25 171.25,42.15 171.25,41.98 171.35,41.87 194.93,41.87 207.71,29.09 207.71,26.29 208.73,25.27 208.73,21.1 v2(207.92,20.29)
  BOTTOM w0.076: UC1.AM29 150.73,66.99 v2(150.4,66.66)
  BOTTOM w0.102: v2(207.92,20.29) 208.38,19.84 JDIMM2.146
DDR_B_D17: length 96.8
  IN3 w0.076: 152.56,59.43 149.72,62.27 149.72,67.28 v2(150.4,67.96)
  IN3 w0.084: 152.75,53.86 152.56,54.05 152.56,59.43
  IN3 w0.102: 152.75,53.86 153.83,52.77 153.83,51.06 162.95,41.95 163.43,41.95 163.53,41.85 163.53,41.59 163.63,41.49 163.84,41.49 163.94,41.59 163.94,41.85 164.04,41.95 164.24,41.95 164.34,41.85 164.34,41.59 164.45,41.49 164.65,41.49 164.75,41.59 164.75,41.85 164.85,41.95 165.06,41.95 165.16,41.85 165.16,41.59 165.26,41.49 165.46,41.49 165.56,41.59 165.56,41.85 165.67,41.95 165.87,41.95 165.97,41.85 165.97,41.59 166.07,41.49 166.27,41.49 166.38,41.59 166.38,41.85 166.48,41.95 166.68,41.95 166.78,41.85 166.78,41.59 166.88,41.49 194.88,41.49 207.41,28.96 207.41,26.17 208.43,25.14 208.43,22.32 v2(207.92,21.82)
  BOTTOM w0.076: v2(150.4,67.96) 150.73,68.29 UC1.AK29
  BOTTOM w0.102: v2(207.92,21.82) 208.98,20.76 JDIMM2.148
DDR_B_D18: length 95.6
  IN3 w0.076: v2(151.34,67.31) 151.83,66.82 151.83,66.2 151.91,66.13 151.91,64.34 154.66,61.59 154.66,55.13 156.81,52.98 156.81,52.92
  IN3 w0.102: v2(213.02,19.72) 212.33,20.41 212.33,27.02 211.82,27.53 211.82,29.65 204.98,36.49 204.84,36.49 204.53,36.19 204.39,36.19 204.25,36.33 204.25,36.48 204.55,36.78 204.55,36.93 204.4,37.07 204.26,37.07 203.96,36.77 203.81,36.77 195.62,44.96 164.11,44.96 156.81,52.26 156.81,52.92
  BOTTOM w0.076: UC1.AL28 151.67,67.64 v2(151.34,67.31)
  BOTTOM w0.102: v2(213.02,19.72) 212.58,19.28 JDIMM2.160
DDR_B_D19: length 96
  IN3 w0.076: 156.86,53.25 155.95,54.16 154.83,55.28 154.83,61.8 152.69,63.94 152.69,67.44 v2(152.18,67.95)
  IN3 w0.102: 156.86,53.25 157.12,53 157.12,52.39 164.23,45.27 195.83,45.27 203.21,37.89 203.35,37.89 203.61,38.15 203.76,38.15 203.9,38 203.9,37.86 203.64,37.6 203.64,37.46 203.79,37.31 203.93,37.31 204.19,37.57 204.33,37.57 212.28,29.62 212.28,27.51 212.64,27.15 212.64,21.37 v2(213.02,20.99)
  BOTTOM w0.076: UC1.AK28 151.84,68.29 v2(152.18,67.95)
  BOTTOM w0.102: v2(213.02,20.99) 211.98,19.95 JDIMM2.158
DDR_B_D20: length 93.2
  IN3 w0.076: 154.75,53.17 154.75,53.74 153.71,54.77 153.71,59.71 152.88,60.54 152.33,60.54 150.4,62.47 v2(150.4,64.71)
  IN3 w0.102: v2(209.79,25.03) 209.79,25.24 208.89,26.15 208.89,28.78 195.18,42.48 187.92,42.48 187.82,42.58 187.82,42.83 187.72,42.93 187.52,42.93 187.42,42.83 187.42,42.58 187.31,42.48 187.11,42.48 187.01,42.58 187.01,42.83 186.91,42.93 186.7,42.93 186.6,42.83 186.6,42.58 186.5,42.48 186.3,42.48 186.2,42.58 186.2,42.83 186.09,42.93 185.89,42.93 185.79,42.83 185.79,42.58 185.69,42.48 185.49,42.48 185.38,42.58 185.38,42.83 185.28,42.93 185.08,42.93 184.98,42.83 184.98,42.58 184.88,42.48 184.57,42.48 184.47,42.58 184.47,42.83 184.37,42.93 184.17,42.93 184.06,42.83 184.06,42.58 183.96,42.48 183.76,42.48 183.66,42.58 183.66,42.83 183.56,42.93 183.35,42.93 183.25,42.83 183.25,42.58 183.15,42.48 182.95,42.48 182.85,42.58 182.85,42.83 182.74,42.93 182.54,42.93 182.44,42.83 182.44,42.58 182.34,42.48 182.13,42.48 182.03,42.58 182.03,42.83 181.93,42.93 181.73,42.93 181.63,42.83 181.63,42.58 181.52,42.48 181.32,42.48 181.22,42.58 181.22,42.83 181.12,42.93 180.92,42.93 180.81,42.83 180.81,42.58 180.71,42.48 180.51,42.48 180.41,42.58 180.41,42.83 180.31,42.93 180.1,42.93 180,42.83 180,42.58 179.9,42.48 179.7,42.48 179.59,42.58 179.59,42.83 179.49,42.93 179.29,42.93 179.19,42.83 179.19,42.58 179.09,42.48 178.88,42.48 178.78,42.58 178.78,42.83 178.68,42.93 178.48,42.93 178.38,42.83 178.38,42.58 178.27,42.48 178.07,42.48 177.97,42.58 177.97,42.83 177.87,42.93 163.26,42.93 154.75,51.44 154.75,53.17
  BOTTOM w0.089: UC1.AR29 150.78,64.84 150.65,64.71 v2(150.4,64.71)
  BOTTOM w0.102: v2(209.79,25.03) 209.28,25.55 JDIMM2.149
DDR_B_D21: length 94.7
  IN3 w0.076: 153.89,54.16 153.89,54.29 153.53,54.65 153.53,59.65 152.95,60.23 152.4,60.23 150.05,62.59 150.05,65.66 v2(150.4,66.01)
  IN3 w0.102: 153.89,54.16 154.44,53.61 154.44,51.32 163.14,42.62 171.69,42.62 171.79,42.52 171.79,42.28 171.89,42.18 172.1,42.18 172.2,42.28 172.2,42.52 172.3,42.62 172.5,42.62 172.61,42.52 172.61,42.28 172.71,42.18 172.91,42.18 173.01,42.28 173.01,42.52 173.11,42.62 173.32,42.62 173.42,42.52 173.42,42.28 173.52,42.18 173.72,42.18 173.82,42.28 173.82,42.52 173.93,42.62 174.13,42.62 174.23,42.52 174.23,42.28 174.33,42.18 174.54,42.18 174.64,42.28 174.64,42.52 174.74,42.62 174.94,42.62 175.04,42.52 175.04,42.28 175.15,42.18 175.35,42.18 175.45,42.28 175.45,42.52 175.55,42.62 175.76,42.62 175.86,42.52 175.86,42.28 175.96,42.18 176.16,42.18 176.26,42.28 176.26,42.52 176.36,42.62 176.57,42.62 176.67,42.52 176.67,42.28 176.77,42.18 176.97,42.18 177.08,42.28 177.08,42.52 177.18,42.62 177.38,42.62 177.48,42.52 177.48,42.28 177.58,42.18 195.05,42.18 208.55,28.68 208.55,25.89 209.08,25.37 209.08,24.48 v2(209.79,23.76)
  BOTTOM w0.076: v2(150.4,66.01) 150.73,66.34 UC1.AN29
  BOTTOM w0.102: JDIMM2.147 208.68,24.04 208.96,23.76 v2(209.79,23.76)
DDR_B_D22: length 93
  IN3 w0.076: v2(151.34,64.71) 151.34,64.25 154.26,61.34 154.26,55.03 156.19,53.09 156.19,52.51
  IN3 w0.102: 156.19,52.51 156.19,52.27 156.19,52.02 163.85,44.36 188.62,44.36 188.72,44.25 188.72,44.15 188.82,44.05 189.02,44.05 189.13,44.15 189.13,44.25 189.23,44.36 189.43,44.36 189.53,44.25 189.53,44.15 189.63,44.05 189.84,44.05 189.94,44.15 189.94,44.25 190.04,44.36 190.24,44.36 190.34,44.25 190.34,44.15 190.45,44.05 190.65,44.05 190.75,44.15 190.75,44.25 190.85,44.36 191.06,44.36 191.16,44.25 191.16,44.15 191.26,44.05 191.46,44.05 191.56,44.15 191.56,44.25 191.67,44.36 191.87,44.36 191.97,44.25 191.97,44.15 192.07,44.05 192.27,44.05 192.38,44.15 192.38,44.25 192.48,44.36 192.68,44.36 192.78,44.25 192.78,44.15 192.88,44.05 193.09,44.05 193.19,44.15 193.19,44.25 193.29,44.36 193.49,44.36 193.6,44.25 193.6,44.15 193.7,44.05 195.67,44.05 207.01,32.7 207.16,32.7 207.37,32.92 207.52,32.92 207.66,32.78 207.66,32.63 207.44,32.42 207.44,32.27 207.59,32.13 207.73,32.13 208.04,32.43 208.18,32.43 208.32,32.29 208.32,32.14 208.02,31.84 208.02,31.7 208.16,31.55 208.31,31.55 208.61,31.86 208.75,31.86 208.9,31.71 208.9,31.57 208.59,31.27 208.59,31.12 208.74,30.98 208.88,30.98 209.19,31.28 209.33,31.28 209.47,31.14 209.47,30.99 209.17,30.69 209.17,30.55 209.31,30.4 209.46,30.4 209.76,30.71 209.9,30.71 210.05,30.56 210.05,30.42 209.74,30.12 209.74,29.97 209.89,29.83 210.03,29.83 210.34,30.13 210.48,30.13 210.62,29.99 210.62,27.53 211.29,26.86 v2(211.29,25.06)
  BOTTOM w0.089: v2(151.34,64.71) 151.34,64.85 151.53,65.04 UC1.AR28
  BOTTOM w0.102: JDIMM2.157 211.68,25.44 v2(211.29,25.06)
DDR_B_D23: length 94.3
  IN3 w0.076: 156.49,52.88 156.49,53.06 154.43,55.12 154.43,61.5 151.74,64.19 151.74,64.97 v2(151.34,65.36)
  IN3 w0.102: 156.49,52.88 156.49,52.15 163.98,44.66 193.92,44.66 194.02,44.56 194.02,44.46 194.12,44.35 195.79,44.35 204.5,35.65 204.64,35.65 204.81,35.81 204.95,35.81 205.1,35.67 205.1,35.53 204.93,35.36 204.93,35.22 205.08,35.07 205.22,35.07 205.52,35.38 205.67,35.38 205.81,35.23 205.81,35.09 205.51,34.79 205.51,34.64 205.65,34.5 205.79,34.5 206.1,34.8 206.24,34.8 206.39,34.66 206.39,34.51 206.08,34.21 206.08,34.07 206.23,33.92 206.37,33.92 206.67,34.23 206.82,34.23 206.96,34.08 206.96,33.94 206.66,33.64 206.66,33.49 206.8,33.35 206.94,33.35 207.25,33.65 207.39,33.65 211.41,29.64 211.41,27.49 211.69,27.21 211.69,24.18 v2(211.29,23.79)
  BOTTOM w0.076: v2(151.34,65.36) 151.34,65.51 151.52,65.69 UC1.AP28
  BOTTOM w0.102: v2(211.29,23.79) 212.39,23.79 212.52,23.92 212.52,25.21 212.28,25.45 JDIMM2.159
DDR_B_D24: length 57.8
  IN1 w0.076: 155.01,53.45 155.01,53.9 154.07,54.85 154.07,60.45 151.94,62.58 151.94,65.65 v2(152.29,66.01)
  IN1 w0.097: 155.01,53.45 155.01,51.21 169.71,36.51 169.71,31.89 169.48,31.66 168.85,31.66 168.72,31.53 168.72,31.26 168.85,31.14 169.03,31.14 169.13,31.04 169.13,30.85 169.03,30.75 168.6,30.75 168.51,30.65 168.51,23.29 169.03,22.77 169.03,21.07 v2(169.48,20.61)
  BOTTOM w0.076: v2(152.29,66.01) 152.62,66.34 UC1.AN26
  BOTTOM w0.102: JDIMM2.24 169.38,20.5 v2(169.48,20.61)
DDR_B_D25: length 56.8
  IN1 w0.076: 155.33,53.45 155.33,53.84 154.27,54.9 154.27,60.49 154.15,60.61 154.15,61.57 152.29,63.42 v2(152.29,64.71)
  IN1 w0.097: 155.33,53.45 155.33,51.36 170.02,36.66 170.02,31.27 169.93,31.18 169.57,31.18 169.46,31.06 169.46,30.9 169.57,30.79 169.93,30.79 170.02,30.69 170.02,30.47 169.9,30.34 169.03,30.34 168.85,30.16 168.85,23.64 169.48,23.01 v2(169.48,21.88)
  BOTTOM w0.089: v2(152.29,64.71) 152.62,65.04 UC1.AR26
  BOTTOM w0.102: JDIMM2.22 168.78,21.17 v2(169.48,21.88)
DDR_B_D26: length 56
  IN1 w0.076: 156.76,53.5 156.76,53.63 155.87,54.52 155.54,54.52 154.83,55.23 154.83,60.85 154.68,61 154.68,62.42 153.25,63.85 v2(153.25,64.71)
  IN1 w0.097: v2(171.64,24.86) 171.42,24.86 171.31,24.75 171.31,24.4 171.2,24.29 170.97,24.29 170.93,24.33 170.86,24.4 170.86,24.85 170.75,24.95 170.52,24.95 170.41,25.06 170.41,25.4 170.52,25.51 171.2,25.51 171.31,25.62 171.31,25.84 171.2,25.95 170.33,25.95 170.25,26.02 170.25,26.5 170.36,26.61 170.65,26.61 170.8,26.45 171,26.45 171.43,26.88 171.43,27.09 171.33,27.19 171.08,27.19 170.98,27.29 170.98,27.48 171.08,27.58 171.33,27.58 171.43,27.67 171.43,28.39 171.33,28.49 171.07,28.49 170.98,28.58 170.98,28.88 171.07,28.97 171.33,28.97 171.43,29.07 171.43,37.29 156.76,51.95 156.76,53.5
  BOTTOM w0.076: v2(153.25,64.71) 153.57,65.04 UC1.AR25
  BOTTOM w0.102: v2(171.64,24.86) 172.08,25.31 JDIMM2.33
DDR_B_D27: length 57.1
  IN1 w0.076: 157.09,53.45 157.09,53.68 155.79,54.98 155.36,54.98 155.03,55.31 155.03,60.97 154.85,61.15 154.85,62.93 153.63,64.15 153.63,64.98 v2(153.25,65.36)
  IN1 w0.097: 157.09,53.45 157.09,52.08 171.74,37.43 171.74,26.38 172.13,25.99 172.13,22.47 172.02,22.36 171.27,22.36 171.16,22.47 171.16,22.85 v2(171.67,23.35)
  BOTTOM w0.076: v2(153.25,65.36) 153.57,65.69 UC1.AP25
  BOTTOM w0.102: v2(171.67,23.35) 172.23,23.91 172.23,24.83 172.68,25.28 JDIMM2.35
DDR_B_D28: length 59.2
  IN1 w0.076: 154.39,53.45 154.39,54.02 153.69,54.72 153.69,60.29 152.13,61.84 151.98,61.84 150.93,62.89 150.93,67.41 151.86,68.34 152.75,68.34 v2(153.07,68.65)
  IN1 w0.097: v2(167.8,24.86) 167.8,27.09 167.15,27.75 167.15,28.28 167.88,29.01 167.88,33.01 168.01,33.15 168.66,33.15 168.77,33.25 168.77,33.43 168.66,33.54 167.97,33.54 167.88,33.63 167.88,33.83 167.97,33.92 168.96,33.92 169.05,34.02 169.05,34.21 168.96,34.31 168.71,34.31 168.6,34.42 168.6,34.58 168.71,34.69 168.96,34.69 169.05,34.79 169.05,36.16 154.39,50.82 154.39,53.45
  BOTTOM w0.076: UC1.AK26 152.7,68.29 v2(153.07,68.65)
  BOTTOM w0.102: JDIMM2.21 168.48,25.11 168.23,24.86 v2(167.8,24.86)
DDR_B_D29: length 58.7
  IN1 w0.076: v2(152.26,66.62) 151.76,66.13 151.76,62.49 153.89,60.36 153.89,54.77 154.7,53.96 154.7,53.45
  IN1 w0.097: 154.7,53.45 154.7,51.01 169.38,36.33 169.38,33.63 169.29,33.53 169.19,33.53 169.08,33.42 169.08,33.26 169.19,33.15 169.29,33.15 169.38,33.05 169.38,32.86 169.29,32.76 168.29,32.76 168.19,32.67 168.19,32.47 168.29,32.38 169.29,32.38 169.38,32.28 169.38,32.09 169.29,31.99 168.39,31.99 168.19,31.79 168.19,25.03 168.19,25.03 168.19,24.7 168.19,24.7 168.19,23.73 v2(167.8,23.34)
  BOTTOM w0.076: v2(152.26,66.62) 152.62,66.99 UC1.AM26
  BOTTOM w0.102: v2(167.8,23.34) 169.08,24.62 JDIMM2.23
DDR_B_D30: length 59.3
  IN1 w0.076: v2(153.2,67.96) 153.81,67.35 153.81,67.2 154.07,66.94 154.33,66.94 154.59,66.67 154.59,64.33 155.2,63.72 155.2,62.61 156.07,61.73 156.07,55.43 157.44,54.06
  IN1 w0.097: v2(171.8,20.61) 172.77,21.59 172.77,26.82 172.38,27.21 172.38,29.07 172.53,29.22 172.53,37.55 157.75,52.34 157.75,53.76 157.44,54.06
  BOTTOM w0.076: UC1.AK25 153.52,68.29 v2(153.2,67.96)
  BOTTOM w0.102: JDIMM2.34 172.38,20.03 v2(171.8,20.61)
DDR_B_D31: length 59.5
  IN1 w0.076: v2(153.28,67.31) 153.81,66.79 153.81,64.28 155.03,63.06 155.03,62.32 155.85,61.51 155.85,55.36 157.42,53.78
  IN1 w0.097: v2(171.8,21.88) 171.8,21.45 171.9,21.35 172.09,21.35 172.46,21.71 172.46,26.46 172.05,26.86 172.05,37.58 157.42,52.21 157.42,53.78
  BOTTOM w0.076: v2(153.28,67.31) 153.61,67.64 UC1.AL25
  BOTTOM w0.102: JDIMM2.36 172.98,20.7 v2(171.8,21.88)
DDR_B_D32: length 91.3
  IN3 w0.076: v2(155.44,57.37) 156.02,56.78 156.02,54.99 157.03,53.99
  IN3 w0.102: v2(214.93,19.62) 214.26,19.62 214.1,19.77 214.1,29.53 197.15,46.49 166.78,46.49 166.63,46.65 166.63,47.67 166.52,47.77 166.32,47.77 166.22,47.67 166.22,46.65 166.12,46.54 165.91,46.54 165.81,46.65 165.81,47.67 165.71,47.77 164.12,47.77 160.47,51.42 159.81,51.42 157.24,53.99 157.03,53.99
  BOTTOM w0.076: v2(155.44,57.37) 154.75,58.05 154.75,60.7 154.51,60.94 154.51,61.66 154.5,61.67 UC1.AY23
  BOTTOM w0.102: v2(214.93,19.62) 214.38,19.07 JDIMM2.166
DDR_B_D33: length 92.6
  IN3 w0.076: 157.4,53.31 155.83,54.88 155.83,56.32 v2(155.44,56.72)
  IN3 w0.102: v2(213.27,23.78) 213.67,24.18 213.67,29.54 197.02,46.18 165.51,46.18 165.41,46.29 165.41,46.98 165.3,47.08 165.1,47.08 165,46.98 165,46.29 164.9,46.18 164.61,46.18 164.2,46.6 164.2,46.85 164.3,46.95 164.43,46.95 164.53,47.06 164.53,47.36 164.43,47.46 163.85,47.46 163.67,47.27 163.52,47.27 163.38,47.42 163.38,47.56 163.57,47.75 163.57,47.89 163.42,48.04 163.28,48.04 163.09,47.85 162.95,47.85 162.8,47.99 162.8,48.14 162.99,48.32 162.99,48.47 162.85,48.61 162.7,48.61 162.52,48.42 162.37,48.42 162.23,48.57 162.23,48.71 162.42,48.9 162.42,49.04 162.27,49.19 162.13,49.19 161.94,49 161.8,49 161.65,49.14 161.65,49.29 161.84,49.47 161.84,49.62 161.7,49.76 161.55,49.76 161.37,49.57 161.22,49.57 161.08,49.72 161.08,49.86 161.27,50.05 161.27,50.19 161.12,50.34 160.98,50.34 160.79,50.15 160.65,50.15 160.5,50.29 160.5,50.44 160.69,50.62 160.69,50.77 160.55,50.91 160.4,50.91 160.22,50.72 160.07,50.72 157.48,53.31 157.4,53.31
  BOTTOM w0.076: v2(155.44,56.72) 154.58,57.57 154.58,60.63 154.35,60.87 154.35,61.59 154.21,61.73 154.21,62 154.3,62.17 154.5,62.37 UC1.AW23
  BOTTOM w0.102: JDIMM2.165 214.08,25.33 213.73,24.99 213.73,24.24 v2(213.27,23.78)
