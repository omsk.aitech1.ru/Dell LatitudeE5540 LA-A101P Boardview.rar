# Allegro board Alpine15_LA-A101PR10-0826C.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_B_D34: length 91.3
  IN3 w0.076: 160.53,53.8 160.39,53.94 159.07,53.94 157.41,55.6
  IN3 w0.084: v2(157.04,56.07) 157.41,55.69 157.41,55.6
  IN3 w0.102: v2(216.45,19.62) 217,20.17 217,24.86 216.52,25.34 216.52,30 197.99,48.53 170.78,48.53 170.63,48.68 170.63,49.41 170.53,49.52 170.32,49.52 170.22,49.41 170.22,48.68 170.12,48.58 169.92,48.58 169.81,48.68 169.81,49.74 169.71,49.84 165.14,49.84 161.53,53.45 160.87,53.45 160.53,53.8
  BOTTOM w0.076: UC1.AY21 155.98,61.8 155.98,60.45 156.27,60.16 156.27,56.83 v2(157.04,56.07)
  BOTTOM w0.102: JDIMM2.174 216.78,19.29 v2(216.45,19.62)
DDR_B_D35: length 92.4
  IN3 w0.076: v2(157.04,56.72) 157.79,55.96 157.79,55.64 159.26,54.16 160.63,54.16 160.76,54.03
  IN3 w0.102: 160.76,54.03 161.01,53.78 161.63,53.78 165.27,50.15 170.93,50.15 171.03,50.05 171.03,48.93 171.14,48.83 171.34,48.83 171.44,48.93 171.44,50.05 171.54,50.15 171.75,50.15 171.85,50.05 171.85,48.93 171.95,48.83 172.15,48.83 172.25,48.93 172.25,49.97 172.35,50.08 172.56,50.08 172.66,49.97 172.66,48.93 172.76,48.83 198.12,48.83 216.85,30.1 216.85,25.53 217.31,25.07 217.31,24.42 v2(217.92,23.81)
  BOTTOM w0.076: UC1.AW21 155.85,62.34 156.14,62.05 156.14,60.52 156.44,60.23 156.44,57.32 v2(157.04,56.72)
  BOTTOM w0.102: JDIMM2.175 217.08,24.66 v2(217.92,23.81)
DDR_B_D36: length 93.1
  IN3 w0.084: v2(155.44,55.42) 155.44,55.02 157.33,53.12
  IN3 w0.102: v2(213.27,25.05) 213.25,25.08 213.25,29.52 203.7,39.07 203.56,39.07 203.31,38.82 203.17,38.82 203.02,38.96 203.02,39.11 203.27,39.36 203.27,39.5 203.13,39.65 202.99,39.65 202.74,39.4 202.59,39.4 202.45,39.54 202.45,39.68 202.7,39.93 202.7,40.08 202.55,40.22 202.41,40.22 202.16,39.97 202.02,39.97 201.87,40.11 201.87,40.26 202.12,40.51 202.12,40.65 201.98,40.8 201.84,40.8 201.59,40.55 201.44,40.55 201.3,40.69 201.3,40.83 201.55,41.08 201.55,41.23 201.4,41.37 201.26,41.37 201.01,41.12 200.87,41.12 200.72,41.27 200.72,41.41 200.97,41.66 200.97,41.8 200.83,41.95 200.69,41.95 200.44,41.7 200.29,41.7 200.15,41.84 200.15,41.98 200.4,42.23 200.4,42.38 200.25,42.52 200.11,42.52 199.86,42.27 199.72,42.27 199.57,42.42 199.57,42.56 199.82,42.81 199.82,42.95 199.68,43.1 199.54,43.1 199.29,42.85 199.14,42.85 199,42.99 199,43.13 199.25,43.38 199.25,43.53 199.1,43.67 198.96,43.67 198.71,43.42 198.57,43.42 198.42,43.57 198.42,43.71 198.67,43.96 198.67,44.1 198.53,44.25 198.39,44.25 198.14,44 197.99,44 197.82,44.17 197.82,44.31 198.07,44.56 198.07,44.71 197.92,44.85 197.78,44.85 197.53,44.6 197.39,44.6 197.24,44.75 197.24,44.89 197.45,45.1 197.45,45.25 197.31,45.39 197.17,45.39 196.95,45.18 196.81,45.18 196.11,45.88 164.49,45.88 157.33,53.04 157.33,53.12
  BOTTOM w0.076: UC1.AV23 154.12,62.84 154.12,62.18 154.04,62.04 154.04,61.66 154.18,61.52 154.18,60.8 154.42,60.57 154.42,56.43 v2(155.44,55.42)
  BOTTOM w0.102: JDIMM2.163 213.48,25.26 v2(213.27,25.05)
DDR_B_D37: length 94
  IN3 w0.076: v2(155.44,58.02) 156.23,57.23 156.23,55.21 157.24,54.19
  IN3 w0.102: v2(214.93,20.89) 214.93,20.79 214.82,20.69 214.52,20.69 214.42,20.79 214.42,29.65 197.28,46.79 167.95,46.79 167.84,46.9 167.84,47.59 167.74,47.69 167.54,47.69 167.44,47.59 167.44,46.9 167.34,46.8 167.13,46.8 167.03,46.9 167.03,47.99 166.93,48.09 164.23,48.09 160.6,51.72 159.96,51.72 157.5,54.19 157.24,54.19
  BOTTOM w0.076: UC1.AU23 155.26,63.88 155.47,63.67 155.47,63.43 155.45,63.42 155.45,63.04 155.47,63.02 155.47,62.83 155.46,62.82 155.39,62.68 155.39,62.47 155.47,62.32 155.47,62.19 155.42,62.08 155.39,62.03 155.39,61.74 155.63,61.5 155.63,60.33 155.93,60.03 155.93,58.51 v2(155.44,58.02)
  BOTTOM w0.102: v2(214.93,20.89) 214.06,20.03 214.06,19.7 213.78,19.41 JDIMM2.164
DDR_B_D38: length 92.8
  IN3 w0.076: 157.34,55.42 159.19,53.57 160.3,53.57
  IN3 w0.084: v2(157.04,55.42) 157.34,55.42
  IN3 w0.102: 160.3,53.57 160.72,53.15 161.33,53.15 164.94,49.54 168.48,49.54 168.58,49.44 168.58,48.93 168.69,48.83 168.89,48.83 168.99,48.93 168.99,49.44 169.09,49.54 169.3,49.54 169.4,49.44 169.4,48.35 169.52,48.22 197.87,48.22 216.21,29.88 216.21,25.2 216.63,24.79 216.63,22.52 216.02,21.91 216.02,21.17 216.3,20.89 v2(216.45,20.89)
  BOTTOM w0.076: v2(157.04,55.42) 156.58,55.87 156.58,55.88 156.1,56.36 156.1,59.9 156.1,59.9 156.1,60.1 155.8,60.39 155.8,61.56 155.56,61.8 155.56,61.99 155.61,62.1 155.63,62.15 155.63,62.35 155.61,62.41 155.57,62.5 155.56,62.51 155.56,62.64 155.58,62.69 155.61,62.75 155.74,62.88 UC1.AV21
  BOTTOM w0.102: JDIMM2.176 217.38,19.96 v2(216.45,20.89)
DDR_B_D39: length 93.4
  IN3 w0.076: v2(157.04,57.37) 157.96,56.44 157.96,55.71 159.22,54.44 160.86,54.44 161.02,54.28
  IN3 w0.102: v2(217.92,25.08) 217.17,25.83 217.17,26.05 217.28,26.15 217.57,26.15 217.67,26.25 217.67,26.48 217.57,26.58 217.28,26.58 217.17,26.68 217.17,30.21 198.2,49.18 176.71,49.18 175.68,49.18 175.58,49.28 175.58,49.89 175.42,50.05 175.25,50.05 175.15,49.95 175.15,49.28 175.05,49.18 174.82,49.18 174.72,49.28 174.72,50.41 174.62,50.51 174.39,50.51 174.29,50.41 174.29,49.31 174.18,49.21 173.98,49.21 173.88,49.31 173.88,50.41 173.78,50.51 173.57,50.51 173.47,50.41 173.47,49.31 173.37,49.21 173.17,49.21 173.07,49.31 173.07,50.41 172.96,50.51 165.34,50.51 161.76,54.09 161.21,54.09 161.02,54.28
  BOTTOM w0.076: v2(157.04,57.37) 156.6,57.8 156.6,60.29 156.31,60.59 156.31,62.12 156.14,62.28 156.14,62.7 156.02,62.82 156.02,63.09 156.04,63.11 156.04,63.35 155.74,63.64 UC1.AU21
  BOTTOM w0.102: JDIMM2.177 217.68,25.33 v2(217.92,25.08)
DDR_B_D40: length 53.7
  IN1 w0.076: 158.27,53.45 158.27,53.65 157.42,54.49 157.42,58.28 v2(157.04,58.67)
  IN1 w0.097: 158.27,53.45 158.27,52.56 174.51,36.31 174.51,28.97 174.29,28.74 172.99,28.74 172.89,28.64 172.89,27.72 173.07,27.55 173.93,27.55 174.06,27.42 174.06,26.71 173.93,26.58 173.39,26.58 173.29,26.49 173.29,26.29 173.39,26.2 174.15,26.2 174.26,26.08 174.26,25.92 174.15,25.81 173.39,25.81 173.29,25.71 173.29,25.52 173.39,25.42 174.23,25.42 174.36,25.3 174.36,24.99 174.23,24.86 v2(173.28,24.86)
  BOTTOM w0.076: UC1.AY19 156.8,61.8 156.8,60.95 156.82,60.94 156.82,60.88 157.21,60.49 157.25,60.49 157.56,60.18 157.56,60.14 157.59,60.1 157.59,59.23 v2(157.04,58.67)
  BOTTOM w0.102: v2(173.28,24.86) 173.74,24.86 173.88,25 JDIMM2.39
DDR_B_D41: length 54.6
  IN1 w0.076: v2(157.04,59.32) 157.62,58.73 157.62,54.6 158.58,53.64 158.58,53.45
  IN1 w0.097: v2(173.28,23.34) 174.2,23.34 174.34,23.2 174.34,22.41 174.46,22.29 174.72,22.29 174.85,22.41 174.85,27.04 174.47,27.41 174.47,28.42 174.85,28.79 174.85,36.42 158.58,52.68 158.58,53.45
  BOTTOM w0.076: UC1.AW19 156.93,62.34 156.64,62.05 156.64,60.89 156.65,60.87 156.65,60.81 157.14,60.32 157.18,60.32 157.39,60.11 157.39,60.07 157.43,60.03 157.43,59.71 v2(157.04,59.32)
  BOTTOM w0.102: v2(173.28,23.34) 174.48,24.54 JDIMM2.41
DDR_B_D42: length 53.2
  IN1 w0.076: 159.63,56.24 159.63,59.22 159.02,59.83 v2(158.82,59.83)
  IN1 w0.084: 161.78,54.09 159.63,56.24
  IN1 w0.097: 161.78,54.09 161.78,53.84 178.58,37.05 178.58,36.53 178.46,36.41 178.34,36.41 178.22,36.3 178.22,36.14 178.34,36.03 178.48,36.03 178.58,35.93 178.58,35.74 178.48,35.64 178.09,35.64 177.99,35.55 177.99,35.35 178.09,35.26 178.48,35.26 178.58,35.16 178.58,34.97 178.48,34.87 178.09,34.87 177.99,34.77 177.99,34.58 178.09,34.48 178.48,34.48 178.58,34.39 178.58,34.19 178.48,34.1 178.09,34.1 177.99,34 177.99,33.81 178.09,33.71 178.48,33.71 178.58,33.62 178.58,33.42 178.48,33.33 178.09,33.33 177.99,33.23 177.99,33.04 178.09,32.94 178.48,32.94 178.58,32.84 178.58,32.65 178.48,32.55 178.09,32.55 177.99,32.46 177.99,32.26 178.09,32.17 178.48,32.17 178.58,32.07 178.58,31.86 178.45,31.74 178.12,31.74 177.99,31.61 177.99,27.55 178.65,26.89 v2(178.65,24.92)
  BOTTOM w0.076: UC1.AY17 158.23,61.88 158.23,60.79 158.8,60.22 158.8,59.85 v2(158.82,59.83)
  BOTTOM w0.102: JDIMM2.53 178.08,25.49 v2(178.65,24.92)
DDR_B_D43: length 54.2
  IN1 w0.084: 160.61,54.09 159.24,55.46 v2(158.97,55.46)
  IN1 w0.097: v2(177.18,20.9) 177.92,20.9 178.02,21 178.02,21.42 177.9,21.54 177.9,25.54 177.19,26.26 177.19,37.51 160.61,54.09
  BOTTOM w0.076: UC1.AW17 158.5,62.36 158.5,62.15 158.54,62.06 158.57,61.99 158.57,61.8 158.4,61.63 158.4,60.86 159.31,59.95 159.31,59.53 159.39,59.45 159.39,55.88 v2(158.97,55.46)
  BOTTOM w0.102: v2(177.18,20.9) 177.78,20.3 JDIMM2.52
DDR_B_D44: length 54.9
  IN1 w0.076: 157.8,54.75 157.8,59.2 v2(157.04,59.97)
  IN1 w0.084: 157.8,54.75 158.49,54.06
  IN1 w0.097: v2(174.78,19.63) 174.27,19.63 174.13,19.77 174.13,21.27 174.26,21.4 175.25,21.4 175.4,21.54 175.4,22.51 175.16,22.74 175.16,27.18 174.95,27.39 174.95,28.4 175.16,28.61 175.16,36.55 158.89,52.81 158.89,53.66 158.49,54.06
  BOTTOM w0.076: v2(157.04,59.97) 157.04,60.11 156.47,60.67 156.47,62.12 156.64,62.29 156.64,62.7 157.04,63.1 UC1.AV19
  BOTTOM w0.102: JDIMM2.42 v2(174.78,19.63)
DDR_B_D45: length 55.8
  IN1 w0.076: v2(158.84,58.59) 158.59,58.59 158,58 158,54.9 159.22,53.68 159.22,53.45
  IN1 w0.097: 159.22,53.45 159.22,52.95 175.47,36.7 175.47,28.4 175.28,28.21 175.28,27.57 175.47,27.37 175.47,22.91 175.71,22.67 175.71,21.37 175.24,20.9 v2(174.78,20.9)
  BOTTOM w0.076: UC1.AU19 157.69,63.88 157.9,63.67 157.9,62.84 157.85,62.73 157.82,62.68 157.82,62.47 157.86,62.39 157.9,62.32 157.9,62.19 157.82,62.03 157.82,61.69 157.89,61.63 157.89,61.48 157.89,60.67 158.26,60.3 158.26,59.14 158.68,58.72 v2(158.84,58.59)
  BOTTOM w0.102: v2(174.78,20.9) 174.18,20.3 JDIMM2.40
DDR_B_D46: length 54.3
  IN1 w0.076: 161.07,54.09 159.29,55.86 159.29,58.75 v2(158.82,59.22)
  IN1 w0.097: v2(178.6,23.62) 178.34,23.62 178.21,23.75 178.21,25.41 178.21,25.67 178.21,25.67 178.21,26.06 178.07,26.2 177.69,26.2 177.56,26.32 177.56,26.49 177.68,26.61 178.06,26.61 178.17,26.72 178.17,26.88 178.06,27 177.67,27 177.58,27.09 177.58,35.75 177.67,35.84 177.8,35.84 177.89,35.94 177.89,36.13 177.8,36.23 177.67,36.23 177.58,36.33 177.58,36.55 177.67,36.65 178.11,36.65 178.22,36.76 178.22,36.92 178.11,37.03 177.67,37.03 177.58,37.13 177.58,37.58 161.07,54.09
  BOTTOM w0.076: v2(158.82,59.22) 158.44,59.6 158.44,60.36 158.05,60.74 158.05,61.11 158.06,61.11 158.06,61.55 158.05,61.55 158.05,61.69 157.99,61.76 157.99,61.99 158.04,62.1 158.06,62.15 158.06,62.35 158.04,62.41 158.03,62.42 158,62.5 157.99,62.51 157.99,62.64 158.04,62.75 158.28,62.99 UC1.AV17
  BOTTOM w0.102: JDIMM2.51 177.48,24.75 v2(178.6,23.62)
DDR_B_D47: length 55.5
  IN1 w0.076: 160.29,53.96 159.32,54.93 v2(159.23,54.93)
  IN1 w0.097: v2(177.18,19.63) 177.51,19.63 177.64,19.76 177.64,20.2 177.51,20.33 176.89,20.33 176.79,20.43 176.79,21.18 177.59,21.98 177.59,25.33 176.88,26.04 176.88,37.31 160.75,53.44 160.75,53.51 160.29,53.96
  BOTTOM w0.076: UC1.AU17 158.57,63.58 158.57,62.83 158.67,62.74 158.67,62.19 158.71,62.08 158.74,62.03 158.74,61.74 158.57,61.57 158.57,60.93 159.47,60.03 159.47,59.6 159.55,59.52 159.55,55.25 v2(159.23,54.93)
  BOTTOM w0.102: JDIMM2.50 v2(177.18,19.63)
DDR_B_D48: length 96.4
  IN3 w0.076: 161.48,58.74 161.48,59.21 156,64.69 v2(156,64.71) ; 161.79,58.43 161.56,58.66
  IN3 w0.102: 161.56,58.66 161.48,58.74 ; v2(221.5,25.06) 221.86,25.06 221.96,25.16 221.96,25.51 221.86,25.61 221.51,25.61 221.41,25.72 221.41,25.95 221.51,26.05 222.14,26.05 222.24,26.15 222.24,26.4 222.14,26.5 221.53,26.5 221.43,26.61 221.43,26.83 221.53,26.94 222.09,26.94 222.19,27.04 222.19,27.24 222.09,27.34 221.83,27.34 221.73,27.44 221.73,27.65 221.83,27.75 222.22,27.75 222.32,27.85 222.32,28.1 222.22,28.21 221.51,28.21 221.41,28.31 221.41,28.51 221.51,28.61 222.22,28.61 222.32,28.71 222.32,28.89 222.22,28.99 221.55,28.99 221.45,29.09 221.45,29.27 221.55,29.37 221.71,29.37 221.81,29.48 221.81,29.64 199.42,52.03 177.49,52.03 176.08,53.44 175.5,53.44 175.4,53.54 175.4,54.06 175.3,54.16 175.09,54.16 174.99,54.06 174.99,53.53 174.89,53.43 174.69,53.43 174.58,53.53 174.58,54.06 174.48,54.16 174.28,54.16 174.18,54.06 174.18,53.48 174.08,53.38 173.87,53.38 173.77,53.48 173.77,54.06 173.67,54.16 166.06,54.16 161.79,58.43
  BOTTOM w0.076: v2(156,64.71) 156.32,65.04 UC1.AR21
  BOTTOM w0.102: v2(221.5,25.06) 221.88,25.43 JDIMM2.191
DDR_B_D49: length 97.2
  IN3 w0.076: 159.73,58.3 159.73,59.89 159.09,60.54 157.78,60.54 155.05,63.28 v2(155.05,64.71)
  IN3 w0.102: v2(219.95,25.05) 219.95,27.14 219.83,27.27 219.63,27.27 219.51,27.39 219.51,28.07 219.61,28.17 219.86,28.17 219.98,28.29 219.98,28.46 219.86,28.58 219.61,28.58 219.51,28.68 219.51,29.04 219.63,29.17 219.79,29.17 219.92,29.3 219.92,29.51 219.79,29.64 219.63,29.64 219.51,29.77 219.51,29.9 198.8,50.6 176.88,50.6 175.53,51.95 172.85,51.95 172.74,52.06 172.74,52.44 172.64,52.54 172.44,52.54 172.34,52.44 172.34,52.06 172.24,51.95 172.03,51.95 171.93,52.06 171.93,52.64 171.83,52.74 171.62,52.74 171.52,52.64 171.52,52.06 171.42,51.95 170.21,51.95 170.11,52.06 170.11,52.24 169.99,52.36 169.83,52.36 169.71,52.24 169.71,52.06 169.6,51.95 169.4,51.95 169.3,52.06 169.3,52.59 169.2,52.69 169,52.69 168.89,52.59 168.89,52.06 168.79,51.95 168.59,51.95 168.49,52.06 168.49,52.64 168.39,52.74 168.18,52.74 168.08,52.64 168.08,52.06 167.98,51.95 167.78,51.95 167.67,52.06 167.67,52.67 167.6,52.74 167.34,52.74 167.27,52.67 167.27,52.06 167.17,51.95 166.82,51.95 166.72,52.06 166.72,52.62 166.61,52.72 166.34,52.72 166.23,52.62 166.23,52.31 166.13,52.21 165.78,52.21 162.66,55.32 162.37,55.32 162.25,55.45 162.25,55.45 162.03,55.66 162.03,55.67 161.01,56.68 161.01,57.02 159.73,58.3
  BOTTOM w0.076: UC1.AR22 155.37,65.04 v2(155.05,64.71)
  BOTTOM w0.102: v2(219.95,25.05) 219.57,25.05 219.48,25.15 JDIMM2.183
DDR_B_D50: length 99.4
  IN3 w0.076: v2(156,67.31) 156.56,66.75 156.56,64.6 156.8,64.36 157.24,64.36 161.18,60.42 161.18,60.3 161.36,60.12 161.48,60.12
  IN3 w0.102: v2(223.38,19.79) 222.05,19.79 221.69,20.14 221.69,21.67 222.01,21.98 222.01,23.23 222.11,23.33 223.41,23.33 223.51,23.43 223.51,28.8 199.57,52.74 177.92,52.74 175.89,54.77 166.48,54.77 163.8,57.46 163.8,57.93 161.61,60.12 161.48,60.12
  BOTTOM w0.076: UC1.AL21 156.32,67.64 v2(156,67.31)
  BOTTOM w0.102: v2(223.38,19.79) 222.78,19.19 JDIMM2.194
DDR_B_D51: length 99.6
  IN3 w0.076: v2(155.05,66.66) 154.65,66.27 154.65,65.9 153.84,65.1 153.84,64.01 157.65,60.21 158.95,60.21 159.25,59.91 159.25,57.87 159.35,57.77
  IN3 w0.084: 159.35,57.77 160.02,57.1 160.02,56.82 162.07,54.77 162.35,54.77 162.4,54.72
  IN3 w0.102: 162.4,54.72 165.79,51.33 175.29,51.33 176.63,49.99 198.54,49.99 218,30.53 218,28.87 218.14,28.72 218.46,28.72 218.74,28.44 218.74,19.11 218.63,19.01 217.29,19.01 217.19,19.11 217.19,19.54 217.29,19.64 v2(218.05,19.64)
  BOTTOM w0.076: v2(155.05,66.66) 155.37,66.99 UC1.AM22
  BOTTOM w0.102: v2(218.05,19.64) 218.58,19.11 JDIMM2.180
DDR_B_D52: length 98.8
  IN3 w0.076: 159.63,57.92 159.53,58.02 159.53,59.86 159.02,60.37 157.71,60.37 154.69,63.4 154.69,65.56 155.05,65.92 v2(155.05,66.01)
  IN3 w0.102: v2(219.95,23.78) 219.95,22.77 219.85,22.67 219.27,22.67 219.17,22.77 219.17,23.56 219.27,23.66 219.4,23.66 219.5,23.76 219.5,23.97 219.4,24.07 219.27,24.07 219.17,24.17 219.17,24.37 219.27,24.47 219.4,24.47 219.5,24.58 219.5,24.78 219.4,24.88 219.27,24.88 219.17,24.98 219.17,25.41 219.27,25.51 219.55,25.51 219.65,25.62 219.65,25.82 219.55,25.92 219.27,25.92 219.17,26.02 219.17,26.22 219.27,26.33 219.55,26.33 219.65,26.43 219.65,26.63 219.55,26.73 219.27,26.73 219.17,26.83 219.17,28.94 219.07,29.04 218.41,29.04 218.3,29.15 218.3,29.35 218.41,29.45 218.99,29.45 219.09,29.55 219.09,29.76 218.99,29.86 218.41,29.86 218.3,29.96 218.3,30.66 198.67,50.3 176.75,50.3 175.41,51.64 165.91,51.64 162.52,55.03 162.37,55.03 160.65,56.76 160.65,56.91 159.63,57.92
  BOTTOM w0.076: v2(155.05,66.01) 155.37,66.34 UC1.AN22
  BOTTOM w0.102: v2(219.95,23.78) 218.88,24.86 JDIMM2.181
DDR_B_D53: length 97.4
  IN3 w0.076: v2(156,65.36) 156.37,64.99 156.37,64.56 161.11,59.81 161.48,59.81
  IN3 w0.102: v2(221.5,23.79) 222.01,23.79 222.11,23.89 222.11,24.34 222.22,24.45 222.57,24.45 222.67,24.34 222.67,24.27 222.77,24.17 223.05,24.17 223.16,24.27 223.16,24.75 223.05,24.85 222.47,24.85 222.37,24.95 222.37,25.17 222.47,25.27 223.1,25.27 223.21,25.38 223.21,25.58 223.1,25.68 222.75,25.68 222.65,25.78 222.65,25.99 222.75,26.09 223.1,26.09 223.21,26.19 223.21,26.39 223.1,26.49 222.75,26.49 222.65,26.6 222.65,26.8 222.75,26.9 223.1,26.9 223.21,27 223.21,27.2 223.1,27.31 222.75,27.31 222.65,27.41 222.65,28.15 222.75,28.25 223.05,28.25 223.16,28.35 223.16,28.56 223.05,28.66 222.75,28.66 222.65,28.76 222.65,29.24 199.55,52.34 177.89,52.34 175.76,54.47 166.36,54.47 163.34,57.49 163.34,57.96 161.48,59.81
  BOTTOM w0.076: v2(156,65.36) 156.32,65.69 UC1.AP21
  BOTTOM w0.102: v2(221.5,23.79) 222.48,24.76 JDIMM2.193
DDR_B_D54: length 100.1
  IN3 w0.076: 161.48,60.42 157.4,64.51 157.4,68.02 157.1,68.32 156.33,68.32 v2(155.97,67.96)
  IN3 w0.102: v2(223.38,21.06) 223.01,21.06 222.72,21.35 222.72,21.96 224.17,23.41 224.17,26.63 223.82,26.99 223.82,28.93 199.7,53.05 194.21,53.05 193.27,53.99 192.24,53.99 191.35,53.1 177.99,53.1 176.01,55.08 168.32,55.08 168.16,55.23 167.15,55.23 161.96,60.42 161.48,60.42
  BOTTOM w0.076: UC1.AK21 156.3,68.29 v2(155.97,67.96)
  BOTTOM w0.102: JDIMM2.192 222.18,19.86 v2(223.38,21.06)
DDR_B_D55: length 100.6
  IN3 w0.076: v2(155.05,67.96) 154.65,67.57 154.65,67.14 153.68,66.17 153.68,63.85 157.42,60.11
  IN3 w0.084: 161.17,55.09 159.45,56.81 159.45,57.26 159.04,57.67 158.21,57.67 157.42,58.45 157.42,60.11
  IN3 w0.102: 161.17,55.09 161.76,54.49 162.07,54.49 165.55,51.02 175.17,51.02 176.5,49.69 198.41,49.69 217.69,30.41 217.69,28.52 217.8,28.42 218.33,28.42 218.43,28.32 218.43,27.55 218.33,27.44 217.85,27.44 217.74,27.34 217.74,27.11 217.85,27.01 218.33,27.01 218.43,26.91 218.43,22.74 218.33,22.63 217.61,22.63 217.51,22.53 217.51,22.33 217.61,22.23 218.33,22.23 218.43,22.13 218.43,21.09 218.25,20.91 v2(218.05,20.91)
  BOTTOM w0.076: UC1.AK22 155.37,68.29 v2(155.05,67.96)
  BOTTOM w0.102: JDIMM2.182 219.18,19.78 v2(218.05,20.91)
DDR_B_D56: length 64.4
  IN1 w0.076: 163.21,54.09 163.13,54.16 163.13,54.27 160.3,57.1 160.3,59.58 159.27,60.62 158.13,60.62 157.95,60.8 157.95,61.73 156.86,62.82 156.86,63.42 156.59,63.69 156.59,65.65 v2(156.95,66.01)
  IN1 w0.097: 163.21,54.09 179.7,37.6 179.7,37.17 179.8,37.07 180.27,37.07 180.38,36.96 180.38,36.8 180.27,36.68 179.8,36.68 179.7,36.59 179.7,36.39 179.8,36.3 180.27,36.3 180.38,36.18 180.38,36.02 180.27,35.91 179.8,35.91 179.7,35.81 179.7,35.62 179.8,35.53 180.29,35.53 180.41,35.41 180.41,35.25 180.29,35.14 179.8,35.14 179.7,35.04 179.7,27.51 180.4,26.82 180.4,25.56 180,25.16 180,22.52 180.33,22.19 180.94,22.19 181.08,22.33 181.08,22.68 180.48,23.28 v2(180.48,23.59)
  BOTTOM w0.076: UC1.AN20 157.28,66.34 v2(156.95,66.01)
  BOTTOM w0.102: v2(180.48,23.59) 179.28,24.79 JDIMM2.57
DDR_B_D57: length 63.2
  IN1 w0.076: 163.76,54.09 163.63,54.09 162.25,55.46 162.25,55.46 162.04,55.67 162.04,55.67 160.65,57.07 160.65,59.47 159.3,60.82 158.61,60.82 158.46,60.97 158.46,61.78 157.12,63.13 157.12,63.82 156.95,63.98 v2(156.95,64.71)
  IN1 w0.097: v2(180.48,24.86) 180.71,25.1 180.71,27.44 180.58,27.57 180.18,27.57 180.05,27.7 180.05,28.33 180.18,28.46 180.61,28.46 180.73,28.58 180.73,28.84 180.63,28.94 180.11,28.94 180.02,29.04 180.02,29.23 180.11,29.33 180.63,29.33 180.73,29.42 180.73,29.61 180.63,29.71 180.11,29.71 180.02,29.81 180.02,30 180.11,30.1 180.63,30.1 180.73,30.19 180.73,30.39 180.63,30.48 180.11,30.48 180.02,30.58 180.02,30.77 180.11,30.87 180.63,30.87 180.73,30.97 180.73,31.16 180.63,31.26 180.11,31.26 180.02,31.35 180.02,31.55 180.11,31.64 180.63,31.64 180.73,31.74 180.73,31.93 180.63,32.03 180.11,32.03 180.02,32.12 180.02,32.32 180.11,32.41 180.63,32.41 180.73,32.51 180.73,32.7 180.63,32.8 180.11,32.8 180.02,32.9 180.02,33.09 180.11,33.19 180.63,33.19 180.73,33.28 180.73,33.48 180.63,33.57 180.11,33.57 180.02,33.67 180.02,33.86 180.11,33.96 180.62,33.96 180.73,34.06 180.73,34.24 180.62,34.34 180.11,34.34 180.02,34.44 180.02,34.63 180.11,34.73 180.63,34.73 180.73,34.83 180.73,37.04 180.73,37.05 180.73,37.12 176.46,41.38 176.46,41.38 164.04,53.8 163.76,54.09
  BOTTOM w0.076: UC1.AR20 157.28,65.04 v2(156.95,64.71)
  BOTTOM w0.102: JDIMM2.59 179.88,25.46 v2(180.48,24.86)
DDR_B_D58: length 65.4
  IN1 w0.076: 165.42,56.91 165.04,57.29 164.51,57.29 160.49,61.3 160.49,61.45 158.62,63.33 158.62,67.17 v2(157.86,67.92)
  IN1 w0.097: v2(183.5,24.32) 185.16,25.98 185.16,27.3 185.25,27.4 185.67,27.4 185.77,27.49 185.77,27.78 185.67,27.88 185.25,27.88 185.16,27.97 185.16,28.26 185.25,28.36 185.67,28.36 185.77,28.46 185.77,28.75 185.67,28.84 185.25,28.84 185.16,28.94 185.16,29.23 185.25,29.33 185.67,29.33 185.77,29.42 185.77,29.71 185.67,29.81 185.25,29.81 185.16,29.91 185.16,30.19 185.25,30.29 185.67,30.29 185.77,30.39 185.77,30.68 185.67,30.77 185.25,30.77 185.16,30.87 185.16,31.16 185.25,31.26 185.72,31.26 185.82,31.36 185.82,31.64 185.72,31.74 185.25,31.74 185.16,31.84 185.16,32.13 185.25,32.22 185.69,32.22 185.79,32.32 185.79,32.68 185.69,32.78 185.57,32.78 185.46,32.89 185.46,33.33 185.57,33.44 185.86,33.44 185.97,33.55 185.97,35.28 165.95,55.29 165.95,56.38 165.42,56.91
  BOTTOM w0.076: UC1.AK18 158.23,68.29 v2(157.86,67.92)
  BOTTOM w0.102: v2(183.5,24.32) 183.5,24.87 182.88,25.49 JDIMM2.69
DDR_B_D59: length 65
  IN1 w0.076: v2(157.88,67.31) 158.45,66.74 158.45,63.27 158.46,63.26 158.46,63.26 160.29,61.42 160.29,61.24 162.55,58.98 162.55,58.56 164.81,56.3
  IN1 w0.097: v2(183.48,23.62) 183.03,24.07 183.03,24.53 184.83,26.33 184.83,28.33 184.73,28.43 184.26,28.43 184.12,28.57 184.12,28.77 184.26,28.91 184.73,28.91 184.83,29.01 184.83,29.3 184.73,29.39 184.31,29.39 184.17,29.53 184.17,29.73 184.31,29.87 184.73,29.87 184.83,29.97 184.83,30.26 184.73,30.36 184.28,30.36 184.14,30.5 184.14,30.7 184.28,30.84 184.73,30.84 184.83,30.94 184.83,31.23 184.73,31.32 184.41,31.32 184.27,31.46 184.27,31.66 184.41,31.8 184.73,31.8 184.83,31.9 184.83,34.58 184.92,34.68 185.47,34.68 185.61,34.82 185.61,35.02 185.47,35.16 185.01,35.16 184.83,35.34 184.83,35.97 177.76,43.04 177.76,43.04 165.64,55.16 165.64,55.47 164.81,56.3
  BOTTOM w0.076: UC1.AL18 158.2,67.64 v2(157.88,67.31)
  BOTTOM w0.102: JDIMM2.67 182.28,24.82 v2(183.48,23.62)
DDR_B_D60: length 65.8
  IN1 w0.076: 162.3,54.09 162.3,54.16 159.81,56.65 159.81,59.4 158.99,60.21 157.55,60.21 156.78,60.97 156.78,61.71 155.54,62.95 155.54,68.04 155.82,68.32 156.56,68.32 156.92,67.96 v2(156.95,67.96)
  IN1 w0.097: v2(179.29,20.9) 179.24,20.95 179.24,27.01 178.53,27.72 178.53,28.29 179.08,28.84 179.08,29.19 178.98,29.29 178.62,29.29 178.53,29.38 178.53,29.58 178.62,29.67 178.98,29.67 179.08,29.77 179.08,29.96 178.98,30.06 178.62,30.06 178.53,30.16 178.53,30.35 178.62,30.45 178.98,30.45 179.08,30.54 179.08,30.74 178.98,30.83 178.71,30.83 178.6,30.93 178.6,31.12 178.71,31.22 178.98,31.22 179.08,31.31 179.08,37.26 162.3,54.04 162.3,54.09
  BOTTOM w0.076: UC1.AK20 157.28,68.29 v2(156.95,67.96)
  BOTTOM w0.102: JDIMM2.58 179.58,19.36 179.68,19.47 179.68,20.51 v2(179.29,20.9)
DDR_B_D61: length 64.9
  IN1 w0.076: 162.75,54.09 162.73,54.11 162.73,54.19 160.06,56.86 160.06,59.47 159.15,60.39 157.75,60.39 157.01,61.12 157.01,61.84 155.9,62.95 155.9,63.61 156.42,64.14 156.42,66.13 v2(156.95,66.66)
  IN1 w0.097: 162.75,54.09 179.39,37.45 179.39,27.37 180.09,26.67 180.09,25.78 179.62,25.31 179.62,22.01 179.8,21.83 180.97,21.83 181.08,21.72 181.08,21.53 180.97,21.42 179.82,21.42 179.72,21.32 179.72,21.05 179.94,20.84 179.94,20.59 179.76,20.41 178.65,20.41 178.53,20.28 178.53,20.05 178.65,19.93 179,19.93 v2(179.29,19.63)
  BOTTOM w0.076: UC1.AM20 157.28,66.99 v2(156.95,66.66)
  BOTTOM w0.102: JDIMM2.56 178.98,19.32 v2(179.29,19.63)
DDR_B_D62: length 61.8
  IN1 w0.076: v2(157.9,64.71) 157.9,63.26 159.86,61.3 159.86,61.07 162.09,58.84 162.09,58.13 164.37,55.85
  IN1 w0.097: v2(183.26,20.92) 183.26,22.09 182.67,22.68 182.67,23.47 182.41,23.73 182.41,25.56 182.77,25.92 183.21,25.92 183.3,26.02 183.3,26.31 183.21,26.4 182.5,26.4 182.41,26.5 182.41,26.79 182.5,26.89 183.21,26.89 183.3,26.98 183.3,27.27 183.21,27.37 182.67,27.37 182.46,27.57 182.46,27.93 183.43,28.89 183.43,36.41 177.28,42.56 177.28,42.58 164.75,55.12 164.75,55.47 164.37,55.85
  BOTTOM w0.076: UC1.AR18 158.23,65.04 v2(157.9,64.71)
  BOTTOM w0.102: JDIMM2.70 183.18,18.95 183.94,19.71 183.94,20.24 v2(183.26,20.92)
DDR_B_D63: length 62.6
  IN1 w0.076: v2(157.9,65.36) 158.27,64.99 158.27,63.12 160.03,61.36 160.03,61.18 162.28,58.93 162.28,58.39 164.5,56.18 164.5,56.17 164.59,56.08
  IN1 w0.097: 164.59,56.08 165.22,55.45 165.22,55.14 177.52,42.84 177.52,42.79 184.45,35.86 184.45,34.46 184.35,34.37 184.04,34.37 183.91,34.24 183.91,34.01 184.04,33.89 184.35,33.89 184.45,33.79 184.45,33.5 184.35,33.4 183.86,33.4 183.76,33.31 183.76,33.02 183.86,32.92 184.35,32.92 184.45,32.82 184.45,32.53 184.35,32.44 183.86,32.44 183.76,32.34 183.76,25.77 182.72,24.73 182.72,23.86 182.98,23.59 182.98,22.81 183.79,22.01 183.79,20.17 v2(183.26,19.65)
  BOTTOM w0.076: v2(157.9,65.36) 158.23,65.69 UC1.AP18
  BOTTOM w0.102: JDIMM2.68 182.58,18.97 v2(183.26,19.65)
DDR_B_DQS0: length 88
  IN3 w0.076: v2(149.82,59.32) 150.05,59.55 150.48,59.55 150.85,59.18 150.85,54.2 151.1,53.95 151.1,53.34 151.41,53.03 151.41,52.6 151.4,52.59 151.4,52.55 151.37,52.52 151.37,52.51
  IN3 w0.102: v2(205.1,22.88) 205.1,23.04 204.75,23.4 204.62,23.4 204.41,23.61 204.41,26.74 203.8,27.35 203.8,29.4 193.95,39.25 161.98,39.25 151.37,49.86 151.37,52.51
  BOTTOM w0.076: UC1.AV30 150.04,63.4 149.96,63.32 149.81,63.32 149.72,63.23 149.65,63.16 149.65,63.14 149.58,63 149.58,62.8 149.61,62.74 149.66,62.64 149.66,62.51 149.58,62.35 149.58,62.15 149.61,62.1 149.61,62.09 149.66,61.99 149.66,61.8 149.42,61.56 149.42,60.95 149.28,60.82 149.28,59.72 149.49,59.51 149.63,59.51 v2(149.82,59.32)
  BOTTOM w0.102: v2(205.1,22.88) 205.1,23.11 205.27,23.28 205.61,23.28 205.9,23.57 205.9,25.1 205.68,25.33 JDIMM2.137
DDR_B_DQS1: length 56.3
  IN1 w0.076: v2(153.12,57.69) 152.88,57.44 152.49,57.44 152.05,57 152.05,53.55 152.02,53.53 152.02,53.45
  IN1 w0.097: v2(166.54,20.67) 166.33,20.67 166.13,20.47 166.13,20.26 165.9,20.04 164.81,20.04 164.44,20.4 164.44,21.1 165.03,21.68 165.03,25.11 163.03,27.11 163.03,38.83 161.15,40.71 152.02,49.84 152.02,53.45
  BOTTOM w0.076: v2(153.12,57.69) 153.12,57.46 153.05,57.39 152.83,57.39 152.37,57.84 152.37,60.46 151.9,60.93 151.9,61.25 151.97,61.32 151.97,61.33 152.25,61.62 152.25,62.03 152.23,62.08 152.23,62.08 152.19,62.17 152.19,62.33 152.23,62.42 152.25,62.47 152.25,62.86 152.29,62.9 UC1.AW26
  BOTTOM w0.102: v2(166.54,20.67) 166.02,20.67 165.91,20.56 165.91,20.12 165.6,19.82 165.6,19.37 165.78,19.19 JDIMM2.12
DDR_B_DQS2: length 95
  IN3 w0.076: v2(151.34,66.66) 151.15,66.47 151,66.47 150.8,66.27 150.8,64.05 152.94,61.92 152.94,61.18 153.88,60.24 153.88,54.88 153.93,54.83 153.93,54.82 155.38,53.37 155.38,52.55 155.36,52.53 155.36,52.51
  IN3 w0.102: v2(211.19,20.23) 211.19,20.28 210.97,20.5 210.6,20.5 210.37,20.73 210.37,22.73 210.48,22.83 210.48,25.77 209.7,26.54 209.7,28.85 195.47,43.09 188.42,43.09 187.97,43.54 163.52,43.54 155.36,51.7 155.36,52.51
  BOTTOM w0.076: UC1.AM28 151.67,66.99 v2(151.34,66.66)
  BOTTOM w0.102: v2(211.19,20.23) 211.19,20.71 211.01,20.89 210.62,20.89 210.52,20.79 210.52,19.48 210.78,19.22 JDIMM2.154
DDR_B_DQS3: length 57.9
  IN1 w0.076: v2(153.25,66.66) 153.06,66.47 152.86,66.47 152.66,66.27 152.66,63.68 154.33,62 154.33,60.78 154.46,60.65 154.46,55.04 155.42,54.08 155.55,54.08 155.97,53.65 155.97,53.49 155.96,53.47 155.96,53.45
  IN1 w0.097: 155.96,53.45 155.96,51.61 170.63,36.94 170.63,29.75 170.55,29.67 169.88,29.67 169.6,29.39 169.6,28.99 169.88,28.71 170.08,28.71 170.18,28.61 170.18,27.54 170.01,27.37 169.84,27.37 169.45,26.98 169.45,23.89 169.84,23.51 170.02,23.51 170.11,23.41 v2(170.11,23.02)
  BOTTOM w0.076: UC1.AM25 153.57,66.99 v2(153.25,66.66)
  BOTTOM w0.102: v2(170.11,23.02) 170.11,23.32 170.27,23.48 170.6,23.48 170.88,23.76 JDIMM2.29
DDR_B_DQS4: length 92.3
  IN3 w0.076: 159.72,52.99 159.71,53 159.71,53 159.51,53.21 158.96,53.21 157.4,54.76 156.94,54.76 156.42,55.29 156.42,59.33 156.16,59.59 155.71,59.59 v2(155.44,59.32)
  IN3 w0.102: v2(215.15,23.81) 215.15,23.2 215.26,23.1 215.71,23.1 215.81,23.2 215.81,24.45 215.4,24.87 215.4,29.54 197.53,47.4 168.96,47.4 167.64,48.72 164.6,48.72 160.99,52.33 160.85,52.33 160.38,52.33 159.72,52.99
  BOTTOM w0.076: UC1.AV22 155.18,63.4 155.1,63.32 154.95,63.32 154.86,63.23 154.78,63.16 154.78,63.14 154.72,63 154.72,62.8 154.74,62.74 154.79,62.64 154.79,62.51 154.72,62.35 154.72,62.15 154.74,62.1 154.74,62.09 154.79,61.99 154.79,61.8 154.68,61.69 154.68,61.07 154.92,60.83 154.92,59.76 155.12,59.56 155.19,59.56 v2(155.44,59.32)
  BOTTOM w0.102: v2(215.15,23.81) 215.15,23.53 215.05,23.43 214.67,23.43 214.57,23.53 214.57,24.5 214.99,24.93 215.37,24.93 215.88,25.43 JDIMM2.171
DDR_B_DQS5: length 54.5
  IN1 w0.076: v2(158.92,57.29) 158.92,57.16 158.79,57.03 158.41,57.03 158.21,56.84 158.21,55.2 159.84,53.57 159.84,53.47
  IN1 w0.097: v2(176.35,24.31) 176.35,23.86 176.47,23.74 176.64,23.74 176.79,23.89 176.79,25 176.08,25.71 176.08,36.98 159.84,53.21 159.84,53.47
  BOTTOM w0.076: v2(158.92,57.29) 158.97,57.24 158.97,57.06 158.9,57 158.77,57 158.66,56.89 158.48,56.89 158.05,57.32 158.05,60.16 157.15,61.06 157.15,61.47 157.39,61.71 157.39,62.03 157.36,62.08 157.37,62.08 157.31,62.19 157.31,62.32 157.32,62.34 157.36,62.42 157.39,62.47 157.39,62.86 157.43,62.9 UC1.AW18
  BOTTOM w0.102: JDIMM2.47 176.28,25.41 176.16,25.29 175.95,25.29 175.89,25.23 175.89,25.03 175.74,24.88 175.74,23.88 175.9,23.71 176.27,23.71 176.35,23.79 v2(176.35,24.31)
DDR_B_DQS6: length 98.2
  IN3 w0.076: 161.79,57.11 161.77,57.11 161.75,57.13 161.41,57.13 160.33,58.21 160.33,59.68 159.31,60.7 158.6,60.7 157.96,61.34 157.96,61.53 157.24,62.24 156.43,62.24 155.45,63.22 155.45,63.23 155.43,63.25 155.43,66.2 155.64,66.42 155.75,66.42 155.86,66.52 v2(156,66.66)
  IN3 w0.102: v2(219.88,21.5) 219.88,21.17 220.13,20.92 220.47,20.92 220.71,21.15 220.71,22.01 220.59,22.14 220.59,29.7 199.08,51.21 177.13,51.21 175.78,52.56 173.52,52.56 172.74,53.35 165.72,53.35 161.95,57.11 161.79,57.11
  BOTTOM w0.076: UC1.AM21 156.32,66.99 v2(156,66.66)
  BOTTOM w0.102: v2(219.88,21.5) 219.88,21.32 220.11,21.09 220.45,21.09 220.79,20.76 220.79,19.57 220.98,19.38 JDIMM2.188
DDR_B_DQS7: length 63.5
  IN1 w0.076: v2(157.9,66.66) 157.9,66.51 157.72,66.33 157.5,66.33 157.33,66.17 157.33,64.33 157.48,64.18 157.48,63.17 159.44,61.21 159.44,60.95 161.73,58.67 161.73,57.68 163.85,55.56 163.85,54.87 164.16,54.56 164.16,54.54 164.17,54.53
  IN1 w0.097: 164.17,54.53 176.71,41.99 176.71,41.99 181.33,37.37 181.33,23.32 181.69,22.96 181.69,21.32 182.4,20.61 182.4,19.5 182.16,19.25 181.46,19.25 181.17,19.54 181.17,20.01 181.37,20.21 v2(181.81,20.21)
  BOTTOM w0.076: UC1.AM18 158.23,66.99 v2(157.9,66.66)
  BOTTOM w0.102: JDIMM2.64 181.38,19.44 181.3,19.52 181.3,20 181.5,20.21 v2(181.81,20.21)
DDR_B_DQS#0: length 88.1
  IN3 w0.076: v2(149.82,59.97) 150.08,59.71 150.55,59.71 151.02,59.24 151.02,54.27 151.27,54.02 151.27,53.41 151.58,53.1 151.58,52.51
  IN3 w0.102: 151.58,52.51 151.58,49.95 162.07,39.46 194.04,39.46 204.01,29.49 204.01,27.44 204.62,26.82 204.62,23.69 204.71,23.61 204.94,23.61 205.1,23.77 v2(205.1,24.15)
  BOTTOM w0.076: UC1.AW30 150.04,63.08 149.97,63.15 149.88,63.15 149.8,63.07 149.75,62.97 149.75,62.84 149.82,62.68 149.82,62.47 149.8,62.42 149.76,62.34 149.75,62.32 149.75,62.19 149.78,62.13 149.8,62.08 149.8,62.08 149.82,62.03 149.82,61.74 149.58,61.49 149.58,60.88 149.45,60.75 149.45,59.79 149.56,59.68 149.71,59.68 149.82,59.79 v2(149.82,59.97)
  BOTTOM w0.102: JDIMM2.135 205.08,25.4 205.23,25.26 205.44,25.26 205.7,25 205.7,23.66 205.52,23.48 205.2,23.48 205.02,23.66 205.02,24.07 v2(205.1,24.15)
DDR_B_DQS#1: length 56.6
  IN1 w0.076: v2(153.12,57.04) 152.88,57.28 152.56,57.28 152.21,56.93 152.21,53.45
  IN1 w0.097: v2(165.27,20.67) 165.27,20.79 165.42,20.94 165.75,20.94 165.93,20.76 165.93,20.34 165.82,20.23 164.89,20.23 164.63,20.48 164.63,21.02 165.22,21.6 165.22,25.19 163.22,27.19 163.22,38.91 152.21,49.92 152.21,53.45
  BOTTOM w0.076: UC1.AV26 152.25,63.33 152.25,63.15 152.09,62.99 152.09,62.51 152.08,62.49 152.02,62.37 152.02,62.13 152.09,61.99 152.09,61.69 151.81,61.41 151.72,61.32 151.72,60.86 152.18,60.4 152.18,57.8 152.76,57.23 152.93,57.23 v2(153.12,57.04)
  BOTTOM w0.102: JDIMM2.10 165.18,19.15 165.4,19.37 165.4,19.9 165.7,20.21 165.7,20.56 165.59,20.67 v2(165.27,20.67)
DDR_B_DQS#2: length 95.1
  IN3 w0.076: 155.57,52.51 155.57,52.53 155.54,52.55 155.54,53.44 154.1,54.89 154.1,54.9 154.04,54.95 154.04,60.31 153.1,61.25 153.1,61.99 150.97,64.12 150.97,66.2 151.07,66.31 151.24,66.31 151.34,66.2 v2(151.34,66.01)
  IN3 w0.102: 155.57,52.51 155.57,51.78 163.6,43.75 188.06,43.75 188.5,43.3 195.55,43.3 209.91,28.94 209.91,26.63 210.68,25.86 210.68,22.74 210.58,22.64 210.58,20.81 210.68,20.71 211.09,20.71 211.19,20.81 v2(211.19,21.5)
  BOTTOM w0.076: UC1.AN28 151.41,66.01 v2(151.34,66.01)
  BOTTOM w0.102: v2(211.19,21.5) 211.19,21.3 210.99,21.09 210.54,21.09 210.32,20.87 210.32,19.44 210.18,19.3 JDIMM2.152
DDR_B_DQS#3: length 58.1
  IN1 w0.076: v2(153.25,66.01) 153.25,66.26 153.2,66.31 152.93,66.31 152.82,66.2 152.82,63.75 154.5,62.07 154.5,60.84 154.63,60.72 154.63,55.1 155.49,54.24 155.62,54.24 156.14,53.72 156.14,53.49 156.15,53.47 156.15,53.45
  IN1 w0.097: v2(170.11,24.29) 170.32,24.08 170.32,23.81 170.21,23.7 169.92,23.7 169.65,23.97 169.65,26.9 169.92,27.17 170.09,27.17 170.37,27.46 170.37,28.69 170.16,28.9 169.96,28.9 169.79,29.07 169.79,29.31 169.96,29.48 170.63,29.48 170.82,29.67 170.82,37.02 156.15,51.69 156.15,53.45
  BOTTOM w0.076: v2(153.25,66.01) 153.54,66.01 153.64,66.11 UC1.AN25
  BOTTOM w0.102: JDIMM2.27 170.28,25.39 170.4,25.27 170.54,25.27 170.66,25.14 170.66,23.83 170.52,23.69 170.32,23.69 170.11,23.9 v2(170.11,24.29)
DDR_B_DQS#4: length 92.5
  IN3 w0.076: 159.87,53.14 159.84,53.17 159.78,53.17 159.58,53.37 159.03,53.37 157.47,54.93 157.01,54.93 156.58,55.36 156.58,59.4 156.22,59.76 155.66,59.76 v2(155.45,59.97)
  IN3 w0.102: v2(215.15,22.54) 215.15,22.67 215.38,22.89 215.79,22.89 216.02,23.12 216.02,24.54 215.6,24.95 215.6,29.62 197.62,47.61 169.04,47.61 167.73,48.93 164.69,48.93 161.08,52.54 160.94,52.54 160.94,52.54 160.47,52.54 159.87,53.14
  BOTTOM w0.076: v2(155.45,59.97) 155.45,59.83 155.35,59.73 155.18,59.73 155.08,59.83 155.08,60.9 154.84,61.14 154.84,61.62 154.96,61.74 154.96,62.03 154.93,62.08 154.88,62.19 154.88,62.32 154.89,62.34 154.93,62.42 154.96,62.47 154.96,62.68 154.88,62.84 154.88,62.97 154.93,63.07 155.01,63.15 155.1,63.15 155.18,63.08 UC1.AW22
  BOTTOM w0.102: JDIMM2.169 215.28,25.43 215.36,25.34 215.36,25.22 215.28,25.14 214.9,25.14 214.37,24.6 214.37,23.45 214.59,23.23 214.85,23.23 215.15,22.92 v2(215.15,22.54)
DDR_B_DQS#5: length 54.8
  IN1 w0.076: v2(158.92,56.64) 158.69,56.87 158.47,56.87 158.37,56.77 158.37,55.27 160.04,53.61 160.04,53.47
  IN1 w0.097: v2(176.35,23.04) 176.35,23.45 176.44,23.54 176.72,23.54 176.98,23.81 176.98,25.08 176.27,25.79 176.27,37.06 160.04,53.29 160.04,53.47
  BOTTOM w0.076: UC1.AV18 157.38,63.33 157.38,63.15 157.22,62.99 157.22,62.51 157.15,62.35 157.15,62.15 157.22,61.99 157.22,61.78 156.98,61.54 156.98,60.99 157.86,60.12 157.86,57.24 158.4,56.7 158.86,56.7 v2(158.92,56.64)
  BOTTOM w0.102: JDIMM2.45 175.68,25.12 175.52,24.97 175.52,23.8 175.82,23.51 176.14,23.51 176.35,23.3 v2(176.35,23.04)
DDR_B_DQS#6: length 98.2
  IN3 w0.076: v2(156,66.01) 156,66.14 155.88,66.25 155.71,66.25 155.59,66.14 155.59,63.32 155.61,63.3 155.61,63.29 156.5,62.41 157.31,62.41 158.12,61.6 158.12,61.41 158.67,60.87 159.38,60.87 160.49,59.75 160.49,58.28 161.47,57.3 161.75,57.3 161.77,57.32 161.79,57.32
  IN3 w0.102: 161.79,57.32 162.04,57.32 165.8,53.55 172.83,53.55 173.61,52.77 175.87,52.77 177.22,51.42 199.17,51.42 220.8,29.79 220.8,22.22 220.92,22.1 220.92,21.07 220.56,20.71 220.16,20.71 219.88,20.43 v2(219.88,20.23)
  BOTTOM w0.076: v2(156,66.01) 156.32,66.34 UC1.AN21
  BOTTOM w0.102: JDIMM2.186 220.38,19.38 220.58,19.58 220.58,20.67 220.37,20.89 220.01,20.89 219.88,20.76 v2(219.88,20.23)
DDR_B_DQS#7: length 63.7
  IN1 w0.076: 164.3,54.67 164.29,54.68 164.27,54.68 164.01,54.94 164.01,55.62 161.89,57.75 161.89,58.74 159.61,61.02 159.61,61.28 157.65,63.24 157.65,64.25 157.5,64.4 157.5,66.1 157.56,66.17 157.75,66.17 v2(157.9,66.01)
  IN1 w0.097: 164.3,54.67 164.57,54.4 164.57,54.4 181.52,37.45 181.52,23.4 181.88,23.04 181.88,21.4 182.59,20.69 182.59,19.42 182.24,19.06 181.38,19.06 180.98,19.46 180.98,19.77 v2(180.54,20.21)
  BOTTOM w0.076: v2(157.9,66.01) 158.23,66.34 UC1.AN18
  BOTTOM w0.102: v2(180.54,20.21) 180.64,20.31 180.99,20.31 181.09,20.2 181.09,19.54 180.78,19.23 JDIMM2.62
DDR_B_MA0: length 86.1
  IN3 w0.076: 143.62,64.02 143.95,64.35 143.95,65.03 v2(143.62,65.36)
  IN3 w0.132: 143.62,64.02 143.62,57.87 143.45,57.7
  IN3 w0.152: 143.45,57.7 143.13,57.38 143.13,45.78 158.08,30.83 163.33,30.83 164.76,29.41 188.38,29.41 193.4,24.39 193.4,20.89 v2(193.38,20.87)
  BOTTOM w0.076: v2(143.62,65.36) 143.94,65.69 UC1.AP40
  BOTTOM w0.152: v2(193.38,20.87) 193.98,20.27 JDIMM2.98
DDR_B_MA1: length 87.9
  IN3 w0.132: 142.84,58.89 143.39,59.45 143.39,64.51 v2(143.59,64.71)
  IN3 w0.152: v2(192.54,22.74) 192.97,23.18 192.97,24.21 188.23,28.95 186.03,28.95 185.87,28.8 185.87,27.67 185.72,27.52 185.42,27.52 185.26,27.67 185.26,28.8 185.11,28.95 164.4,28.95 162.95,30.4 157.73,30.4 142.25,45.88 142.25,54.79 142.62,55.16 142.62,57.47 142.77,57.62 142.77,58.82 142.84,58.89
  BOTTOM w0.076: v2(143.59,64.71) 143.92,65.04 UC1.AR40
  BOTTOM w0.152: JDIMM2.97 193.68,23.88 v2(192.54,22.74)
DDR_B_MA2: length 89.7
  IN3 w0.132: 141.75,57.54 142.15,57.94 142.15,64.86 v2(142.71,65.41)
  IN3 w0.152: 141.75,57.54 141.75,55.52 141.34,55.1 141.27,55.03 141.27,45.55 157.41,29.41 161.79,29.41 163.63,27.57 168.77,27.57 169.7,26.63 169.98,26.63 170.14,26.78 170.14,27.34 170.29,27.49 170.59,27.49 170.75,27.34 170.75,26.78 170.9,26.63 171.2,26.63 171.36,26.78 171.36,27.34 171.51,27.49 171.81,27.49 171.96,27.34 171.96,26.78 172.12,26.63 189.25,26.63 191.91,23.97 191.91,22.24 192.93,21.22 192.93,20.05 v2(193.38,19.6)
  BOTTOM w0.076: v2(142.71,65.41) 142.98,65.69 UC1.AP42
  BOTTOM w0.152: JDIMM2.96 v2(193.38,19.6)
DDR_B_MA3: length 89.7
  IN3 w0.132: v2(142.71,64.76) 142.51,64.57 142.51,59.18
  IN3 w0.152: 142.51,59.18 142.51,57.97 142.18,57.64 142.18,55.34 141.82,54.97 141.82,45.7 157.65,29.86 162.47,29.86 163.84,28.49 172.61,28.49 172.76,28.34 172.76,27.22 172.91,27.06 176.27,27.06 176.43,27.22 176.43,28.23 176.58,28.38 176.88,28.38 177.04,28.23 177.04,27.22 177.19,27.06 177.49,27.06 177.65,27.22 177.65,28.23 177.8,28.38 178.1,28.38 178.25,28.23 178.25,27.22 178.41,27.06 181.01,27.06 181.16,27.22 181.16,28.13 181.31,28.28 181.62,28.28 181.77,28.13 181.77,27.22 181.92,27.06 189.49,27.06 v2(192.54,24.01)
  BOTTOM w0.076: UC1.AR42 142.98,65.04 v2(142.71,64.76)
  BOTTOM w0.152: JDIMM2.95 193.08,24.55 v2(192.54,24.01)
DDR_B_MA4: length 95.3
  IN3 w0.076: v2(140.8,64.79) 141.82,63.77
  IN3 w0.089: 141.82,63.77 141.82,58.3 141.5,57.99 141.5,57.72
  IN3 w0.152: v2(192.15,21.35) 191.45,22.05 191.45,23.82 189.07,26.2 168.66,26.2 168.51,26.35 168.51,26.91 168.36,27.06 168.05,27.06 167.9,26.91 167.9,26.35 167.75,26.2 167.44,26.2 167.29,26.35 167.29,26.91 167.14,27.06 166.83,27.06 166.68,26.91 166.68,26.35 166.53,26.2 166.22,26.2 166.07,26.35 166.07,26.91 165.92,27.06 165.61,27.06 165.46,26.91 165.46,26.35 165.31,26.2 165,26.2 164.85,26.35 164.85,26.91 164.7,27.06 164.39,27.06 164.24,26.91 164.24,26.35 164.09,26.2 163.72,26.2 163.57,26.35 163.57,26.96 163.41,27.11 163.06,27.11 162.91,26.96 162.91,26.35 162.75,26.2 162.07,26.2 161.92,26.35 161.92,28.67 161.64,28.95 157.18,28.95 140.39,45.73 140.39,54.55 141.5,55.65 141.5,57.72
  BOTTOM w0.076: v2(140.8,64.79) 141.05,65.04 UC1.AR45
  BOTTOM w0.152: JDIMM2.92 192.18,19.35 192.62,19.8 192.62,20.87 v2(192.15,21.35)
DDR_B_MA5: length 92.9
  IN3 w0.076: 141.07,57.54 141.07,58.41 141.01,58.47 141.01,63.79 140.44,64.36 140.44,65.08 v2(140.8,65.44)
  IN3 w0.152: 141.07,57.54 141.07,56.38 140.64,55.96 140.64,55.5 139.94,54.8 139.94,45.57 157.15,28.37 158.78,28.37 158.93,28.21 158.93,26.63 159.08,26.48 159.39,26.48 159.54,26.63 159.54,28.21 159.69,28.37 160,28.37 160.15,28.21 160.15,26.48 160.3,26.33 160.61,26.33 160.76,26.48 160.76,28.21 160.91,28.37 161.33,28.37 161.48,28.21 161.48,26.17 161.89,25.77 188.89,25.77 v2(190.97,23.68)
  BOTTOM w0.076: v2(140.8,65.44) 141.05,65.69 UC1.AP45
  BOTTOM w0.152: JDIMM2.91 191.88,24.59 v2(190.97,23.68)
DDR_B_MA6: length 98.4
  IN3 w0.076: v2(139.83,62.28) 139.48,61.93 139.48,61.43 139.74,61.17 139.94,61.17 140.58,60.53 140.58,57.74 140.39,57.54
  IN3 w0.152: v2(192.15,20.08) 190.52,21.71 190.52,22.26 189.94,22.83 189.94,23.34 188.38,24.9 183.49,24.9 180.04,21.46 178.53,21.46 178.37,21.61 178.37,22.19 178.22,22.34 177.92,22.34 177.76,22.19 177.76,21.61 177.61,21.46 177.31,21.46 177.16,21.61 177.16,22.19 177,22.34 176.7,22.34 176.55,22.19 176.55,21.61 176.39,21.46 175.94,21.46 175.78,21.61 175.78,23.28 175.63,23.43 175.33,23.43 175.17,23.28 175.17,21.61 175.02,21.46 174.67,21.46 174.51,21.61 174.51,23.46 174.36,23.61 174.06,23.61 173.9,23.46 173.9,21.61 173.75,21.46 164.96,21.46 161.01,25.41 158.81,25.41 139.01,45.21 139.01,54.88 139.78,55.65 139.78,56.13 140.39,56.74 140.39,57.54
  BOTTOM w0.076: UC1.AW46 140.15,62.58 139.85,62.28 v2(139.83,62.28)
  BOTTOM w0.152: JDIMM2.90 191.58,19.51 v2(192.15,20.08)
DDR_B_MA7: length 98.1
  IN3 w0.076: 139.96,57.54 139.96,58.6 140.42,59.06 140.42,60.19 v2(139.85,60.76)
  IN3 w0.152: 139.96,57.54 139.96,56.75 139.35,56.14 139.35,55.83 138.55,55.03 138.55,44.99 148.45,35.09 148.45,34.17 149.25,33.37 149.47,33.37 149.74,33.65 149.96,33.65 150.17,33.44 150.17,33.22 149.9,32.94 149.9,32.73 150.11,32.51 150.33,32.51 150.61,32.79 150.82,32.79 151.04,32.57 151.04,32.36 150.76,32.08 150.76,31.87 150.98,31.65 151.19,31.65 151.47,31.93 151.68,31.93 151.9,31.71 151.9,31.49 151.62,31.22 151.62,31 151.84,30.79 152.05,30.79 152.33,31.06 152.55,31.06 152.76,30.85 152.76,30.63 152.49,30.36 152.49,30.14 152.7,29.92 152.92,29.92 153.19,30.2 153.41,30.2 153.63,29.99 153.63,29.77 153.35,29.49 153.35,29.28 153.56,29.06 153.78,29.06 154.06,29.34 154.27,29.34 154.49,29.12 154.49,28.91 154.21,28.63 154.21,28.41 154.43,28.2 154.64,28.2 154.92,28.48 155.13,28.48 155.35,28.26 155.35,28.04 155.07,27.77 155.07,27.55 157.65,24.98 160.72,24.98 163.74,21.96 163.74,21.35 165.89,19.2 181.07,19.2 181.22,19.35 181.22,22.03 181.81,22.62 183.91,22.62 184.75,23.46 184.75,23.83 185.39,24.47 188.21,24.47 189.47,23.2 189.47,22.23 189.7,22 189.7,21.82 v2(190.36,21.16)
  BOTTOM w0.076: v2(139.85,60.76) 140.24,61.16 UC1.AY46
  BOTTOM w0.152: JDIMM2.86 190.38,19.13 190.82,19.57 190.82,20.7 v2(190.36,21.16)
DDR_B_MA8: length 96.5
  IN3 w0.076: 140.82,57.54 140.82,58 140.82,58 140.82,61.13 140.38,61.58 v2(139.84,61.58)
  IN3 w0.152: v2(190.97,22.41) 190.38,23.01 190.38,23.57 188.61,25.34 179.95,25.34 179.8,25.18 179.8,22.21 179.64,22.06 179.34,22.06 179.19,22.21 179.19,25.18 179.03,25.34 177.68,25.34 177.53,25.18 177.53,23.89 177.38,23.74 177.07,23.74 176.92,23.89 176.92,25.18 176.77,25.34 175.83,25.34 175.68,25.18 175.68,24.32 175.53,24.17 175.22,24.17 175.07,24.32 175.07,25.18 174.92,25.34 161.71,25.34 161.28,25.77 161.27,25.77 161.19,25.84 158.99,25.84 158.01,26.83 158.01,27.04 158.45,27.49 158.45,27.71 158.24,27.92 158.02,27.92 157.57,27.47 157.36,27.47 139.45,45.39 139.45,54.71 140.21,55.47 140.21,56.06 140.82,56.67 140.82,57.54
  BOTTOM w0.076: UC1.AY47 139.49,61.93 v2(139.84,61.58)
  BOTTOM w0.152: JDIMM2.89 191.28,26.07 191.28,25.13 190.53,24.38 190.53,22.86 v2(190.97,22.41)
DDR_B_MA9: length 99.2
  IN3 w0.076: v2(139.85,63.58) 139.8,63.58 138.95,62.73 138.95,60.44 137.85,59.34 137.85,58.23 137.17,57.54
  IN3 w0.152: 137.17,57.54 137.17,56.83 135.54,55.2 135.54,44.3 137.27,42.56 137.27,42.35 136.99,42.06 136.99,41.85 137.21,41.63 137.42,41.63 137.7,41.92 137.92,41.92 138.14,41.7 138.14,41.49 137.85,41.2 137.85,40.99 138.07,40.77 138.28,40.77 138.57,41.05 138.78,41.05 139,40.84 139,40.62 138.71,40.34 138.71,40.12 138.93,39.91 139.15,39.91 139.43,40.19 139.65,40.19 139.86,39.98 139.86,39.76 139.58,39.48 139.58,39.26 139.79,39.05 140.01,39.05 140.29,39.33 140.51,39.33 140.72,39.11 140.72,38.9 140.44,38.61 140.44,38.4 162.18,16.66 183.91,16.66 187.54,20.29 187.54,22.21 188.08,22.74 v2(188.61,22.74)
  BOTTOM w0.076: v2(139.85,63.58) 139.99,63.58 UC1.AU46
  BOTTOM w0.152: JDIMM2.85 190.08,24.21 v2(188.61,22.74)
DDR_B_MA10: length 102.8
  IN3 w0.152: v2(146.05,68.12) 145.57,67.64 145.57,58.31 145.24,57.97 145.24,46.87 159.17,32.93 168.73,32.93 168.88,32.78 168.88,31.66 169.04,31.51 169.34,31.51 169.49,31.66 169.49,32.78 169.65,32.93 169.95,32.93 170.1,32.78 170.1,31.66 170.26,31.51 170.56,31.51 170.71,31.66 170.71,32.78 170.86,32.93 171.17,32.93 171.32,32.78 171.32,31.66 171.47,31.51 171.78,31.51 171.93,31.66 171.93,32.78 172.08,32.93 172.39,32.93 172.54,32.78 172.54,31.66 172.69,31.51 173,31.51 173.15,31.66 173.15,32.78 173.3,32.93 173.61,32.93 173.76,32.78 173.76,31.66 173.91,31.51 174.22,31.51 174.37,31.66 174.37,32.78 174.52,32.93 174.83,32.93 174.98,32.78 174.98,31.66 175.13,31.51 175.44,31.51 175.59,31.66 175.59,32.78 175.74,32.93 176.05,32.93 176.2,32.78 176.2,31.66 176.35,31.51 176.66,31.51 176.81,31.66 176.81,32.78 176.96,32.93 177.27,32.93 177.42,32.78 177.42,31.66 177.57,31.51 189.7,31.51 192.41,28.8 193.55,28.8 194.17,28.17 194.17,27.55 196.65,25.07 v2(196.65,24.86)
  BOTTOM w0.076: UC1.AK36 146.22,68.29 v2(146.05,68.12)
  BOTTOM w0.152: JDIMM2.107 196.68,24.9 v2(196.65,24.86)
DDR_B_MA11: length 98.1
  IN3 w0.076: v2(139.85,60.11) 140.23,59.73 140.23,59.27 139.64,58.69 139.64,57.76 139.42,57.54
  IN3 w0.152: 139.42,57.54 138.96,57.09 138.96,56.05 137.67,54.77 137.67,45.25 143.41,39.51 143.41,39.3 143.17,39.06 143.17,38.84 143.39,38.63 143.6,38.63 143.85,38.87 144.06,38.87 144.28,38.65 144.28,38.44 144.04,38.19 144.04,37.98 144.25,37.76 144.47,37.76 144.71,38 144.92,38 145.14,37.79 145.14,37.57 144.9,37.33 144.9,37.12 145.11,36.9 145.33,36.9 145.57,37.14 145.79,37.14 146,36.93 146,36.71 145.76,36.47 145.76,36.25 145.98,36.04 146.19,36.04 146.43,36.28 146.65,36.28 146.86,36.06 146.86,35.85 146.62,35.61 146.62,35.39 146.84,35.18 147.05,35.18 147.3,35.42 147.51,35.42 147.73,35.2 147.73,34.99 147.49,34.74 147.49,34.53 157.47,24.55 160.54,24.55 163.31,21.78 163.31,20.1 164.62,18.79 183.01,18.79 183.91,19.7 183.91,21.95 185.18,23.22 185.18,23.65 185.57,24.04 188.03,24.04 189.04,23.02 189.04,22.05 189.27,21.83 189.27,20.98 v2(190.36,19.89)
  BOTTOM w0.076: UC1.AV47 139.13,62.93 139.13,61.74 139.44,61.42 139.44,60.52 v2(139.85,60.11)
  BOTTOM w0.152: v2(190.36,19.89) 189.78,19.3 JDIMM2.84
DDR_B_MA12: length 95.3
  IN3 w0.076: 135.13,54.67 135.13,55.89 137.65,58.41 137.65,59.43 137.84,59.62 137.84,61.81 v2(138.26,62.22)
  IN3 w0.152: v2(188.01,22.08) 188,22.08 188,20.17 184.08,16.25 161.98,16.25 135.13,43.09 135.13,54.67
  BOTTOM w0.076: v2(138.26,62.22) 138.33,62.3 138.78,62.3 138.96,62.48 138.96,63.18 139.37,63.59 UC1.AU47
  BOTTOM w0.152: JDIMM2.83 189.48,24.58 188,23.1 188,22.08 v2(188.01,22.08)
DDR_B_MA13: length 103.8
  IN3 w0.076: v2(147.95,68.03) 148.55,67.43 148.55,57.66 148.66,57.54
  IN3 w0.152: v2(199.53,21.82) 199.53,21.87 199.96,22.3 199.96,28.64 193.08,35.52 185.8,35.52 185.65,35.67 185.65,35.8 185.5,35.95 185.19,35.95 185.04,35.8 185.04,35.67 184.89,35.52 184.58,35.52 184.43,35.67 184.43,35.8 184.28,35.95 183.97,35.95 183.82,35.8 183.82,35.67 183.67,35.52 183.36,35.52 183.21,35.67 183.21,35.8 183.06,35.95 182.75,35.95 182.6,35.8 182.6,35.67 182.45,35.52 182.14,35.52 181.99,35.67 181.99,35.8 181.84,35.95 181.53,35.95 181.38,35.8 181.38,35.67 181.23,35.52 180.92,35.52 180.77,35.67 180.77,35.8 180.62,35.95 180.31,35.95 180.16,35.8 180.16,35.67 180.01,35.52 179.7,35.52 179.55,35.67 179.55,35.8 179.4,35.95 179.09,35.95 178.94,35.8 178.94,35.67 178.79,35.52 178.49,35.52 178.33,35.67 178.33,35.8 178.18,35.95 177.88,35.95 177.72,35.8 177.72,35.67 177.57,35.52 177.27,35.52 177.11,35.67 177.11,35.8 176.96,35.95 176.66,35.95 176.5,35.8 176.5,35.67 176.35,35.52 176.05,35.52 175.89,35.67 175.89,35.8 175.74,35.95 175.44,35.95 175.28,35.8 175.28,35.67 175.13,35.52 174.83,35.52 174.68,35.67 174.68,35.8 174.52,35.95 174.22,35.95 174.07,35.8 174.07,35.67 173.91,35.52 173.61,35.52 173.46,35.67 173.46,35.8 173.3,35.95 173,35.95 172.85,35.8 172.85,35.67 172.69,35.52 172.39,35.52 172.24,35.67 172.24,35.8 172.08,35.95 171.78,35.95 171.63,35.8 171.63,35.67 171.47,35.52 171.17,35.52 171.02,35.67 171.02,35.8 170.87,35.95 170.56,35.95 170.41,35.8 170.41,35.67 170.26,35.52 169.95,35.52 169.8,35.67 169.8,35.8 169.65,35.95 169.34,35.95 169.19,35.8 169.19,35.67 169.04,35.52 168.73,35.52 168.58,35.67 168.58,35.8 168.43,35.95 168.12,35.95 167.97,35.8 167.97,35.67 167.82,35.52 167.51,35.52 167.36,35.67 167.36,35.8 167.21,35.95 166.9,35.95 166.75,35.8 166.75,35.67 166.6,35.52 166.29,35.52 166.14,35.67 166.14,35.8 165.99,35.95 165.68,35.95 165.53,35.8 165.53,35.67 165.38,35.52 165.07,35.52 164.92,35.67 164.92,35.8 164.77,35.95 164.46,35.95 164.31,35.8 164.31,35.67 164.16,35.52 163.85,35.52 163.7,35.67 163.7,35.8 163.55,35.95 163.25,35.95 163.09,35.8 163.09,35.67 162.94,35.52 162.64,35.52 162.48,35.67 162.48,35.8 162.33,35.95 162.03,35.95 161.87,35.8 161.87,35.67 161.72,35.52 161.42,35.52 161.26,35.67 161.26,35.8 161.11,35.95 160.81,35.95 160.65,35.8 160.65,35.67 160.5,35.52 160.25,35.52 148.02,47.75 148.02,55.82 148.66,56.46 148.66,57.54
  BOTTOM w0.076: v2(147.95,68.03) 148.21,68.29 UC1.AK33
  BOTTOM w0.152: v2(199.53,21.82) 200.28,22.57 JDIMM2.119
DDR_B_MA14: length 100.1
  IN3 w0.076: 134.38,54.67 134.38,55.54 137.47,58.62 137.47,59.5 137.64,59.67 137.64,63.44 138.17,63.97 139.14,63.97 139.85,64.67 v2(139.85,64.84)
  IN3 w0.152: v2(188.58,19.65) 188.58,19.41 187.64,18.48 187.64,18.26 188.32,17.59 188.32,17.37 188.1,17.15 187.89,17.15 187.21,17.83 187,17.83 186.78,17.61 186.78,17.4 187.37,16.81 187.37,16.6 187.15,16.38 186.93,16.38 186.35,16.97 186.13,16.97 185.92,16.75 185.92,16.53 186.48,15.98 186.48,15.76 186.26,15.54 186.05,15.54 185.49,16.1 185.27,16.1 184.65,15.48 161.79,15.48 134.38,42.89 134.38,54.67
  BOTTOM w0.076: UC1.AR46 140.23,64.93 140.15,64.84 v2(139.85,64.84)
  BOTTOM w0.152: JDIMM2.80 v2(188.58,19.65)
