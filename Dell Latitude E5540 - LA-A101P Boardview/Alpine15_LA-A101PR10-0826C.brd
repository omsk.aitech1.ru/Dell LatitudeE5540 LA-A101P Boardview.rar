# Allegro board Alpine15_LA-A101PR10-0826C.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
+3.3V_RUN on IN1 (solid shape): 215.74,143.95 215.74,142.48 215.13,141.87 215.13,132.19 214.95,132.02 213.78,132.02 213.35,132.45 213.35,143.78 213.73,144.16 215.54,144.16
+3.3V_RUN on IN1 (solid shape): 186.31,108.94 186.31,106.4 185.79,105.88 181.66,105.88 178.98,103.2 175.75,103.2 175.35,103.59 175.35,104.61 175.57,104.82 178.71,104.82 183.29,109.41 185.84,109.41
+3.3V_RUN on IN1 (solid shape): 31.75,23.23 31.97,23.16 32.19,23.23 32.81,23.23 32.82,23.22 34.59,23.22 35.16,22.65 35.16,21.47 34.51,20.81 31.97,20.81 31.13,21.65 31.13,22.8 31.56,23.23
+3.3V_RUN on IN1 (solid shape): 76.81,25.27 77.7,25.27 77.98,24.99 77.98,24.61 77.73,24.35 77.78,24.3 77.78,24.11 75.86,22.19 74.87,22.19 74.19,22.87 74.19,23.81 75.24,24.87 75.32,24.93 75.39,25.01 75.66,25.29 76.79,25.29
+3.3V_RUN on IN1 (solid shape): 95.06,17.18 95.15,17.14 95.15,17.04 95.48,16.54 95.8,17.04 95.81,17.14 95.9,17.18 97.17,17.18 97.43,16.93 97.43,14.77 97.17,14.51 94.97,14.51 94.28,13.82 94.01,13.82 93.93,13.74 93.89,13.74 93.14,12.99 93.07,12.99 93.07,13.05 93.07,13.06 93.09,13.16 93.08,13.27 93.09,13.34 93.15,13.39 93.22,13.98 92.72,13.66 92.7,13.59 92.63,13.55 92.54,13.52 92.46,13.47 92.39,13.44 92.32,13.47 92.04,13.56 91.78,13.42 91.71,13.39 91.64,13.4 91.29,13.42 91.13,13.1 91.1,13.02 91.03,12.99 89.7,12.99 89.12,13.58 89.12,14.89 89.28,15.05 91.6,15.05 91.64,15.09 91.72,15.09 92,15.37 93.13,15.37 93.6,15.84 93.6,15.93 94.01,16.35 94.02,16.35 94.12,16.42 94.19,16.52 94.19,16.53 94.85,17.18
+3.3V_RUN on IN1 (solid shape): outline of 588 points within 159.27,74.28 173.78,77.64
+3.3V_RUN on IN2 (solid shape): 177.52,104.08 177.52,100.91 177.44,100.83 176.21,100.83 175.61,101.44 175.61,104.14 175.79,104.32 177.29,104.32
+3.3V_RUN on IN2 (solid shape): 184.64,83.77 184.65,83.78 186.12,82.31 186.12,81.75 185.94,81.57 184.19,81.57 183.48,82.28 183.48,83.65 183.91,84.09 184.32,84.09
+3.3V_RUN on IN2 (solid shape): outline of 276 points within 175.96,124.57 188.33,133.5
+3.3V_RUN on IN2 (solid shape): outline of 959 points within 170.68,77.91 200.47,119.62
+3.3V_RUN on IN2 (solid shape): outline of 1790 points within 77.44,74.21 104.11,113.14
+3.3V_RUN on IN2 (solid shape): outline of 3043 points within 160.26,155.97 191.81,178.83
+3.3V_RUN on IN2 (solid shape): outline of 3141 points within 210.15,123.74 315.92,176.26
+3.3V_RUN on IN3 (solid shape): 160.9,166.69 160.9,165.26 160.44,164.81 158.08,164.81 157.85,165.04 157.85,165.54 159.32,167.02 160.57,167.02
+3.3V_RUN on IN3 (solid shape): 87.77,47.15 87.77,46.65 87.44,46.32 86.81,46.32 86.43,46.7 86.43,47.89 86.57,48.03 86.9,48.03
+3.3V_RUN on IN3 (solid shape): 97.3,17.89 97.3,16.19 97.13,16.03 95.89,16.03 95.75,16.17 95.75,16.65 95.88,16.78 95.88,17.97 96.16,18.25 96.94,18.25
+3.3V_RUN on IN3 (solid shape): 177.41,104.38 177.41,103.47 177.36,103.42 177.05,103.42 176.42,102.78 175.83,102.78 175.58,103.03 175.58,104.33 175.76,104.51 177.28,104.51
+3.3V_RUN on IN3 (solid shape): 187.19,81.86 187.19,81.25 187.08,81.15 185.61,81.15 185.5,81.25 185.08,81.25 184.88,81.46 184.88,82.17 185.09,82.38 186.67,82.38
+3.3V_RUN on IN3 (solid shape): 144.77,126.69 144.74,126.67 144.54,126.34 144.74,126 144.77,125.98 144.77,123.86 144.63,123.73 143.58,123.73 142.94,124.37 142.94,124.47 142.95,124.48 143.04,124.74 142.94,124.98 142.94,125.57 142.99,125.76 142.94,125.95 142.94,128.35 144.36,129.78 144.77,129.78
+3.3V_RUN on IN3 (solid shape): outline of 228 points within 188.92,155.41 194.73,163.03
+3.3V_RUN on VCC: 98.92,111.16 98.92,116.77 106.39,124.24 112.29,124.24 114.12,126.07 127.6,126.07 127.62,126.05 145.05,126.05 147.62,128.61 150.86,128.61 151.35,128.13 151.35,126.14 152.21,125.28 172.21,125.28 172.41,125.49 179.93,125.49 180.59,126.15 199.4,126.15 200.27,125.28 202.05,125.28 205.05,128.28 211.52,128.28 211.9,127.9 211.9,123.41 209.29,120.79 209.29,113.2 208.6,112.51 194.91,112.51 191.51,115.91 185.62,115.91 183.56,117.97 179.93,117.97 179.59,118.3 179.59,120.28 178.94,120.94 177.71,120.94 177,120.23 177,113.63 174.21,113.63 173.77,113.19 173.35,113.19 173.24,113.3 173.24,113.99 171.27,115.96 154.8,115.96 154.8,115.74 152.69,113.63 116.65,113.63 116.01,112.99 105.96,112.99 104.13,111.16
+3.3V_RUN_AIN on IN2 (solid shape): outline of 768 points within 13.96,18.83 21.6,32.25
+3.3V_RUN_AUDIO on BOTTOM (solid shape): 269.89,174.79 269.89,168.26 271.92,166.23 271.92,163.61 271.67,163.36 270.15,163.36 267.35,166.15 267.35,175.17 267.61,175.42 269.26,175.42
+3.3V_RUN_AUDIO on IN2 (solid shape): outline of 1139 points within 270.4,154.62 315.92,165.62
+3.3V_RUN_AUDIOP on BOTTOM (solid shape): 269.61,180.28 270.19,180.28 270.25,180.22 270.25,179.52 269.74,179 269.74,178.69 270.65,177.77 270.65,175.93 270.32,175.6 268.85,175.6 268.84,175.61 268.84,176.14 268.4,176.14 268.4,175.61 268.39,175.6 267.94,175.6 267.73,175.81 267.73,176.31 268.04,176.62 269.83,176.62 269.83,176.57 269.84,176.52 269.86,176.47 269.88,176.42 269.91,176.38 269.95,176.34 269.99,176.3 270.04,176.28 270.09,176.26 270.14,176.24 270.19,176.24 270.24,176.24 270.3,176.26 270.35,176.28 270.39,176.3 270.43,176.34 270.47,176.38 270.5,176.42 270.52,176.47 270.54,176.52 270.55,176.57 270.55,176.62 270.54,176.68 270.52,176.73 270.5,176.78 270.47,176.82 270.43,176.86 270.39,176.89 270.35,176.92 270.3,176.94 270.24,176.95 270.19,176.95 270.14,176.95 270.09,176.94 270.04,176.92 269.99,176.89 269.95,176.86 269.91,176.82 269.88,176.78 269.86,176.73 269.84,176.68 269.83,176.62 268.04,176.62 268.37,176.95 268.37,178.37 268.11,178.62 268.11,180.63 268.24,180.76 269.13,180.76
+3.3V_RUN_CARD on BOTTOM (solid shape): 19.14,28.18 20.13,28.18 20.27,28.04 20.27,27.89 20.21,27.82 19.12,27.82 19.09,27.85 18.67,27.85 18.46,27.63 18.04,27.63 17.95,27.55 16.32,27.55 16.2,27.67 16.2,28.15 16.3,28.26 19.07,28.26
+3.3V_RUN_CARD on BOTTOM (solid shape): 34.26,51.57 34.26,50.05 34,49.8 32.1,49.8 31.98,49.68 31.98,49.3 31.61,48.93 29.48,48.93 29.4,49.01 29.4,49.63 29.51,49.73 31.55,49.73 31.84,50.02 31.84,51.57 32.12,51.85 33.98,51.85
+3.3V_RUN_CARD on IN1 (solid shape): 18.39,28.74 18.39,27.81 18.26,27.68 17.34,27.68 17.16,27.86 17.16,28.73 17.36,28.93 18.2,28.93
+3.3V_RUN_CARD on IN1 (solid shape): 34.13,52.28 34.13,50.13 33.87,49.87 33.24,49.87 32.88,50.23 32.88,52.18 33.34,52.64 33.77,52.64
+3.3V_RUN_FFS on TOP (solid shape): 219.12,123.1 219.12,122.34 219.14,122.31 219.65,122.31 219.68,122.29 219.68,122.13 219.65,122.11 219.14,122.11 219.12,122.08 219.12,121.27 218.56,120.71 217.26,120.71 217.16,120.81 217.16,121.7 217.31,121.86 218.33,121.86 218.51,122.03 218.51,123.02 218.66,123.17 219.04,123.17
+3.3V_RUN_FFS on IN2 (solid shape): 220.23,127.12 220.23,121.28 219.1,120.15 217.02,120.15 216.81,120.22 216.59,120.15 215.33,120.15 215.15,120.32 215.15,121.91 215.33,122.08 215.64,122.08 215.64,122.08 215.74,122.08 215.83,122.02 215.82,121.92 215.87,121.44 216.35,121.44 216.43,121.47 216.5,121.43 217.02,121.39 217.03,121.91 217.01,122.02 217.1,122.08 217.26,122.08 217.72,122.54 218.02,122.54 219.29,123.81 219.29,125.79 218.61,126.48 216.7,126.48 216.28,126.06 215.07,126.06 214.6,126.53 214.6,127.27 214.85,127.52 219.83,127.52
+3.3V_RUN_TPM on TOP (solid shape): 183.43,147.09 183.43,146.69 183.99,146.69 183.99,146.5 183.43,146.5 183.43,145.98 183.66,145.75 183.66,143.1 183.49,142.94 183.49,141.38 183.39,141.28 183.21,141.28 183.11,141.39 183.11,142.88 182.31,143.67 180.61,143.67 180.23,143.29 180.23,141.39 180.12,141.28 179.97,141.28 179.85,141.4 179.85,145.91 180.31,146.37 181.35,146.37 182.08,147.1 183.42,147.1
+3.3V_RUN_TPM on IN1 (solid shape): outline of 548 points within 175.4,133.46 184.9,145.93
+3.3V_RUN_VDDA on IN3 (solid shape): outline of 1021 points within 176.29,154.98 183.82,163.31
+3.3V_RUN_VDDIO on BOTTOM (solid shape): 176.93,168.77 176.93,167.78 176.47,167.32 176.47,165.57 176.24,165.34 176.24,163.18 176.28,163.14 176.37,162.82 176.69,162.73 176.93,162.5 176.93,161.71 176.8,161.58 176.29,161.58 175.46,162.41 175.46,163.83 175.45,163.84 175.45,168.82 175.5,168.87 176.83,168.87
+3.3V_RUN_VDDIO on IN1 (solid shape): outline of 1718 points within 173.55,154.88 183.43,168.49
+3.3V_SUS on TOP (solid shape): 92.7,23.2 92.7,20.89 92.55,20.74 91.46,20.74 91.38,20.81 91.38,23.23 91.48,23.33 92.57,23.33
+3.3V_SUS on TOP (solid shape): 189.53,111.44 191.76,111.44 191.81,111.39 191.81,110.81 191.68,110.68 190.29,110.68 190.21,110.76 189.75,110.76 189.55,110.55 188.43,110.55 188.36,110.63 188.36,111.44 188.46,111.54 189.42,111.54
+3.3V_SUS on IN1 (solid shape): 205.32,14.64 205.32,13.88 205.12,13.68 203.29,13.68 202.99,13.98 202.99,14.77 203.04,14.82 205.15,14.82
+3.3V_SUS on IN1 (solid shape): 124.5,14.85 124.5,14.67 124.25,14.41 121.66,14.41 121.48,14.59 121.48,15.76 121.76,16.04 123.08,16.04 123.1,16.06 123.28,16.06
+3.3V_SUS on IN2 (solid shape): 192.14,112.41 192.14,111.7 190.9,110.45 189.7,110.45 189.3,110.86 189.3,111.75 190.19,112.64 191.91,112.64
+3.3V_SUS on IN2 (solid shape): 207.97,60.06 207.97,59.17 207.76,58.97 206.24,58.97 205.98,59.22 205.98,59.7 206.27,59.98 206.49,60.09 206.6,60.31 207.71,60.31
+3.3V_SUS on IN3 (solid shape): 206.49,14.08 206.49,13.5 206.26,13.27 204.11,13.27 203.93,13.45 203.93,14.21 204.11,14.39 206.19,14.39
+3.3V_SUS on IN3 (solid shape): 190.54,111.09 190.54,110.37 190.35,110.19 190.32,110.2 190.05,110.2 189.85,110.02 188.99,110.02 188.76,110.25 188.76,110.81 189.3,111.34 190.29,111.34
+3.3V_SUS on IN3 (solid shape): 207.84,59.57 207.84,59.14 207.48,58.79 206.59,58.79 206.06,59.32 206.06,59.7 206.29,59.94 206.31,59.94 206.54,60.06 206.65,60.29 206.67,60.31 207.1,60.31
+3.3V_TP on TOP (solid shape): 133.54,109.1 133.54,108.95 132.93,108.34 132.93,107.73 132.55,107.35 131.94,107.35 130.95,108.34 130.95,109.05 131.08,109.18 133.47,109.18
+3.3V_TP on TOP (solid shape): 150.16,105.57 150.16,104.84 150.23,104.76 150.23,104.56 150.16,104.48 150.16,103.75 150,103.59 149.14,103.59 149.06,103.67 149.06,103.92 149.24,104.1 149.6,104.1 149.72,104.23 149.72,104.94 149.6,105.07 149.14,105.07 149.06,105.14 149.06,105.55 149.19,105.68 150.05,105.68
+3.3V_USBHUB on TOP (solid shape): 221.83,58.74 221.83,57.52 221.55,57.24 220.28,57.24 219.98,57.54 219.98,58.61 220.21,58.84 221.73,58.84
+3.3V_USBHUB on TOP (solid shape): 231.16,50.02 231.16,48.35 231,48.2 228.97,48.2 228.83,48.34 225.9,48.34 225.87,48.37 225.87,49.43 225.95,49.52 226.2,49.52 226.4,49.33 229.67,49.33 230.52,50.18 231,50.18
+3.3V_USBHUB on BOTTOM (solid shape): outline of 319 points within 226.53,48.73 231.08,57.24
+3.3V_USBHUB on IN2 (solid shape): outline of 991 points within 215.43,46.56 229.86,58.53
+3.3V_VTR on TOP (solid shape): 175.07,124.2 175.07,122 174.9,121.83 173.63,121.83 173.27,122.18 171.41,122.18 171.28,122.31 171.28,122.46 171.38,122.56 173.37,122.56 174.01,123.2 174.01,123.86 174.46,124.32 174.95,124.32
+3.3V_WLAN on TOP (solid shape): 321.24,186.82 321.24,184.38 321.05,184.19 319.82,184.19 319.58,184.43 319.58,186.75 319.84,187 321.06,187
+3.3V_WLAN on BOTTOM (solid shape): 321.43,189.01 321.43,186.56 321.11,186.24 320.13,186.24 320.01,186.36 320.01,189.01 320.16,189.16 321.29,189.16
+3.3V_WLAN on BOTTOM (solid shape): 302.61,180.83 302.61,177.44 302.07,176.9 300.16,176.9 299.97,177.09 299.97,180.56 300.4,180.99 302.46,180.99
+3.3V_WLAN on BOTTOM (solid shape): 267.1,160.69 267.1,157.01 266.28,156.2 263.66,156.2 263.66,155.64 263.43,155.64 263.43,156.2 262.91,156.2 262.4,156.71 262.4,158.15 263.45,159.21 263.45,160.31 264.21,161.07 266.72,161.07
+3.3V_WLAN on BOTTOM (solid shape): 326.53,180.76 326.53,177.96 326.28,177.71 326.28,176.95 326.15,176.82 324.12,176.82 323.99,176.95 323.99,178.09 324.37,178.47 324.82,178.47 325.19,178.84 325.19,180.84 325.37,181.01 326.28,181.01
+3.3V_WLAN on VCC: 263.06,156.86 262.99,156.93 262.96,156.93 261.76,158.13 261.76,165.41 264.94,168.59 277.44,168.59 282.49,173.64 282.49,186.63 289.56,186.63 289.56,186.01 290.22,184.4 291.83,183.74 295.83,183.74 297.44,184.4 298.1,186.01 298.1,189.63 331.26,189.63 331.26,177.69 327.06,173.49 293.51,173.49 276.87,156.86 266.49,156.86 266.47,156.88 264.02,156.88 263.99,156.86
+3.3V_WLANP on BOTTOM (solid shape): 263.26,155.99 263.26,155.49 263.85,155.49 263.85,156.02 264.53,156.02 264.58,155.97 265.7,155.97 266.36,155.31 266.36,154.04 265.52,153.2 263.16,153.2 262.91,153.45 262.14,153.45 262.02,153.58 262.02,154.72 262.44,155.14 262.44,155.4 263.06,156.02 263.24,156.02
+5V_ALW on TOP (solid shape): 215.99,35.6 215.99,33.01 215.87,32.88 215.36,32.88 214.95,33.29 214.95,35.62 215.08,35.75 215.84,35.75
+5V_ALW on TOP (solid shape): 109.72,136.28 109.72,132.21 109.24,131.72 109.07,131.72 108.96,131.61 107.01,131.61 106.87,131.75 106.87,136.23 107.56,136.92 109.08,136.92
+5V_ALW on TOP (solid shape): 230.19,41.59 230.19,38.95 230.01,38.77 229.43,38.77 229.38,38.72 228.82,38.72 228.59,38.95 228.59,40.22 229.51,41.13 229.51,41.69 229.58,41.77 230.01,41.77
+5V_ALW on TOP (solid shape): 159.59,110.26 159.59,108.8 159.5,108.71 158.04,108.71 157.66,109.09 157.66,109.34 157.51,109.48 157.51,109.49 157.45,109.58 157.36,109.64 157.35,109.65 157.31,109.69 156.59,109.69 156.48,109.8 156.48,110.17 156.53,110.22 157.37,110.22 157.48,110.11 157.51,110.03 157.56,109.96 157.56,109.92 157.65,109.83 158.33,109.83 158.93,110.42 159.43,110.42
+5V_ALW on TOP (solid shape): 24.65,71.23 24.65,68.11 24.4,67.86 22.15,67.86 22.07,67.9 22.05,67.99 22.21,68.89 22.15,69.8 21.94,70.56 21.58,71.26 21.58,71.26 21.58,71.41 21.73,71.56 24.32,71.56
+5V_ALW on TOP (solid shape): outline of 660 points within 228.57,146.09 246.47,185.76
+5V_ALW on BOTTOM (solid shape): 274.64,184.19 274.64,181.7 274.49,181.55 271.72,181.55 271.59,181.67 271.59,184.19 271.75,184.34 274.49,184.34
+5V_ALW on BOTTOM (solid shape): 256.05,160.54 256.05,159.14 255.82,158.91 253.79,158.91 253.64,159.07 253.64,160.08 253.89,160.34 254.6,160.34 254.83,160.57 256.02,160.57
+5V_ALW on BOTTOM (solid shape): 23.74,71.99 23.74,70.4 23.99,70.14 24.15,70.14 24.65,69.63 24.65,68.11 24.4,67.86 23,67.86 22.59,68.27 22.59,70.43 22.69,70.54 22.69,71.98 22.78,72.06 23.66,72.06
+5V_ALW on BOTTOM (solid shape): 341.95,178.5 341.95,177.08 341.21,176.34 338.9,176.34 337.81,175.25 333.67,175.25 333.42,175.5 333.42,176.82 333.95,177.35 334.79,177.35 334.8,177.33 334.9,177.23 335.03,177.2 336.32,177.2 336.45,177.23 336.55,177.33 336.56,177.35 336.72,177.35 337.15,177.78 337.22,177.81 337.29,177.78 337.91,177.66 338.28,178.18 338.3,178.23 338.35,178.27 338.75,178.27 339.16,178.68 341.77,178.68
+5V_ALW on IN1 (solid shape): outline of 614 points within 241.6,179.67 274.44,185.76
+5V_ALW on IN1 (solid shape): outline of 645 points within 236.87,144.94 256.18,161.96
+5V_ALW on IN2 (solid shape): outline of 10030 points within 13.11,62.04 241.06,150.6
+5V_ALW on IN3 (solid shape): 21.5,124.52 21.5,122.41 19.9,120.81 15.41,120.81 14.98,121.25 14.98,123.61 16.35,124.98 21.05,124.98
+5V_ALW on IN3 (solid shape): 109.64,136.56 109.64,133.82 108.91,133.08 106.44,133.08 105.58,133.95 105.58,135.95 106.52,136.89 109.31,136.89
+5V_ALW on VCC: outline of 114 points within 219.42,18.17 343.63,189.63 ; 12 cut-outs
+5V_ALWP on TOP (solid shape): 229.94,165.06 230.69,165.06 230.69,165.6 231.14,165.6 231.14,165.06 233.85,165.06 234.1,164.81 234.1,162.88 233.95,162.72 232.27,162.72 231.92,162.37 227.78,162.37 227.45,162.7 227.45,165.42 227.52,165.49 227.77,165.49 227.77,165.49 228.16,165.49 228.56,165.08 228.69,165.08 228.7,165.08 228.72,165.06 229.49,165.06 229.49,165.6 229.94,165.6
+5V_ALWP on BOTTOM (solid shape): 232.47,167.2 232.47,162.95 231.77,162.25 231.77,155.39 231.46,155.08 229.28,155.08 229.05,155.31 229.05,161.17 227.5,162.72 227.5,167.27 227.7,167.47 232.2,167.47
+5V_HDD on BOTTOM (solid shape): 224.53,115.51 224.53,114.08 224.63,113.98 224.81,113.98 224.98,113.8 224.98,113.27 224.83,113.12 224.09,113.12 224.07,113.09 224.07,112.56 224.04,112.53 223.89,112.53 223.87,112.56 223.87,113.12 221.66,113.12 221.05,112.51 218.38,112.51 218.13,112.76 218.13,115.56 218.37,115.8 224.23,115.8
+5V_MOD on TOP (solid shape): 232.45,41.29 232.45,37.81 232.73,37.53 232.73,36.83 232.22,36.83 232.22,36.39 232.73,36.39 232.73,35.67 232.68,35.62 230.27,35.62 229.94,35.95 229.94,36.37 230.49,36.37 230.49,36.86 229.94,36.86 229.94,37.81 230.37,38.24 230.37,41.54 230.52,41.69 232.05,41.69
+5V_RUN on TOP (solid shape): 85.92,46.54 85.92,44.97 85.84,44.89 84.93,44.89 84.9,44.92 84.9,46.47 85.11,46.67 85.79,46.67
+5V_RUN on TOP (solid shape): 81.82,61.57 81.82,60.46 81.53,60.16 80.69,60.16 79.63,61.23 79.63,62.42 79.96,62.75 80.64,62.75
+5V_RUN on TOP (solid shape): 61.76,71.89 61.76,70.29 61.38,69.91 60.09,69.91 59.53,70.47 58.49,70.47 57.85,71.11 57.85,71.94 58.08,72.17 61.48,72.17
+5V_RUN on TOP (solid shape): 17.77,102.93 17.77,100.14 17.77,99.02 17.54,98.79 15.99,98.79 15.48,99.3 15.48,100.8 15.08,101.2 15.08,102.81 15.41,103.14 17.57,103.14
+5V_RUN on TOP (solid shape): 94.71,23.18 94.71,21.83 94.91,21.63 94.91,20.31 94.76,20.15 94.1,20.15 93.84,20.41 93.84,21.75 93.39,22.21 93.39,23.18 93.51,23.3 94.58,23.3
+5V_RUN on TOP (solid shape): 22.55,97.67 22.93,97.67 22.95,97.65 22.95,95.24 22.72,95.01 22.11,95.01 21.35,95.77 21,95.77 20.87,95.9 20.87,96.73 21.96,97.83 22.39,97.83
+5V_RUN on TOP (solid shape): 229.81,36.73 230.37,36.73 230.37,36.5 229.81,36.5 229.81,35.99 229.81,35.22 229.63,35.04 228.54,35.04 228.03,35.55 228.03,36.84 228.21,37.02 228.97,37.02 229.15,37.2 229.81,37.2
+5V_RUN on TOP (solid shape): 21.64,119.65 21.64,117.82 21.16,117.33 19.32,117.33 18.01,116.03 18.01,112.15 17.54,111.68 17.54,109.87 17.24,109.56 16.27,109.56 15.84,109.13 15.41,109.13 15.31,109.23 15.31,112.31 16.17,113.17 16.17,119.58 16.77,120.18 21.11,120.18
+5V_RUN on TOP (solid shape): outline of 215 points within 217.26,106.26 224.4,113.09
+5V_RUN on BOTTOM (solid shape): 20.21,119.87 20.21,116.67 18.5,114.96 17.05,114.96 16.81,115.2 16.81,119.77 17.06,120.03 20.06,120.03
+5V_RUN on BOTTOM (solid shape): 267.61,180.63 267.61,179.64 267.43,179.46 266.26,179.46 266.03,179.69 266.03,180.61 266.16,180.73 267.5,180.73
+5V_RUN on BOTTOM (solid shape): 49.6,32.38 49.6,31.38 49.67,31.3 49.93,31.3 49.94,31.29 49.94,30.29 49.85,30.2 48.54,30.2 48.4,30.34 48.4,32.38 48.5,32.49 49.5,32.49
+5V_RUN on BOTTOM (solid shape): 94.2,164.48 94.2,161.86 94.04,161.71 91.14,161.71 90.91,161.94 90.91,163.16 91.14,163.38 92.19,163.38 92.68,163.87 92.68,164.43 92.8,164.55 94.12,164.55
+5V_RUN on BOTTOM (solid shape): 258.69,160.26 260.24,160.26 260.32,160.18 260.32,158.3 260.16,158.15 257.14,158.15 256.84,158.46 256.84,158.99 257.37,159.52 257.37,160.54 257.39,160.57 258.38,160.57
+5V_RUN on BOTTOM (solid shape): 224.96,112.88 224.96,109.85 224.49,109.38 222.9,109.38 222.39,109.89 222.39,112.86 222.49,112.97 223.74,112.97 223.75,112.95 223.75,112.43 224.19,112.43 224.19,112.95 224.22,112.99 224.84,112.99
+5V_RUN on BOTTOM (solid shape): 31.17,29.73 31.17,29.08 31.27,28.98 32.05,28.98 32.08,28.94 32.08,27.72 31.92,27.56 31.52,27.56 31.23,27.69 30.95,27.56 30.64,27.56 30.55,27.65 30.55,29.73 30.57,29.76 31.14,29.76
+5V_RUN on BOTTOM (solid shape): 182.9,171.28 182.9,170.83 183,170.73 183.43,170.73 183.51,170.65 183.51,170.19 183.58,170.12 183.58,169.71 183.51,169.63 182.9,169.63 182.59,169.94 181.68,169.94 181.6,170.01 181.6,170.14 181.6,170.53 181.66,170.6 182.21,170.6 182.34,170.73 182.34,171.31 182.41,171.39 182.79,171.39
+5V_RUN on BOTTOM (solid shape): 225.44,39.66 226.71,39.66 228.59,37.78 229.63,37.78 229.76,37.65 229.76,35.37 229.4,35.01 228.08,35.01 228.08,35.02 225.59,35.02 224.76,35.85 227.09,35.85 227.09,35.8 227.11,35.74 227.13,35.69 227.15,35.64 227.19,35.6 227.23,35.56 227.27,35.52 227.32,35.5 227.38,35.48 227.43,35.47 227.49,35.47 227.54,35.48 227.6,35.49 227.65,35.51 227.7,35.54 227.74,35.58 227.78,35.62 227.81,35.66 227.83,35.71 227.85,35.77 227.85,35.82 227.85,35.88 227.85,35.93 227.83,35.99 227.81,36.04 227.78,36.08 227.74,36.13 227.7,36.16 227.65,36.19 227.6,36.21 227.54,36.23 227.49,36.23 227.43,36.23 227.38,36.22 227.32,36.2 227.27,36.18 227.23,36.14 227.19,36.11 227.15,36.06 227.13,36.01 227.11,35.96 227.09,35.91 227.09,35.85 224.76,35.85 221.86,38.75 221.86,40.43 222.27,40.84 224.26,40.84
+5V_RUN on VCC (solid shape): outline of 14133 points within 14.11,30.29 223.71,164.63
+5V_RUN on IN2 (solid shape): 33.52,28.83 33.52,27.62 33.29,27.39 31.85,27.39 31.56,27.68 31.56,28.94 31.59,28.97 33.38,28.97
+5V_RUN on IN2 (solid shape): 49.56,32.42 49.56,31.08 49.29,30.81 47.62,30.81 47.48,30.95 47.48,32.47 47.58,32.57 49.41,32.57
+5V_RUN on IN2 (solid shape): 61.59,70.12 61.59,68.64 61.23,68.29 60.11,68.29 59.76,68.64 59.76,70.27 60.04,70.55 61.15,70.55
+5V_RUN on IN2 (solid shape): 66.39,120.23 66.39,119.44 66.13,119.19 63.34,119.19 62.32,120.2 62.32,121.42 62.58,121.68 64.94,121.68
+5V_RUN on IN2 (solid shape): 81.88,118.81 81.88,117.64 81.55,117.31 80.56,117.31 79.7,118.17 79.7,118.99 79.85,119.14 81.55,119.14
+5V_RUN on IN2 (solid shape): 81.17,61.51 81.17,61.05 81.04,60.92 78.78,60.92 77.44,62.27 77.44,64 78.67,64
+5V_RUN on IN2 (solid shape): outline of 504 points within 190.29,149.14 198.16,161.96
+5V_RUN on IN2 (solid shape): outline of 775 points within 92.62,146.72 113.25,164.35
+5V_RUN on IN2 (solid shape): outline of 1087 points within 244.75,150.96 267.1,181.11
+5V_RUN on IN2 (solid shape): outline of 1292 points within 131.59,142.58 177.56,154.77
+5V_RUN on IN3 (solid shape): 61.27,70.72 61.27,68.32 61.14,68.2 59.76,68.2 59.52,68.44 59.52,70.62 59.79,70.9 61.08,70.9
+5V_RUN on IN3 (solid shape): 85.92,46.67 85.92,45.2 85.74,45.02 85.08,45.02 85.04,45.06 85.04,46.68 85.23,46.87 85.72,46.87
+5V_RUN on IN3 (solid shape): 49.38,33.36 49.38,31.22 49.29,31.13 47.83,31.13 47.22,31.74 47.22,33.21 47.49,33.48 49.27,33.48
+5V_RUN on IN3 (solid shape): 94.91,21.63 94.91,20.53 94.68,20.3 94.02,20.3 93.73,20.59 93.73,21.54 94,21.8 94.73,21.8
+5V_RUN on IN3 (solid shape): outline of 500 points within 205.63,162.22 256.05,185.84
+5V_RUN_AUDIO on BOTTOM (solid shape): 280.99,176.67 280.99,172.17 279.54,170.73 279.54,164.48 278.9,163.83 277.3,163.83 276.93,164.2 276.93,172.95 276.25,173.62 272.84,173.62 272.6,173.86 272.6,175.13 274.56,177.1 280.56,177.1
+5V_RUN_AUDIO on BOTTOM (solid shape): 322.79,157.45 322.79,157.45 323.68,156.69 324.75,156.22 324.76,156.22 324.76,155.59 324.68,155.51 322.55,155.51 322.34,155.71 322.34,156.53 322.09,156.78 321.88,156.78 321.78,156.88 321.78,157.52 321.99,157.72 322.51,157.72
+5V_RUN_AUDIO on IN2 (solid shape): outline of 798 points within 277.49,156.37 323.23,165.85
+5V_RUN_AUDIOP on BOTTOM (solid shape): 273.24,180.04 273.24,178.68 273.79,178.13 273.79,176.62 272.44,175.27 272.44,174.85 271.91,174.85 271.91,174.42 272.44,174.42 272.44,173.84 272.27,173.66 270.21,173.66 270.03,173.84 270.03,174.61 270.98,175.56 270.98,176.62 271.04,176.62 271.04,176.57 271.05,176.51 271.07,176.46 271.09,176.41 271.12,176.37 271.15,176.33 271.2,176.3 271.24,176.27 271.29,176.25 271.34,176.24 271.4,176.24 271.45,176.24 271.5,176.25 271.55,176.27 271.6,176.3 271.64,176.33 271.68,176.37 271.71,176.41 271.73,176.46 271.75,176.51 271.75,176.57 271.75,176.62 271.75,176.67 271.73,176.72 271.71,176.77 271.68,176.81 271.64,176.85 271.6,176.89 271.55,176.91 271.5,176.93 271.45,176.95 271.4,176.95 271.34,176.95 271.29,176.93 271.24,176.91 271.2,176.89 271.15,176.85 271.12,176.81 271.09,176.77 271.07,176.72 271.05,176.67 271.04,176.62 270.98,176.62 270.98,178.21 271.47,178.71 271.5,178.71 271.55,178.73 271.6,178.76 271.64,178.8 271.68,178.84 271.71,178.88 271.73,178.93 271.75,178.98 271.75,179.04 271.75,179.09 271.74,179.15 271.73,179.17 271.73,179.38 271.59,179.52 271.59,180.22 271.71,180.35 272.26,180.35 272.93,180.35
+5V_TSP on BOTTOM (solid shape): 92.93,167.35 92.93,166.62 93.27,166.28 93.27,165.85 93.07,165.65 90.69,165.65 90.62,165.72 90.62,166.15 91.18,166.15 91.18,166.64 90.64,166.64 90.62,166.66 90.62,167.32 90.72,167.42 92.85,167.42
+5V_TSP_Q on BOTTOM (solid shape): 85.66,137.67 85.66,137 83.26,134.6 81.04,134.6 80.79,134.84 80.79,135.88 80.92,136 82.38,136 84.37,138 85.34,138
+5V_TSP_Q on BOTTOM (solid shape): 90.47,166.97 90.47,166.53 90.49,166.51 91.02,166.51 91.02,166.33 91,166.31 90.49,166.31 90.47,166.28 90.47,162.75 90.31,162.6 88.74,162.6 88.48,162.85 88.48,166.91 88.63,167.05 90.38,167.05
+5V_USB_CHG_PWR on TOP (solid shape): 19.68,84.77 19.68,83.3 19.43,83.05 16.87,83.05 16.56,83.36 16.56,84.73 16.86,85.02 19.43,85.02
+5V_USB_CHG_PWR on BOTTOM (solid shape): 24.57,76.19 24.57,74.59 24.18,74.21 24.18,73.3 23.99,73.11 23.18,73.11 22.71,73.57 22.71,76.22 22.81,76.32 24.43,76.32
+5V_USB_CHG_PWR on BOTTOM (solid shape): 19.62,90.69 19.62,87.87 18.35,86.59 18.35,83.49 18.15,83.3 15.76,83.3 15.46,83.6 14.9,83.6 14.82,83.68 14.37,83.68 13.94,84.12 13.94,84.42 14.47,84.95 14.47,87.13 16.53,87.13 16.53,87.08 16.53,87.03 16.55,86.98 16.57,86.93 16.6,86.89 16.64,86.85 16.68,86.81 16.73,86.79 16.78,86.77 16.83,86.76 16.88,86.75 16.93,86.76 16.99,86.77 17.04,86.79 17.08,86.81 17.12,86.85 17.16,86.89 17.19,86.93 17.21,86.98 17.23,87.03 17.24,87.08 17.24,87.13 17.23,87.19 17.21,87.24 17.19,87.29 17.16,87.33 17.12,87.37 17.08,87.4 17.04,87.43 16.99,87.45 16.93,87.46 16.88,87.47 16.83,87.46 16.78,87.45 16.73,87.43 16.68,87.4 16.64,87.37 16.6,87.33 16.57,87.29 16.55,87.24 16.53,87.19 16.53,87.13 14.47,87.13 14.47,91.17 14.98,91.68 18.63,91.68
+5V_USB_CHG_PWR on IN1 (solid shape): outline of 159 points within 14.52,73.06 24.78,92.7
+P1.05V_PEX_VDD on BOTTOM (solid shape): 94.58,80.99 94.58,80.63 94.55,80.61 94.02,80.61 94.02,80.05 94.58,80.05 94.58,79.79 94,79.79 94,79.23 94.55,79.23 94.58,79.21 94.58,78.95 94.55,78.93 93.72,78.93 93.63,78.84 91.02,78.84 90.89,78.71 90.25,78.71 90.13,78.84 90.13,79.55 90.44,79.86 90.44,79.86 90.48,79.9 90.48,80.29 90.72,80.53 92.55,80.53 93.06,81.04 94.53,81.04
+V1.05SP_B+ on BOTTOM (solid shape): 76.84,67.76 76.84,66.61 77.4,66.05 77.72,66.05 77.85,66.17 79.12,66.17 79.18,66.11 79.18,64.55 78.83,64.2 75.68,64.2 75.4,64.48 72.07,64.48 71.94,64.6 71.94,65.36 72.38,65.8 73.55,65.8 73.73,65.98 73.73,66.88 73.72,66.88 73.72,66.93 73.19,66.93 73.19,67.22 73.73,67.22 73.73,67.7 73.19,67.7 73.19,67.99 73.72,67.99 73.72,68.03 73.73,68.03 73.73,68.97 73.72,68.98 73.72,69.04 73.91,69.22 75.37,69.22
+VCC_CORE on TOP (solid shape): outline of 1684 points within 95.9,72.37 153.84,103.29
+VCC_CORE on BOTTOM (solid shape): 135.02,81.96 135.02,81.5 135.01,81.48 134.96,81.41 134.87,81.41 134.71,81.43 134.55,81.37 134.45,81.36 134.39,81.45 134.06,81.76 133.73,81.45 133.67,81.36 133.57,81.37 133.39,81.43 133.21,81.4 133.15,81.39 133.1,81.41 133.1,81.94 133.54,82.38 133.54,82.38 133.87,82.71 134.26,82.71
+VCC_CORE on BOTTOM (solid shape): 142.13,82.35 142.14,82.35 142.53,81.96 142.53,81.48 142.48,81.41 142.4,81.41 142.23,81.43 142.07,81.37 141.97,81.36 141.91,81.45 141.58,81.76 141.25,81.45 141.19,81.36 141.09,81.37 140.93,81.43 140.77,81.41 140.71,81.4 140.66,81.43 140.66,82 141.34,82.69 141.79,82.69
+VCC_CORE on BOTTOM (solid shape): 140.03,81.96 140.03,81.51 140.03,81.48 139.98,81.41 139.89,81.41 139.72,81.43 139.57,81.37 139.46,81.36 139.4,81.45 139.07,81.76 138.74,81.45 138.69,81.36 138.58,81.37 138.42,81.43 138.26,81.41 138.17,81.41 138.12,81.48 138.12,81.5 138.12,81.96 138.84,82.68 139.31,82.68
+VCC_CORE on BOTTOM (solid shape): 137.52,81.96 137.52,81.5 137.52,81.48 137.47,81.41 137.38,81.41 137.21,81.43 137.06,81.37 136.95,81.36 136.9,81.45 136.57,81.76 136.24,81.45 136.18,81.36 136.07,81.37 135.92,81.43 135.75,81.41 135.66,81.41 135.61,81.48 135.6,81.54 135.6,81.96 136.36,82.73 136.75,82.73
+VCC_CORE on BOTTOM (solid shape): 145.03,81.98 145.03,81.45 144.97,81.41 144.9,81.41 144.74,81.43 144.58,81.37 144.48,81.36 144.42,81.45 144.09,81.76 143.76,81.45 143.7,81.36 143.6,81.37 143.44,81.43 143.27,81.41 143.19,81.41 143.13,81.48 143.11,81.55 143.11,81.96 143.85,82.69 144.32,82.69
+VCC_CORE on BOTTOM (solid shape): 150.03,81.99 150.03,81.43 149.98,81.4 149.92,81.41 149.75,81.43 149.6,81.37 149.49,81.36 149.43,81.45 149.1,81.76 148.77,81.45 148.72,81.36 148.61,81.37 148.45,81.43 148.29,81.41 148.2,81.41 148.15,81.48 148.13,81.55 148.13,81.9 148.14,81.91 148.14,81.96 148.85,82.67 149.34,82.67
+VCC_CORE on BOTTOM (solid shape): 152.52,82.01 152.52,81.42 152.48,81.4 152.43,81.41 152.26,81.43 152.1,81.37 152,81.36 151.94,81.45 151.61,81.76 151.28,81.45 151.22,81.36 151.12,81.37 150.96,81.43 150.8,81.41 150.71,81.41 150.66,81.48 150.64,81.58 150.64,81.94 151.37,82.67 151.86,82.67
+VCC_CORE on BOTTOM (solid shape): 147.57,81.95 147.57,81.55 147.55,81.48 147.5,81.41 147.41,81.41 147.24,81.43 147.09,81.37 146.98,81.36 146.93,81.45 146.6,81.76 146.27,81.45 146.21,81.36 146.1,81.37 145.95,81.43 145.78,81.41 145.69,81.41 145.64,81.48 145.62,81.55 145.62,81.94 146.37,82.69 146.83,82.69
+VCC_CORE on BOTTOM (solid shape): 154.46,82.45 155.17,82.45 155.71,81.9 155.73,81.87 155.72,81.83 155.69,81.8 155.64,81.76 155.56,81.77 155.26,81.75 155.12,81.49 155.07,81.4 154.97,81.39 154.79,81.43 154.61,81.37 154.51,81.36 154.45,81.45 154.12,81.76 153.79,81.45 153.73,81.36 153.63,81.37 153.47,81.43 153.3,81.41 153.22,81.41 153.17,81.48 153.17,81.96 153.89,82.69 154.22,82.69
+VCC_CORE on BOTTOM (solid shape): outline of 1086 points within 132.83,69.67 155.6,81.24
+VCC_CORE on BOTTOM (solid shape): outline of 1574 points within 96.49,87.29 126.15,104.05
+VCC_CORE on IN2 (solid shape): outline of 5423 points within 96.18,76.52 149.57,102.09
+VCC_CORE on VCC: 103.02,69.94 102.63,70.32 102.63,70.96 93.72,79.87 93.72,90.03 103.25,99.55 107.87,99.55 109.75,101.43 154.83,101.43 154.83,70.09 154.67,69.94 ; 2 cut-outs
+VCC_PWR_SRC on BOTTOM (solid shape): 93.18,113.78 93.18,113.26 92.65,113.26 92.65,112.55 93.18,112.55 93.18,112.06 92.65,112.06 92.65,111.35 93.18,111.35 93.18,110.82 91.61,109.26 90.34,109.26 89.83,108.75 89.83,107.33 89.82,107.31 89.82,105.29 89.83,105.28 89.83,105.27 90.49,104.61 91.95,104.61 91.95,101.15 92.14,100.96 92.14,100.2 84.33,100.2 83.96,100.57 83.96,102.45 85.32,103.81 85.32,113.74 86.77,115.19 91.77,115.19
+VDDA_AVDD1 on BOTTOM (solid shape): 324.7,154.98 324.7,152.44 324.53,152.26 322.44,152.26 322.19,152.51 322.19,153.2 322.47,153.48 322.47,154.88 322.67,155.08 324.6,155.08
+VDDA_AVDD2 on TOP (solid shape): 319.8,155.15 319.8,151.37 319.45,151.01 316.75,151.01 316.55,151.22 316.55,153.12 315.76,153.91 315.76,154.73 318.2,154.73 318.2,154.68 318.21,154.63 318.22,154.58 318.25,154.53 318.28,154.49 318.31,154.45 318.35,154.41 318.4,154.39 318.45,154.37 318.5,154.36 318.55,154.35 318.61,154.36 318.66,154.37 318.71,154.39 318.76,154.41 318.8,154.45 318.83,154.49 318.86,154.53 318.89,154.58 318.9,154.63 318.91,154.68 318.91,154.73 318.9,154.79 318.89,154.84 318.86,154.89 318.83,154.93 318.8,154.97 318.76,155 318.71,155.03 318.66,155.05 318.61,155.06 318.55,155.06 318.5,155.06 318.45,155.05 318.4,155.03 318.35,155 318.31,154.97 318.28,154.93 318.25,154.89 318.22,154.84 318.21,154.79 318.2,154.73 315.76,154.73 315.76,155.09 315.94,155.27 319.69,155.27
+VDDA_PVDD on BOTTOM (solid shape): 276.24,173.19 276.24,164.98 275.48,164.22 274.34,164.22 273.83,164.73 273.83,173.3 273.91,173.39 276.04,173.39
+VDDA_PVDD on IN1 (solid shape): 275,165.29 275.96,165.29 282.39,158.86 288.97,158.86 289.12,158.71 289.12,157.14 288.61,156.63 285.64,156.63 285.56,156.66 285.54,156.74 285.3,157.12 284.88,156.96 284.79,156.91 284.7,156.96 284.28,157.12 284.04,156.74 284.01,156.66 283.94,156.63 280.1,156.63 276.56,160.17 276.46,160.56 276.08,160.65 273.7,163.03 273.7,165.02 273.98,165.3 274.98,165.3
+VDDA_PVDD on IN2 (solid shape): outline of 321 points within 286.78,150.15 304.31,157.52
+VDDRP on BOTTOM (solid shape): 37.21,60.47 37.72,60.47 37.72,61 38.01,61 38.01,60.47 40.85,60.47 40.85,61 41.15,61 41.15,60.47 41.65,60.47 41.65,61 41.95,61 41.95,60.47 43.68,60.47 43.88,60.27 43.88,47.99 42.51,46.62 36.11,46.62 35.75,46.98 35.75,50.08 38.47,52.79 38.47,55.74 36.19,58.03 36.19,60.22 36.44,60.47 36.92,60.47 36.92,61 37.21,61
+VDDRP_B+ on BOTTOM (solid shape): 42.88,39.85 42.88,30.79 42.74,30.65 41.71,30.65 41.71,30.1 41.42,30.1 41.42,30.65 40.92,30.65 40.92,30.1 40.62,30.1 40.62,30.65 40.17,30.65 40.09,30.74 40.09,35.4 39.83,35.66 39.83,39.85 39.96,39.98 42.76,39.98
GND on TOP (solid shape): 110,167.09 110,163.41 108.37,161.78 103.04,161.78 101.26,163.56 101.26,168.64 101.36,168.74 108.35,168.74
GND on TOP (solid shape): 125.83,96.01 125.83,94.66 125.72,94.55 109.11,94.55 108.98,94.68 108.98,96.07 109.13,96.23 125.62,96.23
GND on TOP (solid shape): 128.51,26.35 128.51,24.14 128.39,24.01 128.06,24.01 127.45,24.62 127.45,26.45 127.52,26.53 128.34,26.53
GND on TOP (solid shape): 128.7,147.96 128.7,146.97 128.54,146.81 127.62,146.81 127.48,146.95 127.48,147.94 127.63,148.09 128.57,148.09
GND on TOP (solid shape): 213.68,31.73 213.68,27.69 213.19,27.19 210.7,27.19 210.18,27.72 210.18,32.05 210.29,32.17 213.24,32.17
GND on TOP (solid shape): 123.04,166.45 123.04,164.87 122.84,164.67 122.3,164.67 122.14,164.83 122.14,166.43 122.27,166.56 122.93,166.56
GND on TOP (solid shape): 62.57,90.03 62.57,89.14 62.8,88.91 62.8,88.2 62.72,88.12 61.93,88.12 61.72,88.33 61.72,90.23 61.86,90.36 62.23,90.36
GND on TOP (solid shape): 139.51,34.92 139.51,27.59 139.21,27.29 133.65,27.29 133.28,27.65 133.28,34.63 133.75,35.09 139.34,35.09
GND on TOP (solid shape): 192.85,147.26 192.85,146.18 192.53,145.87 191.07,145.87 190.56,146.38 190.56,147.01 190.75,147.2 191.07,147.2 191.39,147.52 192.59,147.52
GND on TOP (solid shape): 235.88,162.19 235.88,161.1 235.73,160.95 232.17,160.95 232.05,161.07 232.05,162.09 232.43,162.47 235.6,162.47
GND on TOP (solid shape): 330.36,160.21 330.36,157.81 330.18,157.63 328.87,157.63 328.65,157.85 328.65,160.22 329,160.57 330,160.57
GND on TOP (solid shape): 40.82,101.35 40.82,97.07 40.68,96.94 39.08,96.94 38.95,97.07 38.95,101.33 39.16,101.54 40.63,101.54
GND on TOP (solid shape): 141.07,58.14 141.07,52.92 141.01,52.86 140.03,52.86 139.97,52.92 139.97,58.08 140.12,58.23 140.99,58.23
GND on TOP (solid shape): 116.75,115.18 116.75,113.73 117.06,113.42 117.06,113.03 116.85,112.83 115.34,112.83 115.18,112.99 115.18,113.7 114.67,114.21 114.67,115.15 114.82,115.3 116.63,115.3
GND on TOP (solid shape): 127.82,92.24 127.82,91.44 127.55,91.17 109.2,91.17 109.01,91.36 109.01,92.19 109.26,92.44 127.61,92.44
GND on TOP (solid shape): 127.52,99.86 127.52,98.46 127.4,98.34 107.66,98.34 107.46,98.54 107.46,99.94 107.59,100.06 127.32,100.06
GND on TOP (solid shape): 144.75,56.98 144.75,53.1 144.54,52.9 142.38,52.9 142.26,53.02 142.26,54.16 142.88,54.78 142.88,57.04 142.99,57.16 144.57,57.16
GND on TOP (solid shape): 53.89,92.92 53.89,87.91 53.8,87.82 52.48,87.82 52.18,88.11 52.18,89.33 52.15,89.33 52.15,91.3 53.18,92.34 53.18,92.89 53.34,93.05 53.76,93.05
GND on TOP (solid shape): 56.87,92.37 56.87,90.7 57.06,90.52 57.06,89 57.02,88.96 56.11,88.96 55.91,89.16 55.91,90.44 55.43,90.92 55.43,92.29 55.6,92.46 56.78,92.46
GND on TOP (solid shape): 70.96,105 70.96,104.57 70.84,104.45 67.83,104.45 67.48,104.1 67.2,104.1 67.06,104.25 67.06,104.59 67.87,105.41 67.87,105.74 67.94,105.8 69.32,105.8 69.33,105.81 70.15,105.81
GND on TOP (solid shape): 120.84,184.24 120.84,183.63 120.92,183.55 120.92,181.52 120.92,181.52 120.92,181.37 120.83,181.28 120.03,181.28 119.78,181.54 119.78,184.16 119.93,184.31 120.77,184.31
GND on TOP (solid shape): 138.04,58.2 138.04,56.85 138.39,56.5 138.39,54 138.4,53.95 138.42,53.91 138.66,53.67 138.66,52.3 138.55,52.18 137.33,52.18 137.07,52.44 137.07,55.87 137.16,55.96 137.16,58.11 137.38,58.33 137.91,58.33
GND on TOP (solid shape): 60.93,93.61 60.93,93.08 60.82,92.97 59.93,92.97 59.77,92.8 59.77,91.67 60.08,91.35 60.08,88.91 60.46,88.53 60.46,88.32 60.34,88.19 59.81,88.19 58.83,89.17 58.83,91.43 58.7,91.56 58.7,93.52 59.02,93.84 60.7,93.84
GND on TOP (solid shape): 165.18,105.01 165.84,105.01 165.84,105.01 167.22,105.01 167.22,105.01 168.21,105.01 168.41,105.21 169.5,105.21 169.56,105.15 169.56,104.19 169.44,104.06 165.24,104.06 165.05,104.25 165.05,104.5 164.84,104.72 163.72,104.72 163.64,104.8 163.64,105.34 163.77,105.47 164.72,105.47
GND on TOP (solid shape): 220.79,153.17 220.91,153.04 222.68,153.04 222.82,152.89 222.82,152.36 223.18,152.01 224.04,152.01 224.3,151.75 224.3,149.72 224.12,149.54 221.63,149.54 221.5,149.41 221.5,148.42 221.81,148.12 223.61,148.12 223.97,147.76 223.97,146.06 223.66,145.76 221.33,145.76 219.9,144.33 216.14,144.33 214.82,145.66 214.82,148.07 217.25,150.49 217.25,151.23 217.54,151.52 217.54,154.16 217.61,154.24 220.79,154.24
GND on TOP (solid shape): 234.08,40.68 234.08,39.16 234.03,39.15 233.7,38.77 234.03,38.39 234.08,38.39 234.08,38.21 233.8,37.93 232.76,37.93 232.62,38.07 232.62,40.87 232.81,41.06 233.7,41.06
GND on TOP (solid shape): 186.49,145.11 186.49,141.78 185.99,141.28 185.82,141.28 185.71,141.4 185.71,142.73 185.44,142.73 185.44,141.37 185.36,141.28 185.16,141.28 185.06,141.39 185.06,142.76 184.78,142.76 184.78,141.37 184.69,141.28 184.51,141.28 184.42,141.37 184.42,142.76 184.14,142.76 184.14,141.38 184.04,141.28 183.85,141.28 183.75,141.38 183.75,142.85 183.79,142.88 183.79,143.24 183.96,143.42 183.96,145.2 184.24,145.48 186.12,145.48
GND on TOP (solid shape): 224.22,162.44 224.22,160.66 224.09,160.54 222.31,160.54 222.18,160.41 222.18,159.79 221.79,159.59 222.09,159.26 222.13,159.21 222.18,159.21 222.18,159.01 222.31,158.88 222.57,158.88 222.69,158.76 222.69,158.12 222.63,158.06 217.55,158.06 217.49,158.12 217.49,162.5 217.9,162.92 223.74,162.92
GND on TOP (solid shape): 230.57,14.15 235.4,12.9 235.4,8.48 235.4,8.4 235.39,8.32 235.36,8.24 235.34,8.14 235.29,8.03 235.24,7.96 235.18,7.87 235.07,7.75 229.73,7.75 229.73,8 229.32,9.13 228.28,9.73
GND on TOP (solid shape): outline of 105 points within 78.17,63.13 85.26,70.42
GND on TOP (solid shape): 9.71,97.64 11.14,97.64 13.38,95.4 13.38,89.75 14.05,89.08 14.05,85.45 13.9,85.31 12.2,85.31 12.2,86.14 12.68,86.98 11.94,87.6 1.05,87.6 1.05,89.53 6.63,89.53 7.16,89.75 7.38,90.28 7.38,91.78 7.16,92.31 6.63,92.53 1.05,92.53 1.05,94.75 7.74,94.75 7.89,94.49 8.14,94.31 8.26,94.27 8.38,94.25 8.96,94.44 9.2,95 9.2,97.58 9.2,97.65 9.71,97.65
GND on TOP (solid shape): 81.81,144.21 83.57,140.95 81.91,137.64 77.09,137.64 76.23,138.22 76.43,138.51 76.51,138.88 76.3,139.2 75.46,139.77 75.39,139.82 75.33,139.89 75.29,139.98 75.47,140.26 75.66,140.55 76.39,141.76 77.07,143 77.07,143 77.41,143.67 77.73,144.36 77.82,144.46 77.95,144.5 78.39,144.5 78.47,144.5 78.56,144.52 78.72,144.57 78.86,144.67 78.91,144.7 78.94,144.74 79.03,144.7 80.1,144.2 80.49,144.19 80.77,144.47 80.84,144.64 80.91,144.81
GND on TOP (solid shape): outline of 113 points within 21.76,66.94 33.98,75.6
GND on TOP (solid shape): outline of 203 points within 83.99,97.07 103.27,108.5
GND on TOP (solid shape): outline of 722 points within 1.39,36.71 30.24,65.19
GND on TOP (solid shape): outline of 2153 points within 0.25,0.25 344.65,190.65
GND on TOP (solid shape): outline of 3111 points within 186.17,17.79 223.79,33.23
GND on BOTTOM (solid shape): 48.02,84.75 48.02,82.46 47.39,81.83 46.63,81.83 45.99,82.46 45.99,84.62 46.5,85.13 47.64,85.13
GND on BOTTOM (solid shape): 51.36,14.69 51.36,11.89 51.04,11.58 47.76,11.58 47.61,11.72 47.61,14.62 47.81,14.81 51.24,14.81
GND on BOTTOM (solid shape): 52.47,84.49 52.47,80.81 52.34,80.68 51.2,80.68 50.94,80.94 50.94,84.62 51.07,84.75 52.21,84.75
GND on BOTTOM (solid shape): 81.43,59.37 81.43,55.92 80.56,55.05 77.13,55.05 76.49,55.68 76.49,59.37 76.96,59.83 80.97,59.83
GND on BOTTOM (solid shape): 99.84,154.52 99.84,153.45 99.66,153.28 96.49,153.28 96.28,153.48 96.28,154.39 96.49,154.6 99.76,154.6
GND on BOTTOM (solid shape): 175.1,167.35 175.1,165.54 175,165.44 173.55,165.44 173.22,165.77 173.22,167.3 173.37,167.45 175,167.45
GND on BOTTOM (solid shape): 205.88,142.91 205.88,139.81 205.53,139.46 201.67,139.46 201.31,139.81 201.31,142.79 201.64,143.12 205.68,143.12
GND on BOTTOM (solid shape): 225.72,45.5 225.72,42.23 225.21,41.72 220.72,41.72 220.44,42 220.44,45.58 220.62,45.76 225.47,45.76
GND on BOTTOM (solid shape): 230.55,137.71 230.55,134.28 230.19,133.92 228.08,133.92 226.81,135.19 226.81,137.65 227.04,137.88 230.37,137.88
GND on BOTTOM (solid shape): 151.91,96.43 151.91,94.09 150.69,92.87 148.94,92.87 148.15,93.66 148.15,96.53 148.3,96.68 151.65,96.68
GND on BOTTOM (solid shape): 16.3,119.57 16.3,115.33 15.97,115 13.6,115 13.05,115.55 13.05,119.54 13.4,119.9 15.97,119.9
GND on BOTTOM (solid shape): 49.52,53.96 49.52,50.84 48.43,49.75 45.99,49.75 45.58,50.15 45.58,54.09 45.96,54.47 49.01,54.47
GND on BOTTOM (solid shape): 69.54,29.12 69.54,23.81 69.28,23.56 66.84,23.56 66.44,23.96 66.44,29.07 66.87,29.5 69.15,29.5
GND on BOTTOM (solid shape): 109.03,179.44 109.03,175.93 109.64,175.32 109.64,173.37 109.33,173.06 107.39,173.06 107.04,173.4 107.04,179.53 107.22,179.71 108.76,179.71
GND on BOTTOM (solid shape): 184.45,74.41 184.45,73.54 184.32,73.42 183.66,73.42 183.51,73.57 183.51,74.66 183.58,74.74 184.12,74.74
GND on BOTTOM (solid shape): 196.61,83.15 196.61,80.05 196.36,79.79 192.75,79.79 192.32,80.22 192.32,82.98 192.59,83.25 196.51,83.25
GND on BOTTOM (solid shape): 196.87,75.53 196.87,72.58 196.66,72.38 192.88,72.38 192.22,73.04 192.22,75.27 192.7,75.75 196.64,75.75
GND on BOTTOM (solid shape): 227.11,167.18 227.11,163.4 226.91,163.2 222.66,163.2 222.37,163.49 222.37,167.28 222.52,167.42 226.86,167.42
GND on BOTTOM (solid shape): 241.29,133.51 241.29,129.35 241.02,129.08 237.24,129.08 236.34,128.18 233.75,128.18 233.39,128.54 233.39,132.04 235.4,134.05 240.76,134.05
GND on BOTTOM (solid shape): 19.62,96.23 19.62,92.98 19.12,92.47 15.97,92.47 14.73,93.71 14.73,96.1 15.05,96.43 19.42,96.43
GND on BOTTOM (solid shape): 47.08,17.82 47.08,17.03 46.88,16.83 45.66,16.83 45.3,16.47 44.75,16.47 44.42,16.8 44.42,18.1 44.59,18.27 46.63,18.27
GND on BOTTOM (solid shape): 47.31,23.35 47.31,22.62 46.83,22.14 44.67,22.14 44.1,22.71 43.51,22.71 43.22,23 43.22,23.76 43.68,24.22 46.45,24.22
GND on BOTTOM (solid shape): 60.61,45.57 60.61,41.11 60.26,40.77 60.26,39.12 60.13,39 58.35,39 58.23,39.12 58.23,45.6 58.61,45.98 60.19,45.98
GND on BOTTOM (solid shape): 84.98,113.32 84.98,103.92 84.47,103.42 80.53,103.42 79.9,104.05 79.9,113.19 79.9,113.2 79.9,113.68 80.3,114.08 84.22,114.08
GND on BOTTOM (solid shape): 107.13,168.59 107.13,167.42 106.87,167.17 105.43,167.17 104.21,165.95 101.51,165.95 101.21,166.25 101.21,168.67 101.34,168.79 106.92,168.79
GND on BOTTOM (solid shape): 273.7,173.11 273.7,171.54 273.35,171.18 270.31,171.18 270.02,171.47 270.02,173.29 270.11,173.38 273.43,173.38
GND on BOTTOM (solid shape): 38.04,55.74 38.04,52.69 37.53,52.18 34.23,52.18 33.9,52.51 33.9,57.01 34.15,57.26 36.52,57.26
GND on BOTTOM (solid shape): 100.83,146.95 100.83,144.5 100.79,144.46 100.62,144.46 100.55,144.4 97.41,144.4 96.98,144.83 94.97,144.83 94.66,145.15 94.66,146.69 95.22,147.26 100.52,147.26
GND on BOTTOM (solid shape): 103.78,62.01 103.78,57.95 103.03,57.2 98.25,57.2 97.92,57.53 97.92,58.51 98.31,58.9 98.31,62.14 99.08,62.9 102.89,62.9
GND on BOTTOM (solid shape): 127.3,167.02 127.3,164.58 126.97,164.25 124.6,164.25 123.83,165.02 123.83,165.02 122.7,166.15 122.7,166.94 122.85,167.09 127.22,167.09
GND on BOTTOM (solid shape): 226.25,96.56 226.25,94.63 225.36,93.74 225.36,92.21 225.24,92.09 224.48,92.09 224.12,92.44 224.12,95.52 225.36,96.76 226.05,96.76
GND on BOTTOM (solid shape): 262.91,163.36 262.91,159.17 262.78,159.04 261,159.04 260.87,159.17 260.87,160.06 260.37,160.57 260.37,162.22 260.62,162.47 260.62,163.23 260.87,163.49 262.78,163.49
GND on BOTTOM (solid shape): 94.21,73.68 94.21,72.67 93.96,72.41 88.94,72.41 88.71,72.19 88.71,71.36 88.54,71.18 87.6,71.18 87.42,71.36 87.42,73.47 87.76,73.81 94.08,73.81
GND on BOTTOM (solid shape): 147.3,55.06 147.3,53.05 146.3,52.04 137.2,52.04 137.19,52.06 136.91,52.06 136.67,52.3 136.67,54.91 137.07,55.3 147.06,55.3
GND on BOTTOM (solid shape): 158.11,184.48 158.11,182.89 157.88,182.66 146.57,182.66 146.19,183.04 146.19,184.31 146.49,184.61 157.98,184.61
GND on BOTTOM (solid shape): 177.74,167.25 177.74,165.16 177.36,164.78 176.5,164.78 176.42,164.86 176.42,165.11 176.75,165.44 176.75,167.22 176.98,167.45 177.54,167.45
GND on BOTTOM (solid shape): 36.24,30.51 36.24,29.07 36.16,28.99 33.57,28.99 32.99,28.41 32.28,28.41 32.24,28.45 32.24,30.12 32.4,30.29 33.32,30.29 33.65,30.62 36.14,30.62
GND on BOTTOM (solid shape): 327.12,154.29 327.12,154.06 326.61,153.56 326.12,153.56 326.12,153 325.93,153 325.93,153.56 325.4,153.56 325.4,153.55 325.21,153.55 325.11,153.65 325.11,154.16 325.52,154.57 326.84,154.57
GND on BOTTOM (solid shape): 232.1,91.05 232.1,88.68 231.17,87.75 231.17,84.83 230.48,84.14 228.25,84.14 227.87,84.51 227.87,87.37 228,87.5 229.45,87.5 230.48,88.53 230.48,91.02 230.56,91.1 232.05,91.1
GND on BOTTOM (solid shape): 66.79,114.82 66.79,113.22 67.49,112.52 67.49,112.32 67.17,112 66.36,112 66.03,111.67 63.21,111.67 62.74,112.14 62.74,113.57 62.31,113.99 62.3,114.02 62.3,114.04 62.3,114.85 62.5,115.05 66.56,115.05
GND on BOTTOM (solid shape): 191.35,156.68 191.35,155.59 190.97,155.21 190.97,154.11 191.13,153.96 191.53,153.96 191.66,153.83 191.66,152.89 190.69,151.93 188.92,151.93 187.75,153.1 187.75,154.39 187.44,154.7 186.43,154.7 186.1,155.03 186.1,155.94 187.06,156.91 191.13,156.91
GND on BOTTOM (solid shape): 68.9,40.27 68.9,39.12 69.15,38.87 70.8,38.87 70.93,39 70.93,40.52 71.18,40.77 76.01,40.77 76.58,40.2 76.58,37.47 75.98,36.87 65.27,36.87 65.07,37.07 65.07,39.03 65.47,39.43 65.47,40.52 65.72,40.77 68.39,40.77
GND on BOTTOM (solid shape): 82.21,46.06 82.21,42.86 81.55,42.2 81.55,39.28 81.55,39.19 81.58,39.11 81.58,38.76 81.36,38.54 79.54,38.54 79.44,38.65 79.44,39 79.44,39 79.44,45.93 80.18,46.67 81.6,46.67
GND on BOTTOM (solid shape): 39.58,38.52 39.58,35.53 39.83,35.28 39.83,32.29 39.59,32.04 38.3,32.04 38.09,32.24 38.09,33.94 37.71,34.32 33.98,34.32 33.73,34.58 33.73,36.15 34.51,36.94 36.55,36.94 36.72,37.12 36.72,37.5 36.8,37.58 36.8,37.66 36.8,38.66 36.91,38.77 39.33,38.77
GND on BOTTOM (solid shape): 94.42,106.46 94.42,102.28 95.48,101.22 95.48,99.02 93.85,97.4 84.77,97.4 84.04,98.13 84.04,99.32 84.65,99.94 92.11,99.94 92.26,100.09 92.26,106.14 92.27,106.14 92.27,106.61 92.32,106.67 92.8,106.67 93.04,106.91 93.96,106.91
GND on BOTTOM (solid shape): 91.39,176.33 91.39,169.89 91.3,169.8 90.18,169.8 90.08,169.9 90.08,172.26 90.4,172.62 90.08,172.97 90.08,173.36 89.78,173.67 89.78,176.7 90.02,176.94 90.78,176.94
GND on BOTTOM (solid shape): 57.97,40.39 57.97,39 58.17,38.8 58.17,37.54 57.72,37.09 49.66,37.09 48.64,36.08 45.59,36.08 44.89,36.77 44.89,39.44 45.28,39.82 46.16,39.82 46.32,39.66 46.32,39.22 46.54,39 48.45,39 48.7,39.25 48.7,39.26 48.75,39.31 48.75,40.43 48.99,40.67 51.73,40.67 52.13,40.27 52.13,39.12 52.39,38.87 54.04,38.87 54.16,39 54.16,40.52 54.42,40.77 57.59,40.77
GND on BOTTOM (solid shape): 182.97,167.12 182.97,165.06 182.77,164.86 182.33,164.86 182.16,165 181.95,165.03 181.7,165.03 181.57,165.15 181.42,165.42 181.13,165.49 181,165.49 180.91,165.57 180.91,166.33 180.58,166.66 180.58,167.19 180.76,167.37 182.72,167.37
GND on BOTTOM (solid shape): 134.16,84.25 134.16,84.21 134.11,84.09 134.1,84.05 134.1,84.02 134.1,83.83 134.11,83.78 134.16,83.61 134.16,83.53 134,83.37 134,82.94 133.91,82.85 133.83,82.85 133.39,82.42 133.29,82.42 133.17,82.54 133.17,82.63 133.24,82.7 133.24,83.16 133.2,83.2 133.2,83.3 133.29,83.38 133.29,83.41 133.29,83.41 133.29,83.53 133.33,83.58 133.38,83.6 133.53,83.64 133.63,83.75 133.76,83.88 133.76,84.02 133.9,84.15 134.01,84.38 134.11,84.38
GND on BOTTOM (solid shape): 230.57,14.15 235.4,12.9 235.4,8.48 235.4,8.4 235.39,8.32 235.36,8.24 235.34,8.14 235.29,8.03 235.24,7.96 235.18,7.87 235.07,7.75 229.73,7.75 229.73,8 229.32,9.13 228.28,9.73
GND on BOTTOM (solid shape): 80.48,65.11 80.49,65.1 80.49,64.15 80.52,64.12 80.66,64.12 80.69,64.15 80.69,65.12 80.74,65.18 80.83,65.18 80.89,65.11 80.89,64.17 80.94,64.12 81.04,64.12 81.09,64.17 81.09,65.12 81.14,65.18 81.26,65.18 81.32,65.11 81.32,61.63 81.3,61.61 81.21,61.58 81.14,61.63 80.97,61.78 80.75,61.81 80.67,61.83 80.63,61.9 80.18,62.24 79.89,61.76 79.89,61.49 79.72,61.33 73.16,61.33 72.01,62.48 72.01,64.21 72.14,64.33 75.31,64.33 75.63,64.02 79.21,64.02 79.49,64.3 79.49,65.11 79.54,65.16 79.65,65.16 79.7,65.11 79.7,64.15 79.72,64.12 79.87,64.12 79.89,64.14 79.89,65.1 79.95,65.17 80.05,65.17 80.1,65.11 80.1,64.15 80.13,64.12 80.25,64.12 80.28,64.15 80.28,65.11 80.34,65.18 80.42,65.18
GND on BOTTOM (solid shape): outline of 102 points within 191.43,165.42 194.4,169.63
GND on BOTTOM (solid shape): 10.74,96.63 12.91,96.63 13.3,96.24 13.3,89.25 13.64,88.91 13.64,85.83 13.25,85.44 12.7,85.44 12.7,85.21 12.66,85.2 12.5,85.14 12.37,85.03 12.26,85.01 12.2,85.11 12.2,86.14 12.68,86.98 11.94,87.6 1.05,87.6 1.05,89.53 6.63,89.53 7.16,89.75 7.38,90.28 7.38,91.78 7.16,92.31 6.63,92.53 1.05,92.53 1.05,94.75 7.74,94.75 7.89,94.49 8.14,94.31 8.26,94.27 8.38,94.25 8.96,94.44 9.2,95 9.2,97.54 9.2,97.6 9.26,97.6 9.26,97.6 9.77,97.6
GND on BOTTOM (solid shape): outline of 186 points within 1.39,35.08 32.66,66.31
GND on BOTTOM (solid shape): outline of 326 points within 134.61,81.72 154.95,84.41
GND on BOTTOM (solid shape): outline of 2429 points within 0.25,0.25 344.65,190.65
GND on IN1 (solid shape): 17.6,48 17.6,36.85 17.47,36.71 12.82,36.71 12.52,37.02 12.52,44.37 16.53,48.39 17.21,48.39
GND on IN1 (solid shape): 225.72,45.53 225.72,42.07 225.36,41.72 220.79,41.72 220.49,42.02 220.49,45.6 220.64,45.76 225.49,45.76
GND on IN1 (solid shape): 67.48,114.85 67.48,111.59 67.07,111.19 63.87,111.19 62.35,112.71 62.35,114.74 62.65,115.05 67.28,115.05
GND on IN1 (solid shape): 94.53,106.31 94.53,98.16 93.76,97.4 84.77,97.4 84.04,98.13 84.04,99.32 84.65,99.94 92.11,99.94 92.26,100.09 92.26,106.54 92.5,106.77 94.07,106.77
GND on IN1 (solid shape): 149.45,96.71 149.87,96.71 150.05,96.89 151.88,96.89 152.04,96.73 152.04,93.28 151.58,92.82 148.61,92.82 148.07,93.36 148.07,94.37 147.92,94.53 147.18,94.53 146.78,94.93 146.78,96.66 147.01,96.89 149.27,96.89
