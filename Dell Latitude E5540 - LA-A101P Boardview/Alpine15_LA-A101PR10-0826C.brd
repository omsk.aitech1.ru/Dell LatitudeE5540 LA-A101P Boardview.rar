# Allegro board Alpine15_LA-A101PR10-0826C.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PS_ID: length 50.1
  TOP w0.102: v2(159.38,124.95) 159.43,124.95 159.92,124.47 160.32,124.47 160.4,124.39 U38.A55 ; v3(135.73,139.61) 135.73,138.14 136.06,137.81 v1(136.06,136.46) 136.06,135.11 135.69,134.75 135.14,134.75 134.62,135.27 134.62,136.59 134.47,136.74 131.99,136.74 131.62,136.36 PU1.4
  IN1 w0.097: v3(135.73,139.61) 135.98,139.36 141.4,139.36 142.49,140.45 151.49,140.45 157.98,133.96 157.98,132.62 157.98,126.28 157.64,125.94 157.65,125.92 157.65,125.37 157.64,125.37 157.64,124.65 157.87,124.42 158.84,124.42 v2(159.38,124.95)
PSID_DISABLE#: length 90.8
  TOP w0.102: U37.A37 190.33,117.55 v2(190.25,117.47)
  TOP w0.254: PR13.2 128.27,136.9 v3(128.27,137.42)
  IN1 w0.097: v2(190.25,117.47) 189.59,116.81 189.59,116.49 189.25,116.15 181.89,116.15 179.21,113.47 178.01,113.47 175.16,110.63 170.55,110.63 170.07,110.15 165.11,110.15 164.64,110.62 164.03,110.62 163.27,111.38 163.07,111.38 161.26,111.38 161.17,111.29 157.67,111.29 157.67,111.29 157.31,111.29 156.64,110.62 155.9,110.62 155.22,110.62 152.06,113.79 152.06,114.69 151.66,115.1 151.66,128.82 150.81,129.67 150.81,131.4 146.12,136.09 144.09,136.09 143.12,136.09 141.64,134.61 134.02,134.61 132.14,136.49 130.65,136.49 129.71,137.42 v3(128.27,137.42)
  BOTTOM w0.102: v3(128.27,137.42) v1(127.68,137.42)
PWM1: length 22.6
  IN2 w0.254: v2(81.1,90.64) 81.1,93.31 83.71,95.92 83.71,100.11 89.82,106.22 v2(91.39,106.22)
  BOTTOM w0.203: PU300.6 81.38,90.92 v2(81.1,90.64) ; v2(91.39,106.22) 91.39,105.8 91.49,105.7 PU301.8
PWR_DET#: length 178.7
  TOP w0.102: v3(298.31,158.13) 298.75,158.56 303.35,158.56 303.86,159.07 304.91,159.07 305.52,159.68 310.02,159.68 310.99,160.64 310.99,165.72 311.8,166.53 R479.1 312.75,166.85 JPWR1.5 ; U37.B4 194.59,127.87 194.76,127.69 194.76,127.25 v2(195.2,126.82)
  BOTTOM w0.102: v2(195.2,126.82) 194.95,126.57 194.95,125.76 195.19,125.52 196.15,125.52 197.89,123.79 198.74,123.79 200.31,122.21 201.04,122.21 202.06,121.2 202.06,119.02 213.78,107.3 213.78,107.28 213.78,105.6 216.37,103.01 222.97,103.01 223.02,102.96 223.15,102.83 225.23,102.83 225.23,102.83 225.92,102.83 227.09,103.99 227.09,105.46 226.13,106.42 226.13,112 228.18,114.05 228.18,121.76 231.64,125.22 233.87,125.22 234.29,125.64 243.67,125.64 248.47,130.44 v1(249.57,130.44) 250.49,131.36 250.49,135.06 252.37,136.94 264.4,136.94 274.18,146.72 274.31,146.85 290.32,146.85 296.94,153.47 296.94,156.76 v3(298.31,158.13)
PWR_SRC_ON: length 3.9
  BOTTOM w0.254: R2578.1 R2576.2 C438.2 93.92,156.93 94.7,156.16 Q124.3
QSA0: length 27.8
  IN3 w0.102: v5(55.77,107.76) 55.77,107.52 55.69,107.43 55.53,107.43 55.36,107.61 55.36,109.05 54.83,109.58 54.44,109.58 53.41,110.61 53.41,111.29 52.92,111.79 49.83,111.79 45.24,107.2 36.9,107.2 35.96,106.26 35.96,105.76 35.79,105.58 35.62,105.58 35.52,105.68 v2(35.52,105.88)
  BOTTOM w0.102: v5(55.77,107.76) 56.11,107.42 UV1.E19 ; UV4.F3 35.9,105.5 v2(35.52,105.88)
QSA1: length 34.1
  TOP w0.102: v2(36.09,107.54) 36.47,107.93 36.47,108.36 36.13,108.7 UV5.F3
  IN1 w0.097: v5(59.82,108.53) 59.82,108.72 59.36,109.19 59.36,110.3 58.87,110.79 58.87,110.92 57.43,112.36 56.51,113.27 40.75,113.27 39.3,111.83 38.54,111.83 38.42,111.7 38.42,111.7 38.11,111.39 38.11,107.52 37.61,107.02 37.05,107.02 36.65,107.42 36.65,107.54 36.49,107.7 36.24,107.7 36.09,107.55 v2(36.09,107.54)
  BOTTOM w0.102: UV1.C15 59.8,108.53 v5(59.82,108.53)
QSA2: length 31.2
  TOP w0.102: UV5.C7 38.36,105.5 38.49,105.63 38.49,106.39 39,106.89 39.62,106.89 40.8,108.07 42.54,108.07 44.44,109.96 44.44,111.89 46.96,114.41 48,114.41 48.05,114.45 48.66,114.45 48.7,114.41 51.6,114.41 51.81,114.2 51.81,114.14 51.91,114.04 52.21,114.04 52.31,114.14 52.31,114.41 52.55,114.65 52.96,114.65 53.2,114.41 53.2,114.14 53.3,114.04 53.61,114.04 53.71,114.14 53.71,114.41 53.94,114.65 54.35,114.65 54.59,114.41 54.59,114.16 54.72,114.04 54.97,114.04 55.1,114.16 55.1,114.2 55.31,114.41 56.2,114.41 58.23,112.38 58.23,111.24 58.62,110.85 58.62,110.52 v5(58.99,110.15)
  BOTTOM w0.122: v5(58.99,110.15) 58.99,110.14 UV1.B16
QSA3: length 21.1
  BOTTOM w0.102: UV4.C7 38.47,108.55 38.47,107.85 38.84,107.48 40.11,107.48 42.26,109.63 42.32,109.63 42.76,110.07 42.76,110.13 45.1,112.46 45.16,112.46 v3(45.36,112.66) 45.52,112.83 45.52,112.89 46.03,113.39 51.44,113.39 53.24,111.59 53.24,110.38 53.63,109.99 UV1.B22
QSA4: length 23.6
  IN1 w0.097: v2(35.53,90.13) 35.53,90.21 36.39,91.06 37.4,91.06 38.06,91.72 39.94,91.72 40.03,91.82 40.03,92.54 40.24,92.74 40.67,92.74 40.87,92.54 40.87,91.82 40.97,91.72 43.62,91.72 47.66,95.76 47.92,95.76 51,98.84 51,99.45 50.9,99.56 50.84,99.56 v5(50.75,99.47)
  BOTTOM w0.102: UV1.R25 51.13,99 51.07,98.93 50.84,98.93 50.66,99.11 50.66,99.39 50.74,99.47 v5(50.75,99.47) ; UV6.F3 35.86,89.68 35.67,89.68 35.44,89.9 35.44,90.04 v2(35.53,90.13)
QSA5: length 20.1
  TOP w0.102: v5(52.27,96.11) 52.41,96.11 52.59,95.94 52.59,95.72 52.31,95.44 48.3,95.44 47.25,94.38 47.1,94.38 46.87,94.62 46.57,94.62 46.24,94.29 46.24,93.99 46.48,93.76 46.48,93.61 46.26,93.4 46.12,93.4 45.88,93.63 45.58,93.63 45.26,93.31 45.26,93.01 45.49,92.77 45.49,92.63 43.68,90.82 43.36,90.82 43.31,90.87 42.7,90.87 42.65,90.82 39.05,90.82 38.64,90.41 38.64,90.06 UV7.C7
  BOTTOM w0.122: UV1.W23 52.73,95.72 52.33,96.11 v5(52.27,96.11)
QSA6: length 17.6
  TOP w0.102: v2(36.1,91.79) 36.48,92.18 36.48,92.61 36.14,92.95 UV7.F3
  IN3 w0.102: v5(49.91,92.86) 49.62,93.15 43.09,93.15 41.2,91.26 37.06,91.26 36.57,91.75 36.57,91.96 36.49,92.04 36.17,92.04 36.1,91.97 v2(36.1,91.79)
  BOTTOM w0.102: v5(49.91,92.86) 50.29,93.24 UV1.AB26
QSA7: length 17.6
  BOTTOM w0.102: UV6.C7 38.51,92.78 38.51,92.01 38.98,91.53 44.42,91.53 45.86,92.97 45.86,95.99 47.68,97.81 49.94,97.81 UV1.T26
QSA#0: length 27.8
  IN3 w0.102: v5(55.76,106.93) 55.76,107.19 55.71,107.24 55.45,107.24 55.17,107.53 55.17,108.97 54.75,109.39 54.37,109.39 53.22,110.53 53.22,111.22 52.84,111.6 49.9,111.6 45.32,107.01 36.98,107.01 36.15,106.19 36.15,105.68 35.87,105.39 35.62,105.39 35.52,105.29 v2(35.52,105.09)
  BOTTOM w0.102: UV4.G3 35.12,105.49 v2(35.52,105.09) ; UV1.F19 56.11,106.58 v5(55.76,106.93)
QSA#1: length 34.3
  TOP w0.102: v2(36.08,108.19) 36.08,108.03 35.94,107.89 35.69,107.89 35.56,108.03 35.56,108.63 35.46,108.72 35.14,108.72 UV5.G3
  IN1 w0.097: v2(36.08,108.19) 36.08,108.06 36.26,107.88 36.55,107.88 36.83,107.61 36.83,107.5 37.13,107.2 37.54,107.2 37.93,107.59 37.93,111.39 37.93,111.39 37.93,111.41 37.93,111.41 37.93,111.46 38.03,111.57 38.04,111.57 38.24,111.77 38.24,111.78 38.47,112 39.23,112 40.68,113.45 56.59,113.45 57.5,112.54 57.5,112.54 59.05,110.99 59.05,110.86 59.53,110.38 59.53,109.41 59.6,109.35 v5(59.81,109.35)
  BOTTOM w0.102: UV1.C14 60.18,108.89 59.91,108.89 59.69,109.11 59.69,109.23 v5(59.81,109.35)
QSA#2: length 31
  TOP w0.102: v5(58.16,110.14) 58.43,110.41 58.43,110.77 58.04,111.17 58.04,112.3 56.12,114.22 55.39,114.22 55.29,114.12 55.29,114.09 55.05,113.85 54.64,113.85 54.4,114.09 54.4,114.33 54.28,114.46 54.02,114.46 53.89,114.33 53.89,114.06 53.68,113.85 53.22,113.85 53.01,114.06 53.01,114.33 52.88,114.46 52.63,114.46 52.5,114.33 52.5,114.06 52.29,113.85 51.83,113.85 51.62,114.06 51.62,114.12 51.52,114.22 v3(48.36,114.22) 47.04,114.22 44.62,111.81 44.62,109.88 42.62,107.88 40.89,107.88 39.71,106.69 39.12,106.69 38.72,106.29 38.72,105.47 38.78,105.41 39.03,105.41 UV5.B7
  BOTTOM w0.122: v5(58.16,110.14) 58.51,110.14 58.59,110.22 UV1.A16
QSA#3: length 20.9
  BOTTOM w0.102: UV4.B7 39.12,108.76 38.94,108.94 38.77,108.94 38.66,108.83 38.66,107.93 38.91,107.67 40.04,107.67 v3(42.37,110) 45.95,113.58 51.51,113.58 53.43,111.67 53.43,110.74 UV1.A22
QSA#4: length 23.6
  IN1 w0.097: v2(35.49,89.34) 35.49,89.54 35.98,90.02 35.98,90.4 36.46,90.88 37.47,90.88 38.14,91.54 40.01,91.54 40.21,91.74 40.21,92.46 40.31,92.56 40.6,92.56 40.69,92.46 40.69,91.74 40.9,91.54 43.69,91.54 47.73,95.58 47.99,95.58 51.18,98.77 51.18,99.25 51.39,99.46 v5(51.47,99.46)
  BOTTOM w0.102: v5(51.47,99.46) 51.47,99.49 51.13,99.83 UV1.P25 ; v2(35.49,89.34) 35.49,89.37 35.5,89.37 35.13,89.74 UV6.G3
QSA#5: length 20
  TOP w0.102: v2(53.1,96.1) 53,96.1 52.78,95.88 52.78,95.65 52.39,95.25 48.38,95.25 47.33,94.2 47.03,94.2 46.79,94.43 46.65,94.43 46.43,94.21 46.43,94.07 46.67,93.84 46.67,93.54 46.34,93.21 46.04,93.21 45.81,93.44 45.66,93.44 45.45,93.23 45.45,93.08 45.68,92.85 45.68,92.55 43.76,90.63 v3(43.02,90.63) 39.13,90.63 38.83,90.33 38.83,90.06 UV7.B7
  BOTTOM w0.122: UV1.W22 53.48,95.72 v2(53.1,96.1)
QSA#6: length 17.5
  TOP w0.102: UV7.G3 35.5,92.95 35.57,92.88 35.57,92.37 35.68,92.26 35.9,92.26 v2(36.09,92.44)
  IN3 w0.102: v2(36.09,92.44) 36.09,92.31 36.17,92.23 36.57,92.23 36.76,92.04 36.76,91.83 37.14,91.45 41.12,91.45 43.01,93.34 49.62,93.34 49.91,93.63 v2(49.92,93.63)
  BOTTOM w0.102: v2(49.92,93.63) 49.53,93.24 UV1.AB27
QSA#7: length 17.6
  BOTTOM w0.102: UV6.B7 39.17,92.95 39.28,93.06 39.28,93.21 39.17,93.32 38.82,93.32 38.69,93.2 38.69,92.09 39.06,91.72 44.34,91.72 45.68,93.05 45.68,96.07 47.6,97.99 49.32,97.99 UV1.T27
RED_CRT: length 159
  IN1 w0.097: v3(188.92,171.44) 189.33,171.85 190.73,171.85 192.73,169.84 195.3,169.84 196.23,168.91 201.41,168.91 212.2,168.91 215.43,172.15 223.09,172.15 226.05,169.19 249.41,169.19 250.21,168.39 261.97,168.39 262.84,167.51 277.92,167.51 278.49,168.08 278.94,168.08 279.03,167.99 279.03,167.73 279.16,167.6 279.51,167.6 279.64,167.73 279.64,167.99 279.73,168.08 283.9,168.08 284.7,168.89 307.95,168.89 308.39,168.44 317.27,168.44 317.53,168.18 330.19,168.18 331.15,169.15 336.74,169.15 v2(336.82,169.23)
  BOTTOM w0.102: U39.27 188.32,170.85 v3(188.92,171.44) ; v2(336.82,169.23) 336.82,169.46 337.31,169.95 JIO1.34
RED_DOCK: length 10
  IN3 w0.102: v2(188.26,171.44) 187.65,170.83 186.96,170.83 186.6,171.18 186.6,172.05 185.55,173.1 183.36,173.1 182.62,172.35 v2(182.62,172.2)
  BOTTOM w0.102: U39.26 187.92,171.11 v2(188.26,171.44) ; v2(182.62,172.2) 182.64,172.22 182.34,172.22 182.01,172.55 L70.1
RED_DOCK_PI: length 3.7
  BOTTOM w0.102: L70.2 181.14,173.85 v1(181.12,173.87) 180.95,174.04 JDOCK1.53
REF_+1.05V_MP: length 4.3
  BOTTOM w0.203: PU150.26 80.39,70.03 79.77,70.65 79.29,70.65 v1(79.06,70.42) 78.53,70.42 78.25,70.7 PC156.2
REGCTL_PNP10: length 2.4
  TOP w0.203: U21.7 199.31,145.04
  TOP w0.254: L26.1 199.31,143.81 199.31,145.04
REM_DIODE1_N: length 109.2
  TOP w0.254: v2(168.34,119.83) 168.19,119.68 U38.B13 ; Q11.3 146.29,75.49 C370.1 146.57,75.21 151.16,75.21 151.73,74.64 153.28,74.64 153.87,74.05 154.31,74.05 v4(154.47,74.22) ; C358.1 170.37,113.52 v3(170.35,113.5)
  IN1 w0.254: v3(192.73,85.25) 192.56,85.09 192.17,85.09 191.54,84.46 191.54,84.27 186.15,78.88 179.84,78.88 179.3,79.41 174.54,79.41 174.26,79.69 170.95,79.69 170.01,78.75 169.68,78.75 168.95,78.02 166.11,78.02 165.91,78.22 163.11,78.22 162.8,78.53 159.87,78.53 159.59,78.8 158.24,78.8 157.38,77.94 156.69,77.25 156.53,77.09 156.53,74.91 156.02,74.41 154.66,74.41 v4(154.47,74.22)
  BOTTOM w0.254: v2(168.34,119.83) 168.01,119.51 168.01,115.51 169.79,113.73 170.12,113.73 v3(170.35,113.5) 170.35,112.25 172.84,109.77 172.84,103.31 175.27,100.88 175.78,100.88 177.94,98.72 177.94,98.06 178.81,97.19 180.09,97.19 183.4,93.89 184.08,93.89 185.86,92.11 186.83,92.11 187.62,92.91 190.15,92.91 191.18,91.88 191.51,91.55 191.51,87.84 193.36,85.99 193.36,85.29 193.18,85.1 192.88,85.1 v3(192.73,85.25)
REM_DIODE1_P: length 111.9
  TOP w0.254: v2(170.96,113.5) 170.96,114.01 C358.2 ; U38.A13 v1(168.44,117.22) 168.8,116.86 v2(169.16,116.86) ; Q11.1 143.8,74.84 Q11.2 144.79,74.53 C370.2 146.67,74.87 151.02,74.87 151.59,74.29 153.14,74.29 153.72,73.71 154.38,73.71 v3(154.51,73.58)
  IN1 w0.254: v3(192.75,84.42) 192.59,84.58 192.38,84.58 192.05,84.25 192.05,84.06 186.36,78.37 179.62,78.37 179.09,78.9 174.33,78.9 174.05,79.18 171.16,79.18 170.22,78.24 169.89,78.24 169.16,77.52 166.26,77.52 166.02,77.27 163.52,77.27 162.61,78.19 162.19,78.19 161.55,77.55 161.15,77.55 160.89,77.81 160.89,77.97 160.68,78.19 159.73,78.19 159.45,78.46 158.38,78.46 157.62,77.7 156.93,77.01 156.88,76.96 156.88,74.78 156.06,73.96 154.88,73.96 v3(154.51,73.58)
  BOTTOM w0.254: v2(169.16,116.86) 168.76,116.86 168.52,116.62 168.52,115.72 170,114.24 170.45,114.24 170.96,113.73 v2(170.96,113.5) 170.96,113.39 170.86,113.29 170.86,112.46 173.35,109.98 173.35,103.52 175.48,101.38 175.99,101.38 178.45,98.93 178.45,98.27 179.02,97.7 180.31,97.7 183.61,94.4 184.29,94.4 186.07,92.62 186.62,92.62 187.41,93.42 190.36,93.42 191.39,92.39 192.02,91.76 192.02,88.05 193.87,86.2 193.87,85.08 193.39,84.59 192.93,84.59 v3(192.75,84.42)
REM_DIODE2_N: length 181.5
  TOP w0.254: v2(169.1,119.77) 168.89,119.56 168.69,119.36 U38.B14 ; v2(170.86,115.96) 171.29,115.53 C359.1 ; Q13.3 60.24,67.02 C372.2 64.23,67.02 64.62,67.41 64.62,69.22 64.48,69.37 64.04,69.8 63.14,70.71 v6(63.14,73.95) 63.14,75.44 64.15,76.45 64.15,77.96 63.68,78.43 63.68,81.72 61.92,83.49 61.92,84.19 v3(61.97,84.24)
  IN3 w0.254: v3(61.97,84.24) 61.97,85.45 64.13,87.61 64.13,88.66 64.58,89.11 65.78,89.11 67.25,87.64 69.64,87.64 70.84,86.44 73.11,86.44 75.17,88.51 75.17,95.22 79.47,99.52 79.47,112.99 84.21,117.74 94.24,117.74 96.96,115.02 97.22,115.02 98.7,113.54 98.7,110.14 99.81,109.03 109.5,109.03 109.91,108.61 113.05,108.61 114.23,107.43 117.43,107.43 120.6,110.6 128.62,110.6 129.71,109.51 131.39,109.51 131.9,110.02 146.46,110.02 147.92,111.48 148.99,111.48 149.79,110.68 153.97,110.68 155.72,112.43 156.4,112.43 157.02,111.82 160.45,111.82 160.86,112.23 164.68,112.23 165.24,112.79 165.24,114.05 165.4,114.21 169.41,114.21 170.86,115.66 v2(170.86,115.96) 170.86,116.62 171.09,116.84 171.09,117.77 170.49,118.37 169.41,118.37 169.1,118.69 v2(169.1,119.77)
REM_DIODE2_P: length 178.4
  TOP w0.254: v2(170.22,115.99) 170.22,115.38 C359.2 ; v2(169.13,117.45) 168.95,117.63 168.95,118.18 U38.A14 ; Q13.2 60.83,67.6 Q13.1 63.19,67.6 C372.1 64.11,68.53 64.11,69.01 62.63,70.5 62.63,75.65 63.64,76.66 63.64,77.75 63.17,78.22 v6(63.17,79.77) 63.17,81.51 61.41,83.28 61.41,84.13 v3(61.33,84.21)
  IN3 w0.254: v2(169.13,117.45) 169.54,117.86 170.28,117.86 170.58,117.56 170.58,117.05 170.22,116.7 v2(170.22,115.99) 170.22,115.74 169.2,114.72 165.19,114.72 164.74,114.26 164.74,113 164.47,112.74 160.65,112.74 160.24,112.33 157.23,112.33 156.61,112.94 155.51,112.94 153.75,111.19 150,111.19 149.2,111.99 147.71,111.99 146.25,110.53 131.69,110.53 131.18,110.02 129.92,110.02 128.83,111.11 120.39,111.11 117.22,107.94 114.44,107.94 113.26,109.12 110.13,109.12 109.71,109.54 100.02,109.54 99.2,110.35 99.2,113.75 97.43,115.53 97.17,115.53 94.45,118.25 84,118.25 78.96,113.2 78.96,99.73 74.67,95.43 74.67,88.72 72.9,86.95 71.14,86.95 69.91,88.17 67.45,88.17 65.98,89.65 64.35,89.65 63.62,88.91 63.62,87.82 61.33,85.53 v3(61.33,84.21)
REM_DIODE3_N: length 161.6
  TOP w0.254: v3(194.68,84.44) 194.81,84.31 194.81,78.47 197.55,75.73 200.11,75.73 200.97,74.87 206.51,74.87 207.78,73.6 212.59,73.6 v1(213.96,72.23) 216.45,69.74 216.45,68.46 215.46,67.47 211.57,67.47 210.78,66.69 210.2,66.69 208.04,64.53 208.04,60.68 208.33,60.39 208.33,59.01 209.49,57.85 209.49,56.62 208.7,55.84 208.7,53.87 207.09,52.26 v3(206.75,52.26) ; U38.A15 169.44,117.79 169.85,117.38 v3(170.07,117.38) ; v3(174.04,112.5) 174.04,112.72 174.58,113.26 C382.1
  BOTTOM w0.254: v3(206.75,52.26) 206.34,52.26 204.2,50.13 164.13,50.13 161.01,53.25 158.08,53.25 C383.2 157.68,53.65 Q15.3 ; v3(170.07,117.38) 170.35,117.38 172.35,115.37 172.54,115.37 174.04,113.87 v3(174.04,112.5) 174.04,112.41 174.13,112.32 174.13,106.61 175.7,105.04 177.28,105.04 178.27,104.04 178.27,100.81 179.75,99.33 180.15,98.93 183.52,95.56 183.9,95.19 189.67,95.19 190.71,94.14 191.58,94.14 193.44,92.29 193.44,92.08 193.44,92.08 193.44,87.71 194.73,86.42 194.73,84.49 v3(194.68,84.44)
REM_DIODE3_P: length 166.7
  TOP w0.254: U38.B16 169.69,119.3 169.61,119.38 169.61,120.15 v2(169.38,120.38) ; v3(195.32,84.44) 195.32,78.68 197.76,76.24 199.9,76.24 199.9,76.24 200.32,76.24 201.18,75.37 206.72,75.37 207.99,74.1 212.8,74.1 214.32,72.59 214.41,72.5 214.41,72.5 v1(215.95,70.96) 216.96,69.95 216.96,68.25 215.67,66.97 211.78,66.97 210.99,66.18 210.41,66.18 208.55,64.32 208.55,60.89 208.84,60.6 208.84,59.22 210,58.06 210,56.41 209.21,55.63 209.21,53.62 207.34,51.75 207.15,51.75 v3(206.98,51.57) ; C382.2 175.49,113.22 174.76,112.5 v3(174.68,112.5)
  BOTTOM w0.254: Q15.2 155.7,53 Q15.1 157.35,52.54 C383.1 158.08,52.74 160.8,52.74 163.92,49.62 204.41,49.62 206.37,51.57 v3(206.98,51.57) ; 174.64,112.53 174.64,106.82 175.91,105.55 177.49,105.55 178.78,104.25 178.78,101.02 180.11,99.69 180.51,99.29 184.11,95.69 189.88,95.69 190.93,94.65 191.79,94.65 193.95,92.5 193.95,91.87 193.95,91.87 193.95,87.92 195.24,86.63 195.24,84.52 v3(195.32,84.44) ; 174.64,112.53 v3(174.68,112.5) ; 174.64,112.53 174.55,112.62 174.55,114.08 172.76,115.88 172.56,115.88 170.69,117.75 169.61,118.83 169.61,120.15 v2(169.38,120.38)
REM_DIODE4_N: length 6.7
  TOP w0.254: U38.A16 170.25,117.88 170.29,117.88 170.43,117.74 170.65,117.74 171.1,117.28 171.41,117.28 171.59,117.1 171.59,116.7 C361.1 172.24,115.9 172.24,115.71 Q14.3 172.25,114.39 171.99,114.12 C373.1
REM_DIODE4_P: length 8.2
  TOP w0.254: C373.2 Q14.1 172.9,114.76 173.55,115.41 Q14.2 173.35,115.71 C361.2 172.1,116.95 172.1,117.31 171.62,117.79 171.31,117.79 170.86,118.25 170.64,118.25 170.19,118.7 U38.B17
RES_BIAS: length 3.8
  TOP w0.203: v1(203.24,145.12) 202.58,145.12 202.35,145.35 201.57,145.35 201.31,145.61 U21.12
  TOP w0.508: v1(203.24,145.12) 203.89,145.12 R185.1
RESET_OUT#: length 123.9
  TOP w0.102: v3(198.67,62.24) v1(198.67,60.36) 198.22,59.92 198.22,56.82 194.15,52.74 185.69,52.74 183.76,54.67 183.76,55.03 RC263.2 183.41,55.34 182.82,54.75 182.82,53.71 182.67,53.55 RC84.1 RC88.1 ; v2(168.38,127.58) 168.38,127.78 168.19,127.98 U38.B39 ; v3(168.9,131.13) 168.9,131.15 168.27,131.79 R373.2
  IN1 w0.097: v3(168.9,131.13) 169.28,131.13 169.61,130.8 169.61,128.81 v2(168.38,127.58)
  IN2 w0.102: v3(198.67,62.24) 198.67,62.75 200.17,64.25 200.17,68.16 200.24,68.24 200.24,73.38 203.55,76.68 203.55,80.02 200.93,82.63 200.93,83.24 199.38,84.79 199.38,85.31 198.71,85.98 198.71,88.91 198.42,89.2 198.42,95.48 194.91,98.98 194.91,101.86 188.79,107.98 188.79,109.26 188.03,110.02 188.03,114.24 182.97,119.29 182.97,121.38 182.28,122.07 176.91,122.07 176.29,122.69 175.37,122.69 174.46,123.6 174.46,128.01 174.29,128.18 168.64,128.18 168.38,127.92 v2(168.38,127.58)
REXTB: length 3.5
  TOP w0.102: U83.7 302.15,163.77 302.61,163.31 v1(302.61,162.67) 302.61,161.99 302.78,161.81 R2644.1
RF_+VDDRP: length 1.8
  BOTTOM w0.254: PU700.5 33.83,27.86 33.59,27.62 32.81,27.62 PR705.1
RING2: length 32
  IN3 w1.016: 333.67,158.96 332.91,158.2 332.91,156.48 322.9,146.47 315.15,146.47 314.75,146.87 311.24,146.87 310.73,147.38
  BOTTOM w0.254: R187.1 310.2,147.77 v2(310.01,147.96) 310.01,148.41 v2(309.88,148.53) 309.73,148.68 U17.28
  vias: v2(333.85,159.12) v2(334.53,159.19)
ROM_SCLK: length 8
  BOTTOM w0.102: UV1.C12 62.28,109.35 62.28,110.01 62.47,110.2 62.47,110.75 60.46,112.76 59.34,112.76 v1(59.09,113.01) RV89.2
ROM_SI: length 7.9
  BOTTOM w0.102: RV90.2 v1(57.82,113.19) 57.93,113.19 58.44,112.69 58.92,112.69 59.2,112.41 60.49,112.41 62.22,110.67 62.22,110.24 62.08,110.09 62.08,109.95 UV1.B12
ROM_SO: length 9.2
  BOTTOM w0.102: v1(54.6,115.12) 55.59,114.13 RV92.2 57.34,112.43 58.83,112.43 59.11,112.16 60.34,112.16 61.87,110.62 UV1.A12
RSMRST#: length 7.3
  TOP w0.102: R440.2 167.38,140.17 167.07,140.47 v1(166.65,140.47) 166.49,140.47 166.18,140.17 U42.2 166.18,138.77 166.01,138.59 165.24,138.59 164.99,138.85 164.99,140.37 164.62,140.74 U41.3
RTD2136_SCL: length 10.8
  TOP w0.102: v3(109.21,121.74) 109.21,121.75 v1(108.8,122.16) 107.99,122.16 R2590.1 R2592.2 ; U52.48 114.73,121.76 v3(114.54,121.58)
  IN3 w0.102: v3(109.21,121.74) 109.21,121.47 109.39,121.3 109.92,121.3 110.15,121.07 110.15,120.62 110.46,120.31 113.91,120.31 114.34,120.74 114.34,121.37 v3(114.54,121.58)
RTD2136_SDA: length 10.3
  TOP w0.102: v3(111.37,121.68) 111.04,122.01 R2591.1 R2593.2 ; v4(113.91,121.6) 114.47,122.16 U52.47
  IN3 w0.102: v4(113.91,121.6) 114.11,121.4 114.11,120.83 113.81,120.53 110.56,120.53 110.38,120.71 110.38,121.4 110.51,121.53 111.22,121.53 v3(111.37,121.68)
RUN_ON: length 237.6
  TOP w0.102: v3(205.63,109.89) 202.61,109.89 201.72,109 199.14,109 196.57,106.44 186.72,106.44 186.59,106.57 186.34,106.57 v6(182.61,110.3) 181.55,111.37 180.59,111.37 178.36,109.14 167.14,109.14 R418.1 ; U37.A11 190.84,129.97 191.55,130.69 192.04,130.69 R303.2 192.26,131.83 192.26,132.62 192.29,132.65 192.29,132.68 193.99,134.38 198.03,134.38 198.39,134.02 198.39,133.4 Q5.2 199.38,134.05 201.92,134.05 202.96,133.01 v3(202.96,130.87)
  IN2 w0.102: v3(208.9,100.28) 208.18,101 207.71,101 206.48,102.23 206.48,107.44 205.63,108.29 v3(205.63,109.89) 206.39,110.65 206.39,126.55 202.96,129.98 v3(202.96,130.87) ; v3(254.78,165.77) 255.03,165.77 v3(261.23,171.97)
  IN3 w0.102: v3(254.78,165.77) 254.19,165.19 251.37,165.19 248.15,168.41 235.95,168.41 233.8,166.26 233.8,155.42 233.8,152.34 233.8,151.42 234.33,150.89 234.33,148.2 234,147.87 231.66,147.87 225.09,141.29 217.58,141.29 216.23,139.94 209.91,139.94 209.78,140.07 209.03,140.07 208.65,139.69 208.65,139.41 202.99,133.74 202.99,130.87 v3(202.96,130.87)
  BOTTOM w0.102: R154.1 267.78,184.03 261.23,177.48 v3(261.23,171.97) ; v3(208.9,100.28) 214.18,100.28 215.76,101.87 222.5,101.87 222.68,101.68 224.23,101.68 231.11,94.8 PR206.1 ; R426.1 253.25,162.65 253.48,162.88 253.48,164.22 254.78,165.52 v3(254.78,165.77)
RUN_ON#: length 2.9
  TOP w0.102: Q5.5 Q5.6 200.26,131.33 R36.2 v1(201.43,131.25)
RUNPWROK: length 230.3
  TOP w0.102: U38.B26 170.17,123.64 v2(169.76,123.23) ; v2(196.03,132.12) 196.1,132.19 196.1,132.88 196.45,133.23 Q5.3 197.91,133.82 197.68,134.06 196.09,134.06 v1(195.67,133.64) 194.94,132.91 194.69,132.91 194.33,132.56 U37.A4 ; v2(173.9,126.45) 174.01,126.45 R35.2 ; v3(86.15,85.41) 86.4,85.15 86.4,84.74 90.18,80.96 96.71,80.96 97.27,80.4 100.27,80.4 v3(100.73,79.95)
  IN1 w0.097: v3(100.73,79.95) 100.49,79.71 100.49,79.51 100.11,79.14 99.22,79.14 98.61,78.53 v3(98.61,77.4) ; v2(173.9,126.45) 171.95,128.41 171.95,129.87 174.65,132.57 177.54,132.57 177.99,133.03 181.83,133.03 182.54,133.74 186.16,133.74 186.84,134.42 189.91,134.42 192.33,131.99 195.9,131.99 v2(196.03,132.12) ; v3(93.54,117.05) 93.26,117.33 v3(93.26,121.06)
  IN3 w0.102: v2(173.9,126.45) 173.47,126.88 172.53,126.88 171.73,126.08 171.73,125.2 171.67,125.13 v2(169.76,123.23) 169.15,122.62 163.9,122.62 163.59,122.31 161.7,122.31 161.54,122.47 156.97,122.47 156.47,122.97 155.31,122.97 154.7,122.36 154.7,119.52 154.26,119.07 154.26,115.04 153.77,114.55 151.84,114.55 151.62,114.77 147.96,114.77 147.18,113.99 147.18,113.6 146.41,112.83 144,112.83 143.84,112.66 140.34,112.66 139.94,113.06 139.75,113.06 128.44,113.06 127.66,112.28 118.91,112.28 116.56,109.93 115.87,109.93 115.45,110.35 114.7,110.35 114.61,110.26 110.62,110.26 110.14,110.74 105.88,110.74 102.34,114.28 100.5,114.28 93.71,121.06 v3(93.26,121.06) ; v3(98.61,77.4) 99.43,76.58 99.43,75.78 v3(99.46,75.75) 100.9,75.75 v3(101.74,74.92) ; v3(86.15,85.41) 85.82,85.74 78.68,85.74 75.86,88.56 75.86,93.97 80.15,98.26 80.15,112.71 84.5,117.05 v3(93.54,117.05)
  BOTTOM w0.102: UC6.4 101.06,78.9 101.24,79.08 101.24,79.11 101.26,79.13 101.26,79.47 101.11,79.62 101.11,79.79 100.96,79.95 v3(100.73,79.95) ; v3(101.74,74.92) 101.56,75.1 UC6.10 ; UC6.13 99.53,75.93 99.46,75.86 v3(99.46,75.75) ; UC6.1 v3(98.61,77.4)
S5_1.35V: length 4.1
  BOTTOM w0.203: PU100.8 35.79,13.76 v1(35.73,13.82) 35.27,14.28 PC115.1 ; PC115.1 PR108.2 ; PC115.1 PR107.2
SATA_ACT#: length 89.6
  TOP w0.102: Q24.4 221.11,35.93 220.9,36.13 218.43,36.13 217.87,36.69 v1(217.87,41.54) 217.87,42.51 218.91,43.55 v3(219.14,43.55)
  IN1 w0.097: v3(201.18,72.99) 200.9,72.99 198.92,74.97 198.92,75.29 196.33,77.88 190.33,77.88 189.96,77.51 188.04,77.51 187.87,77.67 180.57,77.67 180.37,77.47 179.57,77.47 179.24,77.8 178.71,77.8 178.29,78.22 176.62,78.22 176.29,77.89 176.29,76.34 175.82,75.87 174.59,75.87 174.26,76.2 173.63,76.2 173.51,76.08 172.71,76.08 172.48,75.86 v2(169.82,75.86)
  IN2 w0.102: v3(201.18,72.99) 201.01,72.81 201.01,68.6 205.15,64.46 205.15,61.39 204.3,60.54 204.3,59.18 208.45,55.03 208.75,55.03 208.98,54.8 208.98,54.52 210.91,52.59 210.91,52.03 212.43,50.51 212.43,49.28 218.16,43.55 v3(219.14,43.55)
  BOTTOM w0.076: UC1.U3 167.12,75.05 167.36,74.8 167.62,74.8 167.85,75.03 167.85,75.21 168.02,75.38 168.26,75.38 168.33,75.31 169.28,75.31 v2(169.82,75.86)
SATA_COMP: length 13
  TOP w0.102: v2(164.07,92.52) 164,92.59 162.84,92.59 v1(162.39,92.14)
  TOP w0.381: v2(164.07,92.52) 164.2,92.39 RC19.1
  BOTTOM w0.102: UC1.C12 161.03,84.02 161.4,84.4 161.4,84.84
  BOTTOM w0.305: v2(164.07,92.52) 163.54,91.99 163.54,90.16 162.25,88.86 162.18,88.86 161.7,88.38 161.7,86 161.4,85.7 161.4,84.84
SATA_IREF: length 10.9
  TOP w0.381: RC14.2 164.23,93.28 v2(164.07,93.13)
  BOTTOM w0.305: v2(164.07,93.13) 163.73,93.13 162.93,92.33 v1(162.93,90.64) 162.93,90.18 162.12,89.37 161.89,89.37 161.18,88.66 161.18,88.33 161.18,88.33 161.18,86.32 160.96,86.11 160.96,84.62 UC1.A12
SATA_ODD_PRX_DTX_N2: length 4.1
  TOP w0.102: CS3.2 233.85,27.6 v3(234.38,27.6)
  BOTTOM w0.102: JSATA2.5 236.44,27.29 236.11,27.62 234.41,27.62 v3(234.38,27.6)
SATA_ODD_PRX_DTX_N2_C: length 140.6
  TOP w0.102: v2(193.87,94.73) 193.58,95.02 193.58,95.19 193.83,95.44 197.09,95.44 197.11,95.43 197.64,95.43 197.65,95.44 199.13,95.44 200.37,94.19 209.93,94.19 215.92,88.21 215.92,78.95 225.82,69.05 225.82,64.27 232.71,57.39 232.71,45.2 235.45,42.45 235.45,30.77 234.38,29.7 234.13,29.7 232.8,29.7 232.01,28.91 232.01,28.02 232.25,27.78 232.44,27.78 CS3.1
  IN1 w0.076: v2(164.13,79.54) 164.13,79.55 164.23,79.65 164.32,79.65 164.52,79.45 164.52,79.22 164.81,78.93 165.29,78.93 165.51,79.15 167.35,79.15 169.21,81
  IN1 w0.097: v2(193.87,94.73) 193.86,94.73 193.5,94.37 193.5,89.1 189.67,85.28 189.67,84.42 186.53,81.29 184.79,81.29 182.96,83.11 180.66,83.11 178.64,81.09 175.18,81.09 174.57,81.7 169.9,81.7 169.21,81
  BOTTOM w0.076: v2(164.13,79.54) 164.33,79.33 UC1.J6
SATA_ODD_PRX_DTX_P2: length 4.3
  TOP w0.102: CS4.2 233.73,28.33 233.98,28.08 234.2,28.08 v4(234.38,28.26)
  BOTTOM w0.102: JSATA2.6 236.77,28.56 236.31,28.1 234.53,28.1 v4(234.38,28.26)
SATA_ODD_PRX_DTX_P2_C: length 140.5
  TOP w0.102: CS4.1 232.44,27.99 232.34,27.99 232.22,28.1 232.22,28.82 232.89,29.49 233.64,29.49 234.21,29.49 234.22,29.49 234.47,29.49 235.66,30.68 235.66,42.54 232.92,45.29 232.92,57.48 226.04,64.36 226.04,69.14 216.13,79.04 216.13,88.3 210.02,94.41 200.46,94.41 199.22,95.66 v3(197.37,95.66) 193.74,95.66 193.36,95.28 193.36,94.78 v2(193.28,94.7)
  IN1 w0.076: 169.13,81.22 169.04,81.13 169.04,81.07 167.28,79.31 165.44,79.31 165.23,79.09 164.88,79.09 164.68,79.29 164.68,79.52 164.12,80.09 v2(164.12,80.11)
  IN1 w0.097: 169.13,81.22 169.82,81.91 174.66,81.91 175.26,81.3 178.55,81.3 180.57,83.32 183.05,83.32 184.87,81.5 186.45,81.5 189.46,84.51 189.46,85.36 193.28,89.19 v2(193.28,94.7)
  BOTTOM w0.076: UC1.H6 164.24,79.98 v2(164.12,80.11)
SATA_ODD_PTX_DRX_N2: length 4.1
  TOP w0.102: v4(234.38,24.34) 233.85,24.34 233.68,24.51 CS2.2
  BOTTOM w0.102: v4(234.38,24.34) 236.03,24.34 236.44,24.75 JSATA2.3
SATA_ODD_PTX_DRX_N2_C: length 148.4
  TOP w0.102: CS2.1 232.77,24.19 232.68,24.1 231.99,24.1 231.52,24.57 231.52,29.11 232.6,30.19 233.93,30.19 234.97,31.23 234.97,42.25 231.88,45.34 231.88,57.48 225.28,64.08 225.28,68.88 215.29,78.87 215.29,88.15 212.14,91.3 205.24,91.3 205.02,91.52 205.02,92.58 203.96,93.65 v3(201.69,93.65) 195.71,93.65 193.44,91.38 187.34,91.38 187.05,91.67 187.05,93.39 186.78,93.66 186.53,93.66 v3(186.33,93.86)
  IN1 w0.097: v2(159.88,89.24) 160.05,89.07 160.36,89.07 161.16,89.87 161.16,90.7 160.63,91.24 160.63,91.82 160.94,92.13 161.14,92.13 162.8,93.79 163.64,93.79 163.64,93.8 165.27,93.8 165.64,93.43 171.34,93.43 171.8,93.89 177.73,93.89 177.88,94.05 184.71,94.05 185.15,93.61 186.07,93.61 v3(186.33,93.86)
  BOTTOM w0.076: UC1.B14 159.74,83.81 159.62,83.81 159.54,83.88 159.54,84.04 159.81,84.3 159.81,85.2 159.93,85.33 159.93,87.26 160.66,87.98 160.66,88.87 160.47,89.06 160.06,89.06 v2(159.88,89.24)
SATA_ODD_PTX_DRX_P2: length 4.3
  TOP w0.102: v3(234.38,23.71) 234.31,23.71 234.15,23.86 233.9,23.86 233.68,23.65 CS1.2
  BOTTOM w0.102: v3(234.38,23.71) 234.53,23.86 235.88,23.86 236.26,23.48 JSATA2.2
SATA_ODD_PTX_DRX_P2_C: length 148.4
  TOP w0.102: v4(186.3,93.15) 186.3,93.37 186.38,93.45 186.69,93.45 186.83,93.31 186.83,91.58 187.25,91.16 193.53,91.16 195.8,93.43 201.4,93.43 201.43,93.41 202.01,93.41 202.03,93.43 203.87,93.43 204.8,92.49 204.8,91.43 205.15,91.08 212.05,91.08 215.08,88.06 215.08,78.78 225.06,68.79 225.06,63.99 231.66,57.39 231.66,45.25 234.75,42.16 234.75,31.32 233.84,30.4 232.51,30.4 231.31,29.2 231.31,24.48 231.9,23.89 232.45,23.89 CS1.1
  IN1 w0.097: v2(159.88,88.66) 160.09,88.86 160.45,88.86 161.37,89.78 161.37,90.79 160.84,91.32 160.84,91.73 161.03,91.92 161.23,91.92 162.89,93.58 163.72,93.58 163.73,93.59 165.19,93.59 165.55,93.22 171.43,93.22 171.89,93.68 177.82,93.68 177.97,93.84 184.62,93.84 185.06,93.4 186.05,93.4 v4(186.3,93.15)
  BOTTOM w0.076: UC1.C15 159.38,83.52 159.38,84.1 159.64,84.37 159.64,85.27 159.77,85.4 159.77,87.33 160.49,88.05 160.49,88.81 160.4,88.9 160.01,88.9 159.88,88.77 v2(159.88,88.66)
SATA_PRX_DKTX_N0: length 3
  TOP w0.102: C313.2 182.5,182.31 v2(181.94,182.86)
  BOTTOM w0.102: JDOCK1.56 181.45,183.83 181.35,183.73 181.35,183.58 181.41,183.51 181.56,183.51 181.78,183.3 181.78,183.03 v2(181.94,182.86)
SATA_PRX_DKTX_N0_C: length 169.6
  TOP w0.102: C313.1 182.25,181.09 182.25,180.88 181.98,180.62 181.98,180.38 v2(182.03,180.33)
  IN1 w0.076: v2(165.09,79.58) 165.09,79.64 165.42,79.97 165.42,80.29 165.14,80.57 165.01,80.57 164.71,80.86 164.71,81.27 164.77,81.34 164.77,81.74 164.75,81.77 164.75,83.3
  IN1 w0.097: 164.75,83.3 164.75,83.47 164.74,83.48 164.74,83.68 165.47,84.41 168.61,84.41 174.03,89.82 178.54,89.82 185.27,83.09 185.81,83.09 186.6,83.89 186.6,86.87 191.26,91.53 191.26,93.3 190.92,93.64 190.92,98.13 191.51,98.72 191.51,104.56 195.63,108.68 195.63,109.46 197.18,111.01 198.14,111.01 201.55,114.42 201.55,115.08 205.39,118.92 205.39,118.92 205.39,121.18 205.79,121.59 205.79,125.72 205.01,126.51 205.01,132.78 202.16,135.62 195,135.62 188.49,142.12 188.49,149.48 184.98,153 181.19,153 180.53,152.34 174.69,152.34 171.85,155.17 171.85,163.08 172.75,163.99 172.75,167.16 173.36,167.78 174.79,167.78 177.25,170.24 177.25,170.51 179.14,172.39 179.14,172.65 180.58,174.09 180.58,175.5 182.16,177.08 182.16,178.8 181.98,178.98 181.98,180.28 v2(182.03,180.33)
  BOTTOM w0.076: v2(165.09,79.58) 165.34,79.33 UC1.J5
SATA_PRX_DKTX_P0: length 2.9
  TOP w0.102: v2(181.36,182.88) 181.61,182.63 C312.2
  BOTTOM w0.102: v2(181.36,182.88) 181.56,183.09 181.56,183.21 181.47,183.3 181.32,183.3 181.13,183.49 181.13,183.69 180.95,183.87 JDOCK1.54
SATA_PRX_DKTX_P0_C: length 169.5
  TOP w0.102: C312.1 181.98,181.34 182.03,181.29 182.03,180.97 181.77,180.71 181.77,180.64 181.45,180.33 v2(181.4,180.33)
  IN1 w0.076: v2(165.06,80.14) 165.06,80.29 164.54,80.8 164.54,81.34 164.61,81.41 164.61,81.67 164.58,81.7 164.58,83.21 164.53,83.26 164.53,83.3
  IN1 w0.097: 164.53,83.3 164.53,83.77 165.38,84.62 168.53,84.62 173.94,90.03 178.63,90.03 185.36,83.3 185.72,83.3 186.39,83.97 186.39,86.96 191.05,91.62 191.05,93.21 190.71,93.55 190.71,98.21 191.3,98.81 191.3,104.65 195.42,108.76 195.42,109.54 197.09,111.22 198.05,111.22 201.34,114.51 201.34,115.17 205.18,119 205.18,121.27 205.58,121.67 205.58,125.63 204.79,126.42 204.79,132.69 202.07,135.41 194.91,135.41 188.41,141.91 188.28,142.04 188.28,149.4 184.9,152.79 181.28,152.79 180.62,152.12 174.6,152.12 171.64,155.09 171.64,163.17 172.54,164.07 172.54,167.25 173.28,167.99 174.7,167.99 177.04,170.33 177.04,170.59 178.93,172.48 178.93,172.74 180.37,174.18 180.37,175.59 181.95,177.17 181.95,178.71 181.77,178.89 181.77,180 181.45,180.33 v2(181.4,180.33)
  BOTTOM w0.076: UC1.H5 165.46,79.91 165.31,79.91 165.23,79.98 165.15,79.98 165.06,80.08 v2(165.06,80.14)
SATA_PRX_DTX_N1: length 5.4
  TOP w0.102: v4(221.76,131.56) 221.5,131.3 221.15,131.3 220.56,131.89 219.8,131.89 C109.1
  BOTTOM w0.102: JSATA1.5 220.3,131.92 220.86,131.37 221.57,131.37 v4(221.76,131.56)
SATA_PRX_DTX_N1_C: length 91.9
  TOP w0.102: v2(217.49,132.63) 217.26,132.4 217.26,132.04 217.47,131.84 218.25,131.84 C109.2
  IN3 w0.086: v2(163.16,79.21) 163.73,79.79 163.73,80.26 163.95,80.48 164.71,80.48 164.74,80.5 165.47,80.5 165.92,80.95 165.92,82.9 167.32,84.31 167.32,88.36 169.65,90.69 169.65,93.79 170.53,94.66 170.53,95.82 171.24,96.53 172.55,96.53 173.09,97.07 174.36,97.07 175.86,98.56 176.64,98.56 180.38,102.3 181.65,102.3 183.12,103.78 183.12,104.39 183.93,105.19 195.98,105.19 199.18,108.39 199.69,108.39 204.21,112.92 205.09,112.92 210.38,118.2 210.38,128.21 214.06,131.89 217,131.89 217.23,132.12 217.23,132.37 v2(217.49,132.63)
  BOTTOM w0.076: UC1.J8 163.28,79.33 v2(163.16,79.21)
SATA_PRX_DTX_P1: length 5.4
  TOP w0.102: v3(221.76,130.87) 221.54,131.09 221.06,131.09 220.47,131.67 219.89,131.67 C108.1
  BOTTOM w0.102: v3(221.76,130.87) 221.48,131.15 220.74,131.15 220.24,130.65 JSATA1.6
SATA_PRX_DTX_P1_C: length 91.7
  TOP w0.102: v3(216.86,132.62) 217.05,132.43 217.05,131.95 217.38,131.62 218.26,131.62 C108.2
  IN3 w0.086: v3(216.86,132.62) 217.06,132.41 217.06,132.19 216.93,132.06 213.99,132.06 210.2,128.28 210.2,118.28 205.02,113.09 204.14,113.09 199.61,108.57 199.1,108.57 195.9,105.37 183.86,105.37 182.95,104.46 182.95,103.85 181.58,102.48 180.31,102.48 176.57,98.74 175.79,98.74 174.29,97.24 173.01,97.24 172.48,96.71 171.17,96.71 170.35,95.89 170.35,94.74 169.48,93.86 169.48,90.76 167.15,88.43 167.15,84.38 165.74,82.98 165.74,81.03 165.39,80.68 164.66,80.68 164.64,80.65 163.87,80.65 163.56,80.34 163.56,79.86 163.49,79.79 v2(163.16,79.79)
  BOTTOM w0.076: UC1.H8 163.44,79.79 v2(163.16,79.79)
SATA_PRX_MSATATX_N3: length 29.7
  TOP w0.102: v2(226.55,133.06) 226.39,132.9 225.92,132.9 R67.1
  IN1 w0.097: v3(235.65,153.96) 235.45,153.76 235.02,153.76 234.68,153.41 234.68,150 227.29,142.61 227.29,133.09 227.02,132.83 226.78,132.83 v2(226.55,133.06)
  BOTTOM w0.102: R2663.1 225.89,132.89 226.38,132.89 v2(226.55,133.06) ; v3(235.65,153.96) 235.46,153.77 235.16,153.77 234.83,154.1 JMINI2.25
SATA_PRX_MSATATX_N3_M: length 63.6
  TOP w0.102: R67.2 224.32,132.92 223.86,132.92 223.63,132.7 223.63,132.47 223.53,132.37 223.2,132.37 v4(223.05,132.52) ; v3(202.99,100.57) 202.99,100.8 202.85,100.94 199.91,100.94 199.61,101.24 190.68,101.24 189.81,100.38 189.81,99.55 189.89,99.48 190.01,99.48 190.1,99.39 U91.15
  IN1 w0.097: v3(202.99,100.57) 203.18,100.76 203.44,100.76 203.86,101.18 203.86,102.57 214.01,112.73 219.19,112.73 224.32,117.86 224.32,121.25 223.18,122.39 223.18,128.8 224.17,129.79 224.17,132.04 223.76,132.45 223.13,132.45 v4(223.05,132.52)
SATA_PRX_MSATATX_P3: length 29.7
  TOP w0.102: v3(226.55,132.43) 226.29,132.69 225.89,132.69 R68.1
  IN1 w0.097: v2(235.65,153.33) 235.43,153.55 235.11,153.55 234.89,153.33 234.89,149.91 227.5,142.52 227.5,133.01 227.11,132.62 226.74,132.62 v3(226.55,132.43)
  BOTTOM w0.102: R2662.1 225.87,132.68 226.23,132.68 226.47,132.43 v3(226.55,132.43) ; JMINI2.23 234.77,153.3 235.03,153.55 235.42,153.55 v2(235.65,153.33)
SATA_PRX_MSATATX_P3_M: length 63.6
  TOP w0.102: v4(202.99,101.43) 202.71,101.15 200,101.15 199.7,101.46 190.59,101.46 189.6,100.47 U91.16 ; v3(223.08,131.89) 223.35,132.16 223.62,132.16 223.85,132.38 223.85,132.61 223.95,132.71 224.32,132.71 R68.2
  IN1 w0.097: v4(202.99,101.43) 202.89,101.33 202.89,101.05 202.97,100.97 203.36,100.97 203.65,101.27 203.65,102.66 213.93,112.94 219.11,112.94 224.11,117.95 224.11,121.16 223.09,122.18 222.97,122.3 222.97,128.88 223.96,129.88 223.96,131.95 223.68,132.24 223.34,132.24 223.22,132.12 223.16,132.12 223.08,132.03 v3(223.08,131.89)
SATA_PTX_DKRX_N0: length 2.4
  TOP w0.102: v2(183.06,185.86) 182.86,185.66 182.86,185.45 C315.1
  BOTTOM w0.102: v2(183.06,185.86) 182.85,185.65 182.85,185.52 182.95,185.42 JDOCK1.62
SATA_PTX_DKRX_N0_C: length 165.2
  TOP w0.102: C315.2 182.92,183.92 182.92,183.58 183.23,183.27 183.23,179.77 183.23,179.77 v3(183.23,178.85) 183.23,177.71 182.4,176.88 182.4,176.86 182.03,176.49 182.01,176.49 180.98,175.46 179.48,175.46 179.33,175.31 179.33,175.02 179.4,174.95 v2(179.4,174.94)
  IN1 w0.097: v2(179.4,174.94) 179.39,174.94 179.39,174.35 178.76,173.71 177.12,173.71 171.37,167.96 171.37,164.56 170.47,163.66 170.47,159.11 169.56,158.2 169.56,156.73 170.22,156.07 170.22,153.68 176.84,147.05 182.04,147.05 182.55,146.55 183.98,146.55 185.72,144.81 185.72,140.14 193.1,132.75 194.94,132.75 195.14,132.96 197.08,132.96 197.21,132.83 200.06,132.83 202.94,129.95 202.94,125.66 203.73,124.87 203.73,122.53 202.53,121.33 202.53,119.1 196.57,113.14 195.94,113.14 195.05,112.25 192.97,112.25 192.04,111.32 192.04,110.64 190.36,108.96 190.36,106.9 189.3,105.84 189.3,99.54 187.61,97.85 186.56,97.85 183.23,94.53 177.69,94.53 177.55,94.39 171.09,94.39 170.73,94.04 165.98,94.04 165.09,94.93 161.42,94.93 160.42,93.93 v3(160.42,92.33)
  BOTTOM w0.076: 159.3,87.58 159.48,87.4 159.48,84.48 159.48,84.48 159.48,84.44 159.31,84.27 159.23,84.27 UC1.B15
  BOTTOM w0.102: 159.3,87.58 159.3,89.27 159.55,89.52 159.55,90.3 160.42,91.16 v3(160.42,92.33)
SATA_PTX_DKRX_P0: length 2.4
  TOP w0.102: C314.1 182.64,185.45 182.64,185.69 v2(182.47,185.86)
  BOTTOM w0.102: JDOCK1.60 182.45,185.32 182.63,185.5 182.63,185.7 v2(182.47,185.86)
SATA_PTX_DKRX_P0_C: length 165
  TOP w0.102: C314.2 182.71,183.8 182.71,183.49 183.01,183.18 183.01,179.86 183.01,179.86 183.01,179.13 182.98,179.11 182.98,178.6 183.01,178.57 183.01,177.8 v3(182.05,176.84) 180.89,175.68 179.39,175.68 179.11,175.4 179.11,175.24 178.81,174.94 v2(178.81,174.94)
  IN1 w0.097: v2(178.81,174.94) 179.12,174.64 179.13,174.64 179.18,174.59 179.18,174.43 178.67,173.93 177.04,173.93 171.16,168.05 171.16,164.64 170.26,163.74 170.26,159.2 169.35,158.29 169.35,156.65 170.01,155.98 170.01,153.59 176.76,146.84 181.96,146.84 182.46,146.34 183.9,146.34 185.51,144.72 185.51,140.05 193.02,132.54 195.03,132.54 195.23,132.75 197,132.75 197.13,132.62 199.97,132.62 202.73,129.86 202.73,125.57 203.52,124.78 203.52,122.62 202.32,121.42 202.32,119.19 196.48,113.35 195.85,113.35 194.96,112.46 192.88,112.46 191.83,111.41 191.83,110.73 190.15,109.05 190.15,106.98 189.09,105.92 189.09,99.63 187.53,98.06 186.47,98.06 183.15,94.74 177.6,94.74 177.47,94.6 171,94.6 170.65,94.25 166.07,94.25 165.18,95.14 161.33,95.14 160.21,94.02 160.21,92.71 159.99,92.49 159.93,92.49 v3(159.77,92.33)
  BOTTOM w0.076: 159.08,87.55 159.08,87.54 159.31,87.31 159.31,84.67 UC1.A15
  BOTTOM w0.102: 159.08,87.55 159.08,89.36 159.34,89.61 159.34,90.39 160.2,91.25 160.2,91.9 v3(159.77,92.33)
SATA_PTX_DRX_N1: length 3.5
  TOP w0.102: C106.1 220.22,135.01 220.98,135.01 v3(221.12,134.87)
  BOTTOM w0.102: v3(221.12,134.87) 220.91,135.08 220.47,135.08 219.86,134.46 JSATA1.3
SATA_PTX_DRX_N1_C: length 96.4
  TOP w0.102: v3(216.88,133.95) 216.83,134 216.83,134.73 217.15,135.05 218.61,135.05 C106.2
  IN1 w0.097: v2(158.51,85.08) 158.43,85.08 158.3,85.2 158.3,85.36 158.53,85.59 158.74,85.59 159.3,86.15 159.3,91.08 159.18,91.21 159.17,91.21 158.78,91.6 158.78,93.95 159.87,95.05 159.87,95.99 v2(160.01,96.13)
  IN3 w0.086: v3(216.88,133.95) 216.81,133.95 216.5,133.64 216.5,133.29 216.29,133.08 213.91,133.08 213.06,132.24 213.06,131.83 209.57,128.33 209.57,119.73 200.54,110.7 200.14,110.7 195.44,106.01 182.12,106.01 177.1,100.99 177.1,100.04 176.32,99.25 175.57,99.25 174.05,97.73 172.56,97.73 172.31,97.47 165.78,97.47 165.21,96.9 159.7,96.9 159.58,96.77 159.58,96.52 159.97,96.13 v2(160.01,96.13)
  BOTTOM w0.076: UC1.A17 158.33,84.44 158.18,84.44 158.09,84.53 158.09,84.66 v2(158.51,85.08)
SATA_PTX_DRX_P1: length 3.5
  TOP w0.102: v4(221.12,135.5) 220.85,135.23 220.29,135.23 C105.1
  BOTTOM w0.102: JSATA1.2 220.13,135.73 220.56,135.29 220.91,135.29 v4(221.12,135.5)
SATA_PTX_DRX_P1_C: length 96.7
  TOP w0.102: C105.2 218.61,135.26 217.06,135.26 216.61,134.82 216.61,134.26 216.32,133.97 v4(216.25,133.97)
  IN1 w0.097: v2(157.93,85.03) 158.09,85.19 158.09,85.44 158.45,85.8 158.65,85.8 159.09,86.23 159.09,90.99 159.08,90.99 158.57,91.51 158.57,94.04 159.66,95.13 159.66,95.87 v2(159.4,96.13)
  IN3 w0.086: v2(159.4,96.13) 159.4,96.84 159.63,97.07 165.14,97.07 165.71,97.65 172.23,97.65 172.49,97.9 173.98,97.9 175.5,99.42 176.24,99.42 176.93,100.11 176.93,101.06 182.05,106.18 195.37,106.18 200.07,110.88 200.47,110.88 209.39,119.8 209.39,128.41 212.88,131.9 212.88,132.31 213.83,133.26 216.22,133.26 216.32,133.36 216.32,133.9 v4(216.25,133.97)
  BOTTOM w0.076: v2(157.93,85.03) 157.93,84.08 UC1.B17
SATA_PTX_MSATARX_N3: length 28.9
  TOP w0.102: v3(225.43,134.33) 225.26,134.5 225.03,134.5 R62.1 ; C280.1 232.52,156.84 232.38,156.98 232.17,156.98 232.07,156.88 232.07,155.33 231.7,154.96 231.7,154.45 v2(231.95,154.2)
  IN1 w0.097: v3(225.43,134.33) 225.68,134.58 226.05,134.58 226.36,134.89 226.36,142.39 232.36,148.39 232.36,153.13 231.77,153.73 231.77,154.02 v2(231.95,154.2)
  BOTTOM w0.102: v3(225.43,134.33) 225.26,134.5 225.03,134.5 R62.1
SATA_PTX_MSATARX_N3_C: length 4.2
  TOP w0.102: v3(235.58,156.65) 235.31,156.92 234.65,156.92 234.46,157.11 233.82,157.11 C280.2
  BOTTOM w0.102: JMINI2.31 234.69,156.5 235.04,156.86 235.37,156.86 v3(235.58,156.65)
SATA_PTX_MSATARX_N3_M: length 71.1
  TOP w0.102: U91.17 189.1,99.27 188.81,99.55 188.81,101.28 189.98,102.45 203.76,102.45 205.26,100.95 205.26,100.76 204.87,100.37 v4(204.84,100.37) ; R62.2 223.23,134.63 223.23,134.76 223.09,134.9 222.67,134.9 v3(222.43,134.66)
  IN1 w0.097: v3(222.43,134.66) 222.43,134.73 222.76,135.06 222.96,135.06 224.73,133.29 224.73,129.67 223.76,128.7 223.76,122.83 224.9,121.68 224.9,117.76 217.42,110.28 216.08,110.28 212.19,106.39 208.35,106.39 205.55,103.59 205.55,102.91 205.27,102.62 205.27,100.74 204.89,100.37 v4(204.84,100.37)
SATA_PTX_MSATARX_P3: length 28.9
  TOP w0.102: v2(231.31,154.2) 231.49,154.38 231.49,155.05 231.85,155.42 231.85,156.97 232.08,157.2 232.18,157.2 232.52,157.54 C256.1 ; R61.1 224.93,134.73 225.2,134.73 v3(225.43,134.97)
  IN1 w0.097: v2(231.31,154.2) 231.55,153.96 231.55,153.64 232.15,153.05 232.15,148.47 226.14,142.47 226.14,134.97 225.96,134.79 225.61,134.79 v3(225.43,134.97)
  BOTTOM w0.102: v3(225.43,134.97) 225.19,134.72 224.95,134.72 R61.1
SATA_PTX_MSATARX_P3_C: length 4.2
  TOP w0.102: v2(235.6,157.39) 235.35,157.14 234.74,157.14 234.55,157.33 233.73,157.33 C256.2
  BOTTOM w0.102: JMINI2.33 234.8,157.3 235.03,157.07 235.28,157.07 v2(235.6,157.39)
SATA_PTX_MSATARX_P3_M: length 71.1
  TOP w0.102: v4(222.43,135.3) 222.62,135.11 223.64,135.11 R61.2 ; U91.18 188.6,101.37 189.89,102.67 203.85,102.67 205.48,101.04 v3(205.48,100.37)
  IN1 w0.097: v4(222.43,135.3) 222.47,135.27 223.05,135.27 224.94,133.37 224.94,129.58 223.97,128.61 223.97,122.91 225.11,121.77 225.11,117.67 217.51,110.07 216.17,110.07 212.28,106.18 208.43,106.18 205.76,103.51 205.76,102.82 205.48,102.53 v3(205.48,100.37)
SC48M_CLK_EN: length 252.7
  TOP w0.102: JEXP1.39 87.5,23.73 87.37,23.86 v1(87.13,23.86) v3(86.4,23.86)
  IN3 w0.076: 171.03,60.93 170.28,60.93 168.01,63.2 168.01,66.07 167.69,66.38 167.69,74.91 v2(167.14,75.46)
  IN3 w0.102: 171.03,60.93 171.81,60.93 174.56,58.18 176.24,58.18 176.38,58.32 177.64,59.57 179.52,59.57 180.99,61.05 182.95,61.05 183.48,60.51 184.55,60.51 185.51,59.55 187.31,59.55 189.49,61.73 193.01,61.73 196.78,57.97 202.92,57.97 207.63,53.26 207.63,51.03 214.96,43.69 214.96,43.28 217.34,40.91 217.34,39.89 225.95,31.28 225.95,29.96 226.33,29.58 226.33,28.94 226.58,28.69 226.58,24.04 225.9,23.35 225.9,22.6 225.19,21.89 225.19,19.35 223.43,17.59 222.8,17.59 222.14,16.93 222.14,16.72 220.87,15.45 203.3,15.45 201.09,13.25 171.79,13.25 171.78,13.25 170.65,13.25 170.64,13.25 148.52,13.25 147.79,13.98 124.45,13.98 124.12,13.65 116.83,13.65 114.72,15.76 95.9,15.76 94.83,16.84 94.83,16.92 93.35,18.4 93.01,18.4 92.01,19.39 89.39,19.39 88.1,20.68 88.1,22.16 v3(86.4,23.86)
  BOTTOM w0.076: v2(167.14,75.46) 166.84,75.76 UC1.T3
SD/MMCCD#: length 47
  IN1 w0.097: v3(31.6,54.9) 31.06,54.36 26.58,54.36 24.8,52.58 24.8,52.45 25.49,51.76 25.49,51.62 25.28,51.42 25.15,51.42 24.46,52.11 24.32,52.11 24.12,51.9 24.12,51.76 24.34,51.54 24.34,51.39 24.15,51.2 24,51.2 23.78,51.42 23.64,51.42 21.61,49.39 21.61,31.13 21.25,30.77 21.25,29.63 21.24,29.63 19.13,27.51 v2(18.85,27.51)
  BOTTOM w0.102: v2(18.85,27.51) 18.94,27.6 U27.21 ; v6(33.04,58.51) 32.4,57.87 C273.1 31.6,56.3 v3(31.6,54.9) 31.94,54.9 R53.1 32.03,54.08 31.54,54.08 31.06,53.6 JSD1.18
SD/MMCCLK: length 39.9
  IN1 w0.097: v2(30.2,26.12) 30.47,26.39 30.47,30.12 30.81,30.47 30.81,31.18 30.7,31.29 30.7,35.63 28.64,37.68 28.64,44.84 28.74,44.94 29.22,44.94 29.33,45.05 29.33,45.31 29.22,45.42 28.74,45.42 28.64,45.52 28.64,45.81 28.74,45.91 30.56,45.91 30.65,46 30.65,46.29 30.56,46.39 28.74,46.39 28.64,46.49 28.64,46.78 28.74,46.87 30.56,46.87 30.65,46.97 30.65,48.17 28.99,49.82 v2(28.99,52.97)
  BOTTOM w0.102: JSD1.5 29.77,52.2 v2(28.99,52.97) ; R230.2 28.88,25.6 v1(29.68,25.6) v2(30.2,26.12) 30.36,26.28 C255.1
SD/MMCCLK_R: length 1.9
  BOTTOM w0.102: U27.43 26.36,26.4 26.55,26.21 v2(26.84,26.21) 27.36,26.21 R230.1
SD/MMCCMD: length 42.1
  IN1 w0.097: v2(26.8,25.51) 25.49,26.81 25.49,34.29 22.94,36.84 22.94,47.2 23.05,47.31 23.68,47.31 23.79,47.42 23.79,48.65 23.9,48.75 24.16,48.75 24.27,48.65 24.27,47.36 24.37,47.26 24.66,47.26 24.75,47.36 24.75,48.72 24.86,48.83 25.13,48.83 25.24,48.72 25.24,47.36 25.33,47.26 25.62,47.26 25.72,47.36 25.72,48.7 25.83,48.81 26.09,48.81 26.2,48.7 26.2,47.36 26.3,47.26 26.59,47.26 26.68,47.36 26.68,48.15 26.78,48.25 27.07,48.25 27.17,48.15 27.17,47.36 27.26,47.26 v2(28.36,47.26)
  BOTTOM w0.102: v2(28.36,47.26) 29.13,46.5 JSD1.2 ; U27.45 26.7,25.6 v2(26.8,25.51)
SD/MMCDAT2: length 2
  BOTTOM w0.102: R341.1 27.27,24.2 26.58,24.2 26.39,24.4 U27.48
SD/MMCDAT2_R: length 40.3
  IN1 w0.097: v2(29.28,23.94) 27.81,25.41 27.81,33.23 25.31,35.72 25.31,36.49 23.61,38.19 23.61,42.89 23.71,42.99 24.8,42.99 24.91,43.1 24.91,43.36 24.8,43.47 23.71,43.47 23.61,43.57 23.61,43.86 23.71,43.96 25.22,43.96 25.31,44.05 25.31,44.34 25.22,44.44 23.71,44.44 23.61,44.54 23.61,44.82 23.71,44.92 25.22,44.92 25.31,45.02 25.31,45.31 25.22,45.4 24.66,45.4 24.55,45.51 24.55,45.78 24.66,45.89 26.12,45.89 26.23,45.78 v2(26.23,44.31)
  BOTTOM w0.102: v2(29.28,23.94) 29.2,23.86 R341.2 ; v2(26.23,44.31) 26.84,43.7 JSD1.9
SD/MMCDAT3: length 1.9
  BOTTOM w0.102: U27.47 26.49,24.8 26.73,24.56 27.42,24.56 R410.1
SD/MMCDAT3_R: length 40.5
  IN1 w0.097: v2(27.19,45.81) 27.19,43.58 27.1,43.48 26.05,43.48 25.95,43.39 25.95,43.1 26.05,43 27.1,43 27.19,42.9 27.19,42.61 27.1,42.52 24.43,42.52 24.32,42.41 24.32,42.14 24.43,42.03 27.1,42.03 27.19,41.94 27.19,41.65 27.1,41.55 24.51,41.55 24.4,41.44 24.4,41.18 24.51,41.07 25.87,41.07 25.97,40.96 25.97,40.7 25.87,40.59 24.53,40.59 24.43,40.48 24.43,38.86 27.37,35.91 27.37,35.59 27.83,35.14 27.83,34.57 28.21,34.19 28.21,25.81 v2(29.27,24.75)
  BOTTOM w0.102: v2(27.19,45.81) 27.91,45.1 JSD1.1 ; R410.2 v2(29.27,24.75)
SD_RCLK+: length 23.6
  TOP w0.089: v2(22.75,30.85) 22.55,30.65 22.55,30.33 22.67,30.21 25.57,30.21 28,32.64 30.37,32.64 31.03,31.98 31.03,31.63 31.16,31.51 v2(31.44,31.51)
  IN3 w0.089: v2(26.88,28.31) 26.88,28.37 26.69,28.56 25.72,28.56 24.81,29.48 24.81,30.76 23.97,31.6 23.96,31.6 23.75,31.81 22.58,31.81 22.29,31.52 22.29,31 22.5,30.8 22.7,30.8 v2(22.75,30.85)
  BOTTOM w0.089: v2(26.88,28.31) 26.78,28.4 U27.38 ; R231.1 31.26,32.91 L46.4 31.26,32.37 30.99,32.1 30.99,31.77 31.25,31.51 v2(31.44,31.51) ; U27.30 22.59,30.69 v2(22.75,30.85)
SD_RCLK+_D: length 30.8
  BOTTOM w0.089: R231.2 31.26,34.11 L46.3 31.26,34.89 31.13,35.01 30.98,35.01 30.85,35.14 30.85,37.04 25.37,42.53 25.37,52.46 25.45,52.55 25.78,52.55 26.14,52.91 26.14,53.51 25.78,53.87 25.45,53.87 25.37,53.96 25.37,54.71 27.97,57.32 28.85,57.32 29.12,57.04 29.12,56.86 29.59,56.4 JSD1.7
SD_RCLK-: length 23.6
  TOP w0.089: v2(21.96,30.82) 22.16,30.63 22.16,30.17 22.51,29.82 25.73,29.82 28.16,32.25 30.2,32.25 30.64,31.81 30.64,31.72 30.45,31.54 v2(30.14,31.54)
  IN3 w0.089: v2(21.96,30.82) 21.96,31.66 22.44,32.14 23.89,32.14 24.1,31.93 24.11,31.93 25.14,30.9 25.14,29.61 25.86,28.89 v2(26.88,28.89)
  BOTTOM w0.089: v2(21.96,30.82) 22.19,30.59 U27.29 ; R297.1 30.41,32.91 L46.1 30.41,32.37 30.6,32.18 30.6,31.79 30.35,31.54 v2(30.14,31.54) ; U27.37 26.78,28.8 v2(26.88,28.89)
SD_RCLK-_D: length 30.8
  BOTTOM w0.089: R297.2 30.41,34.11 L46.2 30.41,34.86 30.46,34.91 30.46,36.88 24.97,42.37 24.97,52.62 25.29,52.94 25.62,52.94 25.75,53.07 25.75,53.35 25.62,53.48 25.29,53.48 24.97,53.79 24.97,54.87 27.81,57.71 29.14,57.71 29.23,57.8 JSD1.8
SD_UHS2_D0N: length 6.9
  BOTTOM w0.089: R315.1 28.19,32.84 L47.1 28.19,32.39 28.41,32.16 28.41,32.04 v1(27.98,31.6) 27.41,31.04 24.77,31.04 24.2,30.47 24.2,29.66 U27.34
SD_UHS2_D0N_D: length 42.7
  IN3 w0.089: v2(28.32,36.04) 28.45,35.91 28.45,35.41 27.54,34.5 25.2,34.5 19.99,39.71 16.67,39.71 16.58,39.8 16.58,40.05 16.23,40.4 15.74,40.4 15.39,40.05 15.39,39.8 15.3,39.71 14.94,39.71 14.85,39.8 14.85,40.75 14.57,41.03 13.94,41.03 13.66,40.75 13.66,39.8 13.57,39.71 13.21,39.71 13.13,39.8 13.13,40.75 12.84,41.03 12.21,41.03 11.93,40.75 11.93,39.8 11.84,39.71 11.49,39.71 11.4,39.8 11.4,40.75 11.12,41.03 10.49,41.03 10.2,40.75 10.2,39.8 10.12,39.71 9.76,39.71 9.67,39.8 9.67,40.53 9.37,40.83 8.78,40.83 8.48,40.53 8.48,39.8 8.39,39.71 8.03,39.71 7.94,39.8 7.94,40.05 7.59,40.4 7.1,40.4 6.75,40.05 6.75,39.8 6.66,39.71 5.95,39.71 5.38,39.14 5.38,38.8 v2(4.92,38.34)
  BOTTOM w0.089: JSD1.12 5.05,35.9 5.05,36.52 5.41,36.89 5.41,37.85 v2(4.92,38.34) ; R315.2 28.19,34.18 L47.2 28.19,34.95 28.41,35.18 28.41,35.94 v2(28.32,36.04)
SD_UHS2_D0P: length 6.9
  BOTTOM w0.089: U27.35 24.59,30.3 24.93,30.64 v1(27.13,30.64) 27.57,30.64 28.81,31.88 28.81,32.16 29.04,32.39 L47.4 29.04,32.84 R306.1
SD_UHS2_D0P_D: length 42.7
  IN3 w0.089: v2(6.21,38.34) 6.14,38.34 5.71,38.77 5.71,39 6.09,39.38 6.8,39.38 7.08,39.66 7.08,39.91 7.24,40.07 7.46,40.07 7.61,39.91 7.61,39.66 7.9,39.38 8.53,39.38 8.81,39.66 8.81,40.39 8.92,40.5 9.23,40.5 9.34,40.39 9.34,39.66 9.62,39.38 10.25,39.38 10.53,39.66 10.53,40.61 10.62,40.7 10.98,40.7 11.07,40.61 11.07,39.66 11.35,39.38 11.98,39.38 12.26,39.66 12.26,40.61 12.35,40.7 12.71,40.7 12.79,40.61 12.79,39.66 13.08,39.38 13.71,39.38 13.99,39.66 13.99,40.61 14.08,40.7 14.43,40.7 14.52,40.61 14.52,39.66 14.8,39.38 15.43,39.38 15.72,39.66 15.72,39.91 15.87,40.07 16.09,40.07 16.25,39.91 16.25,39.66 16.53,39.38 19.85,39.38 25.06,34.17 27.68,34.17 28.78,35.27 28.78,35.91 v2(28.9,36.04)
  BOTTOM w0.089: v2(28.9,36.04) 28.81,35.94 28.81,35.18 29.04,34.95 L47.3 29.04,34.18 R306.2 ; JSD1.11 6.15,36.52 5.8,36.87 5.8,37.93 v2(6.21,38.34)
