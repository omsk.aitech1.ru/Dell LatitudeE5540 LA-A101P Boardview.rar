# Allegro board Alpine15_LA-A101PR10-0826C.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
1.5VRUN_VIN on BOTTOM (solid shape): 233.45,89.83 233.45,88.27 233.12,87.93 233.12,84.42 233.11,84.42 233.11,83.66 232.7,83.24 232.7,81.97 231.86,81.14 231.06,81.14 231.06,81.67 230.54,81.67 230.54,81.14 230.29,81.14 230.29,81.67 229.74,81.67 229.74,81.14 229.39,81.14 229.39,82.16 229.4,82.16 229.4,83.15 229.94,83.69 230.41,83.69 231.49,84.77 231.49,87.52 232.41,88.44 232.41,89.9 232.49,89.98 233.29,89.98
1.35V_B+ on BOTTOM (solid shape): 44.52,21.88 50.18,21.88 50.97,21.09 50.97,17.51 50.28,16.83 47.82,16.83 47.59,17.06 47.59,17.61 46.75,18.45 43.2,18.45 42.42,19.23 42.42,20.14 42.89,20.14 42.89,20.59 42.42,20.59 42.42,20.94 42.89,20.94 42.89,21.39 42.42,21.39 42.42,22.37 42.56,22.52 43.88,22.52
+0.9V_LAN on TOP (solid shape): 200.03,142.66 200.03,140.86 199.96,140.79 197.42,140.79 197.17,141.04 197.17,141.55 197.55,141.93 198.05,141.93 198.34,142.21 198.34,142.6 198.5,142.76 199.94,142.76
+0.9V_LAN on TOP (solid shape): 196.66,147.77 196.66,147.2 196.59,147.14 194.94,147.14 193.99,146.18 193.99,146.06 193.93,145.99 193.1,145.99 192.97,146.12 192.97,147.45 193.04,147.52 194.5,147.52 194.63,147.65 195.45,147.65 195.64,147.84 196.59,147.84
+0.9V_LAN on BOTTOM (solid shape): outline of 734 points within 193.87,143.9 205.15,153.63
+0.675V_DDR_VTT on TOP (solid shape): 226.79,26.62 226.79,23.53 226.58,23.33 226.58,21.63 227.41,20.8 227.41,18.77 227.27,18.63 224.63,18.63 224.55,18.71 224.55,26.33 224.97,26.75 226.66,26.75
+0.675V_DDR_VTT on TOP (solid shape): outline of 164 points within 150.15,17.97 154.53,27.23
+0.675V_DDR_VTT on BOTTOM (solid shape): 47.19,12.68 47.19,10.61 47.06,10.48 46.42,10.48 46.3,10.61 46.3,12.66 46.45,12.81 47.06,12.81
+0.675V_DDR_VTT on IN2 (solid shape): 226.41,19.81 226.41,18.09 225.52,17.2 223.71,17.2 223.48,17.43 223.48,19.13 224.35,20 226.22,20
+0.675V_DDR_VTT on IN2 (solid shape): 71.63,30.91 71.63,25.81 71.39,25.56 70.32,25.56 70.03,25.86 70.03,30.78 70.42,31.18 71.36,31.18
+0.675V_DDR_VTT on IN2 (solid shape): outline of 301 points within 147.78,17.97 154.5,24.45
+0.675V_DDR_VTT on IN3 (solid shape): 47.39,12.48 47.39,9.94 46.04,9.94 45.79,10.2 45.79,12.61 45.99,12.81 47.06,12.81
+0.675V_DDR_VTT on IN3 (solid shape): 71.89,27.62 71.89,24.26 71.44,23.81 70.48,23.81 70.08,24.21 70.08,27.68 70.25,27.85 71.66,27.85
+0.675V_P on BOTTOM (solid shape): 40.86,12.61 43.22,12.61 43.63,12.2 45.91,12.2 46.09,12.03 46.09,11.62 45.56,11.62 45.56,11.11 46.12,11.11 46.12,10.88 45.99,10.76 44.59,10.76 44.26,11.09 43.2,11.09 43.07,11.21 40.48,11.21 40.33,11.37 40.33,11.54 40.4,11.62 40.4,11.64 40.07,11.97 40.08,12 40.04,12.29 39.79,12.45 39.37,12.88 39.37,13.01 39.43,13.07 40.39,13.07
+1.2V_LDO on BOTTOM (solid shape): 31.45,21.44 31.45,20.67 31.19,20.42 29.8,20.42 29.54,20.67 29.54,21.55 29.62,21.63 29.73,21.63 29.92,21.82 31.07,21.82
+1.2V_LDO on IN2 (solid shape): outline of 431 points within 19.68,18.78 31.05,28.24
+1.2V_LDO_AIN on BOTTOM (solid shape): 25.41,23.89 26.83,23.89 27.44,23.28 29.61,23.28 30.12,23.78 30.46,23.78 30.7,23.55 30.7,22.59 30.24,22.14 29.73,22.14 29.48,21.88 26.94,21.88 26.56,22.26 26.56,22.79 26.27,23.07 24.95,23.07 24.88,23.15 24.88,23.93 24.96,24.01 25.29,24.01
+1.2V_LDO_AIN on IN2 (solid shape): 29.1,31.91 29.1,30.39 28.97,30.26 27.19,30.26 26.31,29.37 26.31,25.49 27.7,24.09 27.7,22.52 27.07,21.88 26.56,21.88 26.18,22.26 26.18,22.38 26.18,22.38 26.39,22.81 25.99,23.09 25.04,24.04 25.04,31.11 23.74,32.41 23.74,32.69 24.23,33.18 27.83,33.18
+1.5V_GPU on TOP (solid shape): 28.78,86.25 28.78,84.02 28.71,83.96 27.31,83.96 27.25,84.02 27.25,86.18 27.38,86.31 28.71,86.31
+1.5V_GPU on TOP (solid shape): 30.32,114.79 30.32,112.91 30.27,112.86 28.95,112.86 28.87,112.94 28.87,114.31 29.1,114.54 29.1,114.9 29.2,115 30.12,115
+1.5V_GPU on TOP (solid shape): 40.21,117 40.21,112.85 39.95,112.6 38.36,112.6 38.11,112.85 38.11,115.27 37.92,115.46 35.22,115.46 35.22,115.5 34.89,115.84 34.39,115.84 34.16,115.61 31.79,115.61 31.59,115.81 31.59,117.6 31.64,117.65 36.9,117.65 36.94,117.68 39.52,117.68
+1.5V_GPU on TOP (solid shape): outline of 179 points within 28.34,97.73 30.79,101.68
+1.05V_GPU on TOP (solid shape): outline of 655 points within 45.99,79.45 62.47,95.57
+1.5V_GPU on TOP (solid shape): outline of 1739 points within 35.37,93.46 57.78,110.75
+1.5V_GPU on BOTTOM (solid shape): 28.78,86.31 28.78,84.09 28.65,83.96 27.38,83.96 27.19,84.15 27.19,86.31 27.31,86.44 28.65,86.44
+1.5V_GPU on BOTTOM (solid shape): 29.66,114.95 29.66,112.98 29.47,112.79 28.14,112.79 27.95,112.98 27.95,114.38 28.14,114.57 28.14,114.89 28.33,115.08 29.54,115.08
+1.5V_GPU on BOTTOM (solid shape): 52.49,116.83 52.49,116.12 52.24,115.86 42.46,115.86 41.7,115.1 40.12,115.1 39.23,115.99 39.23,116.67 39.69,117.13 52.19,117.13
+1.05V_GPU on BOTTOM (solid shape): 94.1,76.54 94.1,75.51 93.71,75.12 91.22,75.12 91.14,75.2 91.14,75.71 90.13,76.73 90.13,77.38 90.19,77.44 93.2,77.44
+1.5V_GPU on BOTTOM (solid shape): 42.97,62.9 42.97,60.87 42.7,60.6 42.07,60.6 42.07,61.14 41.54,61.14 41.53,61.13 41.53,60.6 41.27,60.6 41.27,61.14 40.74,61.14 40.73,60.6 38.14,60.6 38.14,61.14 38.13,61.15 37.61,61.15 37.59,61.13 37.59,60.6 37.34,60.6 37.34,61.14 37.32,61.15 36.8,61.15 36.79,61.14 36.79,60.6 36.39,60.6 36.38,60.59 35.98,60.59 35.55,61.03 35.55,63 35.78,63.23 42.64,63.23
+1.5V_GPU on BOTTOM (solid shape): outline of 426 points within 53.38,95.44 61.45,106.75
+1.05V_GPU on BOTTOM (solid shape): outline of 552 points within 47.26,81.44 63.82,95.45
+1.05V_GPU on IN1 (solid shape): outline of 2417 points within 47.77,84.47 71.21,100.54
+1.05V_GPU on IN2 (solid shape): outline of 465 points within 56.63,87.59 62.65,95.29
+1.05V_GPU on IN2 (solid shape): outline of 785 points within 50.74,70.73 95.39,83.37
+1.5V_GPU on IN2 (solid shape): outline of 13268 points within 23.65,83.96 63,114.31
+1.05V_GPU on IN3 (solid shape): 51.32,91.33 51.32,87.44 49.95,86.07 49.95,84.72 49.72,84.49 48.28,84.49 48,84.77 48,88.6 50.01,88.6 50.01,88.55 50.02,88.5 50.04,88.45 50.06,88.4 50.09,88.36 50.12,88.33 50.16,88.3 50.21,88.28 50.26,88.26 50.3,88.25 50.35,88.25 50.4,88.26 50.45,88.28 50.5,88.3 50.54,88.33 50.57,88.36 50.6,88.4 50.62,88.45 50.64,88.5 50.65,88.55 50.65,88.6 50.64,88.64 50.62,88.69 50.6,88.74 50.57,88.78 50.54,88.81 50.5,88.84 50.45,88.86 50.4,88.88 50.35,88.89 50.3,88.89 50.26,88.88 50.21,88.86 50.16,88.84 50.12,88.81 50.09,88.78 50.06,88.74 50.04,88.69 50.02,88.64 50.01,88.6 48,88.6 48,88.71 50.71,91.43 51.22,91.43
+1.5V_GPU on VCC: 29.2,60.44 19.02,70.63 19.02,117.36 19.35,117.69 62.22,117.69 62.63,117.28 62.63,105.17 56.88,105.17 55.26,103.55 55.26,88.66 54.39,87.79 47.76,87.79 44.9,84.93 44.9,60.44 ; 3 cut-outs
+1.05V_M on TOP (solid shape): 165.72,107.04 165.72,106.5 165.84,106.37 165.84,105.19 165.79,105.14 165.28,105.14 164.82,105.6 163.41,105.6 163.03,105.22 163.03,103.47 162.81,103.24 161.72,103.24 161.54,103.42 161.54,106.99 161.72,107.17 165.59,107.17
+1.05V_M on TOP (solid shape): 170.98,102.27 170.98,101.56 171.26,101.28 172.36,101.28 172.58,101.05 172.58,100.52 172.54,100.48 172.43,100.27 172.48,100.03 172.47,99.93 172.39,99.88 170.22,99.88 169.86,100.24 169.83,100.33 169.88,100.4 170.05,100.77 169.8,101.09 169.76,101.1 169.76,102.27 169.99,102.5 170.75,102.5
+1.05V_M on TOP (solid shape): 156.31,110.79 156.31,109.65 156.4,109.56 157.25,109.56 157.53,109.28 157.53,107.06 157.31,106.83 154.7,106.83 154.55,106.98 154.55,107.7 155.46,107.7 155.46,107.65 155.47,107.6 155.48,107.55 155.5,107.5 155.53,107.45 155.57,107.41 155.61,107.38 155.66,107.35 155.71,107.33 155.76,107.32 155.81,107.32 155.87,107.32 155.92,107.33 155.97,107.35 156.01,107.38 156.06,107.41 156.09,107.45 156.12,107.5 156.15,107.55 156.16,107.6 156.17,107.65 156.17,107.7 156.16,107.76 156.15,107.81 156.12,107.85 156.09,107.9 156.06,107.94 156.01,107.97 155.97,108 155.92,108.02 155.87,108.03 155.81,108.03 155.76,108.03 155.71,108.02 155.66,108 155.61,107.97 155.57,107.94 155.53,107.9 155.5,107.85 155.48,107.81 155.47,107.76 155.46,107.7 154.55,107.7 154.55,110.84 154.61,110.91 156.2,110.91
+1.05V_M on BOTTOM (solid shape): 103.5,72.43 103.5,68.16 102.71,67.37 102.71,64.35 102.4,64.05 96.71,64.05 95.33,65.43 94.79,65.43 94.64,65.58 94.64,66.61 95.16,66.61 95.16,66.64 95.16,67.34 95.16,67.36 94.64,67.36 94.64,67.81 95.16,67.81 95.16,67.84 95.16,68.54 95.16,68.56 94.64,68.56 94.64,70.55 95,70.92 95.99,70.92 96.01,70.88 96.36,70.65 96.71,70.88 96.72,70.92 100.94,70.92 101.39,71.37 101.42,71.36 101.73,71.47 101.84,71.79 101.84,71.81 102.12,72.1 102.12,72.58 102.25,72.71 103.22,72.71
+1.05V_M on BOTTOM (solid shape): outline of 142 points within 159.2,69.22 161.55,72.86
+1.05V_M on IN2 (solid shape): outline of 200 points within 163.16,99.68 172.91,107.78
+1.05V_M on IN2 (solid shape): outline of 529 points within 154.26,68.19 162.26,73.04
+1.05V_M on VCC: 207.28,46.4 198.85,54.82 191.27,54.82 190.51,54.06 178.28,54.06 176.4,55.94 168.37,55.94 162.12,62.19 161.23,62.19 160.09,63.34 160.09,65.82 160.52,66.25 160.52,76.03 160.78,76.29 172.36,76.29 173.17,77.1 173.67,77.1 174.67,76.11 174.67,71.49 173.17,69.99 173.17,66.91 179.36,60.72 185.77,60.72 186.5,61.45 186.5,67.39 187.09,67.98 195.02,67.98 200.37,73.34 200.37,90.62 190.34,100.65 178.73,100.65 178.15,100.07 178.15,99.81 178.04,99.71 168.57,99.71 166.97,101.31 166.97,103.47 165.78,104.66 157.82,104.66 155.1,101.94 109.54,101.94 107.66,100.06 103.03,100.06 93.21,90.24 93.21,79.66 102.12,70.75 102.12,68.42 94.14,60.44 72.41,60.44 72.41,82.99 75.07,85.66 75.07,98.1 75.69,98.72 80.74,98.72 92.68,110.65 104.34,110.65 106.17,112.48 116.22,112.48 116.86,113.12 152.9,113.12 155.31,115.53 155.31,115.45 171.06,115.45 172.74,113.77 172.74,113.09 173.14,112.69 173.98,112.69 174.42,113.12 188.76,113.12 193.89,107.99 199.86,107.99 201.68,106.17 210.1,106.17 210.1,67.86 207.28,65.04 ; 4 cut-outs
+1.05V_MODPHY on TOP (solid shape): 159.17,105.02 160.93,105.02 161.13,104.81 161.13,103.37 160.46,102.7 160.46,101.43 160.29,101.26 158.89,101.26 158.56,101.59 157.7,101.59 157.52,101.76 157.52,105.6 157.72,105.8 158.39,105.8
+1.05V_MODPHY on TOP (solid shape): 154.41,110.08 154.41,108.18 154.38,108.15 153.46,108.15 153.04,107.73 153.04,107.23 152.99,107.17 152.37,107.17 152.33,107.21 152.33,107.83 152.84,108.34 152.84,110.08 152.97,110.22 154.27,110.22
+1.05V_MODPHY_PCH on TOP (solid shape): 163.36,101.94 163.9,101.94 164.1,101.74 164.1,100.95 164.02,100.88 161.46,100.88 161.15,101.18 161.15,102.81 161.31,102.96 162.35,102.96
+1.05V_MODPHY_PCH on TOP (solid shape): outline of 1139 points within 160.71,76.86 170.93,87.46
+1.05V_MODPHY_PCH on IN2 (solid shape): outline of 653 points within 160.65,85.25 169.87,103.06
+1.05V_MP on TOP (solid shape): outline of 453 points within 90.74,67.86 96.74,80.66
+1.05V_MP on BOTTOM (solid shape): 94.48,71.56 94.48,68.46 94.51,68.44 95.03,68.44 95.03,67.94 94.51,67.94 94.51,67.24 95.03,67.24 95.03,66.74 94.51,66.74 94.51,65.42 94.18,65.09 88.86,65.09 88.41,65.54 88.41,70.78 88.92,71.28 88.92,72.1 88.99,72.17 93.87,72.17
+1.05V_MP on BOTTOM (solid shape): 96.1,80.94 96.1,77.91 95.98,77.79 95.77,77.79 95.74,77.76 93.89,77.76 93.79,77.86 93.79,78.31 94.28,78.79 94.71,78.79 94.74,78.82 94.74,79.39 94.73,79.4 94.2,79.4 94.19,79.4 94.19,79.63 94.73,79.63 94.74,79.64 94.74,80.2 94.19,80.2 94.19,80.2 94.19,80.44 94.73,80.44 94.74,80.45 94.74,80.99 94.81,81.06 95.98,81.06
+1.05V_RUN on TOP (solid shape): 156.39,99.97 156.39,98.75 156.28,98.64 155.46,98.64 155.46,99.22 154.96,99.22 154.96,98.64 154.7,98.64 154.7,100.01 154.83,100.14 156.23,100.14
+1.05V_RUN on TOP (solid shape): 155.73,76.33 156.11,76.33 156.43,76.01 156.43,75.78 156.28,75.63 154.7,75.63 154.52,75.45 152.37,75.45 151.98,75.83 151.98,76.29 152.29,76.59 155.46,76.59
+1.05V_RUN on TOP (solid shape): 165.07,103.87 165.78,103.87 165.85,103.79 165.85,102.65 165.55,102.35 164.23,102.35 164.02,102.15 163.41,102.15 162.93,102.63 162.93,103.11 163.16,103.34 163.16,103.75 163.69,104.28 164.66,104.28
+1.05V_RUN on TOP (solid shape): 158.75,72.85 158.75,72.14 158.48,71.87 158.48,70.66 159.05,70.08 159.05,69.21 158.84,69.01 158.7,69.01 158.56,69.15 158.56,69.66 157.93,70.29 157.93,70.66 157.9,70.7 157.9,70.84 157.86,70.97 157.86,71.56 157.78,71.63 157.78,72.85 157.82,72.89 158.71,72.89
+1.5V_RUN on TOP (solid shape): 185.42,100.76 185.42,100.75 185.32,100.64 185.32,99.68 185.17,99.53 185.17,98.79 185.17,98.61 185.34,98.43 185.34,98.4 185.36,98.31 185.4,98.24 185.41,98.13 185.32,98.07 184.73,98.07 184.51,97.94 184.51,97.68 184.52,97.67 184.52,97.57 184.65,97.44 185.58,97.44 185.65,97.37 185.65,97.25 185.58,97.18 184.64,97.18 184.48,97.02 184.48,96.58 184.61,96.45 185.57,96.45 185.65,96.36 185.65,96.24 185.58,96.18 185.36,96.18 184.93,95.74 184.93,94.78 184.8,94.65 184.8,93.97 184.75,93.92 184.55,93.92 184.28,93.65 183.9,93.65 183.79,93.76 183.79,99.78 183.79,99.78 183.79,100.03 184.71,100.95 185.23,100.95
+1.5V_RUN on TOP (solid shape): 194.17,99.07 194.17,97.75 193.11,96.68 193.11,95.64 191.53,94.07 189.8,94.07 189.47,94.4 189.47,95.8 189.54,95.86 189.66,95.86 189.73,95.79 189.73,94.75 189.83,94.65 190.29,94.65 190.39,94.75 190.39,96.05 190.26,96.18 190.13,96.18 190.05,96.25 190.05,96.39 190.14,96.48 191.4,96.48 191.49,96.56 191.57,96.56 191.66,96.66 191.68,96.66 191.97,97.19 191.37,97.22 191.09,97.22 191.06,97.19 190.11,97.19 190.05,97.25 190.05,97.38 190.11,97.45 191.22,97.45 191.34,97.56 191.36,97.55 191.61,97.6 191.77,97.8 191.84,98.03 191.74,98.25 191.7,98.34 191.6,98.44 191.6,99.64 191.66,99.71 191.69,99.8 191.7,99.83 193.41,99.83
+1.05V_RUN on TOP (solid shape): outline of 105 points within 157.29,78.08 161.58,80.56
+1.5V_RUN on TOP (solid shape): outline of 1393 points within 95.37,12.03 109.16,26.78
+1.5V_RUN on BOTTOM (solid shape): 221.22,80.91 221.22,80.33 220.92,80.02 219.7,80.02 219.09,80.63 219.09,81.09 219.62,81.62 220.51,81.62
+1.05V_RUN on BOTTOM (solid shape): 165.83,103.39 165.83,102.5 165.68,102.35 164.37,102.35 164.2,102.17 163.39,102.17 163.03,102.53 163.03,103.97 163.19,104.13 165.09,104.13
+1.05V_RUN on BOTTOM (solid shape): 191.61,75.48 191.61,73.8 190.11,72.3 188.9,72.3 188.76,72.33 188.62,72.3 187.01,72.3 186.81,72.5 186.81,73.6 186.66,73.75 186.66,75.42 187.05,75.82 191.27,75.82
+1.05V_RUN on BOTTOM (solid shape): 176.39,171.13 177.56,171.13 177.87,170.83 177.87,168.44 177.71,168.29 177.07,168.29 177.05,168.3 177.05,168.9 176.85,169.1 174.44,169.1 174.13,169.4 174.13,171.77 174.23,171.87 175.65,171.87
+1.5V_RUN on BOTTOM (solid shape): 225.82,81.01 226.33,81.01 226.35,81.01 226.35,81.52 226.6,81.52 226.6,81.01 227.13,81.01 227.13,81.52 228.19,81.52 228.62,81.09 228.62,79.82 229.76,78.68 229.76,76.49 229.52,76.25 228.73,76.25 226.05,78.93 226.06,78.96 226.02,79.3 225.71,79.45 225.33,79.45 224.27,80.5 224.27,81.15 224.64,81.52 225.82,81.52
+1.05V_RUN on BOTTOM (solid shape): 191.18,82.84 191.18,79.34 190.95,79.11 188.38,79.11 188.37,79.17 188.37,79.21 188.42,79.23 188.69,79.9 188.06,79.55 188.04,79.48 187.97,79.44 187.74,79.33 187.62,79.11 186.81,79.11 186.29,79.63 186.29,82.73 186.54,82.98 191.04,82.98
+1.05V_RUN on BOTTOM (solid shape): 160.42,135.88 160.42,134.1 158.56,132.24 158.56,131.58 157.85,130.87 156.4,130.87 156.38,130.89 156.34,130.91 156.29,130.93 156.24,130.94 156.2,130.95 156.15,130.95 155.9,131.2 155.9,131.74 156.06,131.9 156.08,131.9 156.13,131.93 156.18,131.95 156.22,131.99 156.25,132.02 156.29,132.08 156.31,132.13 156.32,132.18 156.33,132.23 156.33,132.29 156.32,132.32 158.08,134.07 158.76,134.07 158.77,134.02 158.78,133.96 158.8,133.91 158.83,133.86 158.86,133.82 158.9,133.78 158.95,133.75 159,133.72 159.05,133.7 159.11,133.69 159.16,133.69 159.22,133.7 159.27,133.71 159.32,133.73 159.37,133.76 159.41,133.8 159.45,133.84 159.48,133.89 159.5,133.94 159.52,133.99 159.53,134.04 159.53,134.1 159.52,134.16 159.5,134.21 159.48,134.26 159.45,134.31 159.41,134.35 159.37,134.38 159.32,134.41 159.27,134.43 159.22,134.45 159.16,134.45 159.11,134.45 159.05,134.44 159,134.42 158.95,134.4 158.9,134.37 158.86,134.33 158.83,134.28 158.8,134.24 158.78,134.18 158.77,134.13 158.76,134.07 158.08,134.07 158.69,134.69 158.7,134.69 159.04,135.03 159.04,135.03 159.27,135.27 159.27,135.75 159.63,136.1 160.19,136.1
+1.5V_RUN on BOTTOM (solid shape): outline of 143 points within 184.95,97.42 194.83,101.64
+1.5V_RUN on IN2 (solid shape): 221.63,81.34 221.63,80 221.45,79.82 219.93,79.82 219.55,80.2 219.55,81.27 219.8,81.52 221.45,81.52
+1.5V_RUN on IN2 (solid shape): 229.76,78.73 229.76,75.09 229.48,74.81 228.29,74.81 227.7,75.4 227.7,78.6 228.03,78.93 229.56,78.93
+1.05V_RUN on IN2 (solid shape): outline of 629 points within 151.41,130.56 169.64,137.53
+1.5V_RUN on IN2 (solid shape): outline of 711 points within 230.95,15.71 235.52,42.76
+1.05V_RUN on IN2 (solid shape): outline of 1677 points within 132.91,102.22 165.83,127.93
+1.05V_RUN on IN3 (solid shape): 148.2,130.01 148.2,123.25 147.97,123.02 146.14,123.02 145.89,123.28 145.89,126.61 145.38,127.11 145.38,128.41 147.18,130.21 148,130.21
+1.05V_RUN on IN3 (solid shape): 177,170.2 177,168.93 176.75,168.69 176.49,168.69 176.11,168.31 172.91,168.31 172.41,168.82 173.57,168.82 173.58,168.76 173.59,168.71 173.61,168.66 173.64,168.61 173.67,168.56 173.71,168.53 173.76,168.49 173.81,168.47 173.86,168.45 173.91,168.44 173.97,168.44 174.02,168.44 174.08,168.46 174.13,168.48 174.18,168.51 174.22,168.54 174.26,168.59 174.29,168.63 174.31,168.68 174.33,168.74 174.34,168.79 174.34,168.85 174.33,168.9 174.31,168.96 174.29,169.01 174.26,169.05 174.22,169.1 174.18,169.13 174.13,169.16 174.08,169.18 174.02,169.2 173.97,169.2 173.91,169.2 173.86,169.19 173.81,169.17 173.76,169.15 173.71,169.11 173.67,169.08 173.64,169.03 173.61,168.98 173.59,168.93 173.58,168.88 173.57,168.82 172.41,168.82 171.87,169.35 171.87,170.09 172.59,170.81 176.39,170.81
+1.05V_RUN on VCC: 159.18,67.86 158.36,68.67 157.63,68.67 156.92,69.38 155.87,69.38 155.34,69.92 155.34,101.46 158.03,104.15 165.57,104.15 166.46,103.26 166.46,101.1 168.36,99.2 178.04,99.2 178.15,99.09 178.15,98.23 181.85,94.53 184.59,94.53 185.89,93.23 185.89,92.99 186.13,92.75 186.37,92.75 187.13,91.99 187.14,91.67 187.39,91.45 187.66,91.46 187.77,91.35 188.94,91.35 191.53,88.76 191.53,74.54 191.15,74.15 187.19,74.15 186.5,74.84 186.5,79.97 185.77,80.71 183.69,80.71 181.27,83.12 174.97,83.12 173.17,81.32 173.17,77.82 172.15,76.8 160.57,76.8 160.01,76.24 160.01,68.06 159.8,67.86 ; 13 cut-outs
+1.5V_RUN on VCC: 189.93,3 188.2,1.27 186.47,3 186.47,8 185.66,9.96 183.7,10.77 153.74,10.77 152.23,10.2 151.48,8.77 147.03,8.77 147.03,13.58 146.4,14.21 110.07,14.21 109.21,13.35 109.21,12.69 108.88,12.36 107.69,12.36 107.53,12.51 107.53,12.84 107.59,12.89 107.59,13.1 107.53,13.15 107.53,15.68 107.99,16.14 150.82,16.14 151.94,17.26 156.68,17.26 157.8,16.14 223.72,16.14 224.22,16.65 224.22,17.66 236.26,17.66 236.16,17.29 236.13,16.9 236.13,11.64 235.04,10.81 234.63,9.5 234.63,8.77 230.64,8.77 229.64,10.22 227.97,10.77 192.7,10.77 190.74,9.96 189.93,8
+1.5V_RUNP on BOTTOM (solid shape): 224.96,91.25 224.96,88.02 225.44,87.54 227.51,87.54 227.68,87.37 227.68,81.81 227.56,81.69 227,81.69 227,81.14 226.73,81.14 226.73,81.67 226.22,81.67 226.22,81.14 225.95,81.14 225.95,81.69 225.41,81.69 222.77,84.32 222.77,91.48 222.92,91.62 224.58,91.62
+1.5V_THERMAL on IN2 (solid shape): outline of 213 points within 158.71,79.37 160.47,84.82
+1.05V_VCCST on TOP (solid shape): 155.29,98.49 156.1,98.49 156.76,97.83 156.76,97.52 156.66,97.42 155.51,97.42 154.69,98.25 154.69,98.47 154.71,98.49 155.13,98.49 155.13,99.05 155.29,99.05
+1.05V_VCCST on IN2 (solid shape): 132.25,69.79 135.07,69.79 135.17,69.68 135.17,69.35 134.38,68.57 130.37,68.57 129.71,69.23 129.71,69.24 129.7,69.25 131.63,69.25 131.63,69.2 131.63,69.14 131.65,69.09 131.67,69.04 131.7,69 131.74,68.96 131.78,68.93 131.83,68.9 131.88,68.88 131.93,68.87 131.98,68.87 132.04,68.87 132.09,68.88 132.14,68.9 132.18,68.93 132.22,68.96 132.26,69 132.29,69.04 132.31,69.09 132.33,69.14 132.34,69.2 132.34,69.25 132.33,69.3 132.31,69.35 132.29,69.4 132.26,69.45 132.22,69.48 132.18,69.52 132.14,69.54 132.09,69.56 132.04,69.58 131.98,69.58 131.93,69.58 131.88,69.56 131.83,69.54 131.78,69.52 131.74,69.48 131.7,69.45 131.67,69.4 131.65,69.35 131.63,69.3 131.63,69.25 129.7,69.25 129.58,69.37 129.58,70.01 129.74,70.17 131.87,70.17
+1.05V_VMM_VDD on TOP (solid shape): 172.58,156.45 172.58,155.71 172.48,155.61 171.42,155.61 171.31,155.71 171.31,156.37 171.39,156.45 171.92,156.45 172.08,156.6 172.43,156.6
+1.05V_VMM_VDD on TOP (solid shape): 180.58,171.84 180.58,171.23 179.92,170.57 179.92,169.91 180.05,169.79 180.05,168.19 179.9,168.03 179.54,168.03 179.34,168.24 179.34,169.71 179.04,170.01 179.04,171.56 179.42,171.94 180.48,171.94
+1.05V_VMM_VDD on TOP (solid shape): 189.5,165.07 190.05,165.07 190.08,165.04 190.08,163.99 189.98,163.89 186.84,163.89 186.75,163.98 186.68,164.08 186.64,164.09 186.61,164.12 186.49,164.12 186.37,164.14 186.34,164.12 186.29,164.12 186.22,164.05 186.19,164.05 186.13,163.98 186.11,163.97 186.11,163.96 186.04,163.89 185.87,163.89 184.83,162.85 183.56,162.85 183.49,162.91 183.51,162.95 183.52,163.18 183.38,163.37 183.38,163.77 184.93,165.31 189.25,165.31
+1.05V_VMM_VDD on BOTTOM (solid shape): 179.48,172.24 179.67,172.15 179.87,172.18 179.88,172.18 180.19,172.18 180.48,171.89 180.48,170.8 179.84,170.15 179.84,169.9 179.7,169.76 178.22,169.76 178.07,169.91 178.07,172.15 178.16,172.24
+1.05V_VMM_VDD on IN2 (solid shape): outline of 3019 points within 171.1,154.39 185.36,172.12
+1.05V_VMM_VDDTX on BOTTOM (solid shape): outline of 1238 points within 172.55,152.84 182.92,169.61
+1.35V_MEM on TOP (solid shape): outline of 18122 points within 74.34,8.77 205.5,70.23
+1.35V_MEM on BOTTOM (solid shape): 144.19,58.27 147.15,58.27 147.57,57.85 147.61,57.8 147.73,57.68 148.32,57.68 148.48,57.52 148.48,56.18 147.86,55.56 136.68,55.56 135.99,56.26 135.99,58.18 136.18,58.37 137.96,58.37 137.97,58.35 138.02,58.28 138.08,58.22 138.24,58.16 138.42,58.18 138.67,58.3 138.74,58.57 138.73,58.6 139.12,58.99 143.47,58.99
+1.35V_MEM on BOTTOM (solid shape): outline of 5767 points within 73.47,8.77 201.85,38.54
+1.35V_MEM on IN1 (solid shape): 79.57,11.92 91.49,11.92 91.56,11.85 95.39,11.85 95.46,11.92 98.52,11.92 98.53,11.91 98.63,11.88 98.74,11.88 100.52,11.88 100.56,11.92 106.82,11.92 106.98,12.08 107.45,12.08 107.71,11.97 107.97,12.08 108.16,12.08 108.58,12.01 108.8,12.36 108.8,12.38 109.11,12.69 109.11,13.07 109.36,13.32 113.66,13.32 113.94,13.04 113.94,11.06 113.66,10.78 78.35,10.78 77.49,9.92 74.57,9.92 74.08,10.4 74.08,12.97 74.44,13.32 78.17,13.32
+1.35V_MEM on IN1 (solid shape): outline of 308 points within 140.17,12.2 158.59,17.28
+1.35V_MEM on IN2 (solid shape): 143.11,17.21 143.2,17.15 143.19,17.05 143.48,16.48 143.77,17.05 143.76,17.15 143.85,17.21 144.91,17.21 145,17.15 144.99,17.05 145.28,16.48 145.57,17.05 145.56,17.15 145.65,17.21 146.71,17.21 146.8,17.15 146.79,17.05 147.08,16.48 147.37,17.05 147.36,17.15 147.45,17.21 148.51,17.21 148.6,17.15 148.59,17.05 148.88,16.48 149.17,17.05 149.16,17.15 149.25,17.21 156.38,17.21 156.78,16.8 156.78,15.38 156.21,14.81 151.8,14.81 150.15,13.15 145.84,13.15 145.05,12.36 141.35,12.36 139.54,14.17 139.54,16.6 139.61,16.67 139.71,16.7 139.78,16.64 140.07,16.41 140.41,16.56 140.49,16.61 140.58,16.56 140.91,16.4 141.29,16.68 141.38,16.64 141.88,16.54 141.97,17.05 141.96,17.15 142.05,17.21
+1.35V_MEM on IN2 (solid shape): outline of 785 points within 74.34,8.77 114.06,14.07
+1.35V_MEM on IN3 (solid shape): 107.34,13.37 107.41,13.34 107.44,13.27 107.47,13.15 107.53,13.04 107.55,12.98 107.52,12.91 107.54,12.37 108.08,12.39 108.16,12.42 108.23,12.39 108.77,12.36 108.8,12.9 108.78,12.97 108.8,13.03 108.87,13.14 108.89,13.27 108.92,13.34 109,13.37 113.6,13.37 113.96,13.02 113.96,11.06 113.68,10.78 78.48,10.78 77.51,9.82 74.62,9.82 74.03,10.4 74.03,12.79 74.49,13.25 78.02,13.25 79.57,11.7 104.79,11.7 106.47,13.37
+1.35V_MEM on VCC: 138.99,8.77 138.24,10.2 136.74,10.77 80.12,10.77 80.01,10.77 78.08,10.77 77.51,10.2 75.31,10.2 74.44,11.06 74.44,13.14 74.54,13.25 76.11,13.25 76.62,12.74 107.03,12.74 107.03,12.3 107.48,11.85 109.09,11.85 109.72,12.48 109.72,13.14 110.28,13.7 146.19,13.7 146.52,13.37 146.52,8.77
+1.35V_MEN_P on TOP (solid shape): 66.95,14.01 66.95,12.64 66.77,12.46 65.27,12.46 64.84,12.89 64.84,13.88 65.04,14.08 66.87,14.08
+1.35V_MEN_P on TOP (solid shape): 45.76,13.37 45.76,12.33 45.69,12.25 45,12.25 44.71,12.55 44.11,12.55 43.93,12.72 43.93,13.37 44.14,13.58 45.56,13.58
+1.35V_MEN_P on BOTTOM (solid shape): 45.01,13.8 45.01,12.58 44.91,12.48 43.82,12.48 43.67,12.64 43.67,13.88 43.79,14.01 44.81,14.01
+1.35V_MEN_P on BOTTOM (solid shape): outline of 113 points within 60.21,9.64 73.88,21.88
+3.3V_ALW on TOP (solid shape): 175.02,139.82 175.02,139.04 174.93,138.96 173.33,138.96 173.02,139.27 173.02,139.94 173.17,140.09 174.74,140.09
+3.3V_ALW on TOP (solid shape): 195.29,109.21 195.29,108.67 195.19,108.57 193.11,108.57 193.01,108.67 193.01,109.23 193.11,109.33 195.16,109.33
+3.3V_ALW on TOP (solid shape): 216.12,184.49 216.12,183.93 215.97,183.78 212.56,183.78 212.41,183.93 212.41,184.62 212.49,184.7 215.92,184.7
+3.3V_ALW on TOP (solid shape): 170.65,107.3 170.65,106.39 170.3,106.03 169.23,106.03 168.8,105.59 168.54,105.59 168.09,105.14 167.28,105.14 167.21,105.2 167.21,106.03 167.8,106.62 168.67,107.49 170.47,107.49
+3.3V_ALW on TOP (solid shape): 195.01,111.26 195.01,110.88 194.91,110.78 194.87,110.78 194.66,110.86 194.44,110.78 194.1,110.78 194,110.68 193.16,110.68 193.01,110.83 193.01,111.19 193.16,111.34 194.94,111.34
+3.3V_ALW on TOP (solid shape): 183.02,131.99 183.02,131.18 182.88,131.04 182.25,131.04 181.96,130.75 181.87,130.75 181.64,130.52 181.63,130.25 181.64,129.91 181.46,129.73 181.27,129.73 181.22,129.78 181.22,130.25 181.18,130.29 180.76,130.29 180.74,130.27 180.74,129.75 180.72,129.73 180.53,129.73 180.53,130.64 182.11,132.22 182.79,132.22
+3.3V_ALW on TOP (solid shape): 169.61,140.28 169.61,139.45 169.77,139.29 171.17,139.29 171.26,139.2 171.26,138.06 171.01,137.8 170.99,137.79 169.79,137.79 169.79,138.35 169.3,138.35 169.3,137.79 168.71,137.79 168.49,138.01 167.5,138.01 167.35,137.86 167.35,137.43 166.97,137.04 166.67,137.04 166.61,137.1 166.61,138.09 167.35,138.82 167.35,139.48 167.45,139.58 168.29,139.58 168.44,139.74 168.44,140.26 168.52,140.34 169.55,140.34
+3.3V_ALW on TOP (solid shape): 213.2,130.77 213.2,128.56 212.79,128.15 211.14,128.15 210.38,127.39 210.38,120.38 210.68,120.08 215.76,120.08 216.7,119.14 217.29,119.14 217.52,118.91 218.32,118.91 218.49,118.75 218.49,118.41 218.35,118.27 214.62,118.27 213.96,117.61 207.86,117.61 207.15,118.32 207.15,127.62 210.73,131.2 212.77,131.2
+3.3V_ALW on TOP (solid shape): 219.09,182.18 219.09,174.66 208.8,164.38 208.8,162.09 208.68,161.96 208.68,161.33 208.23,160.88 208.23,159.76 206.9,158.43 206.9,155.23 206.58,154.91 205.6,154.91 205.45,154.76 205.45,154.27 205.6,154.11 205.6,153.73 205.48,153.61 204.44,153.61 204.18,153.86 204.18,158.94 206.14,160.9 206.14,163.33 206.39,163.59 206.39,165.39 216.68,175.68 216.68,180.33 217.85,181.49 217.85,182.18 218,182.33 218.94,182.33
+3.3V_ALW on TOP (solid shape): 166.61,114.54 166.61,114.08 167.07,113.63 167.07,111.49 167.17,111.39 167.71,111.39 167.91,111.19 167.91,110.6 167.81,110.5 162.8,110.5 162.65,110.65 162.65,111.14 162.8,111.29 163.62,111.29 163.62,111.25 165.33,111.25 165.33,111.29 165.4,111.29 165.57,111.46 165.64,111.49 165.71,111.45 166.15,111.35 166.38,111.73 166.38,111.74 166.27,111.98 166.04,112.09 166.02,112.09 165.88,112.23 165.88,113.16 166.06,113.47 165.88,113.78 165.88,114.57 166.01,114.69 166.46,114.69
+3.3V_ALW on BOTTOM (solid shape): 263.03,151.93 263.03,150.15 262.78,149.9 262.27,149.9 262.06,150.11 262.06,152.09 262.14,152.18 262.78,152.18
+3.3V_ALW on BOTTOM (solid shape): 256.18,164.12 256.18,162.72 256.1,162.65 256.1,162.06 256.02,161.99 254.85,161.99 254.55,162.29 254.55,164.4 254.65,164.5 255.79,164.5
+3.3V_ALW on BOTTOM (solid shape): 260.65,152.11 260.65,150.15 260.42,149.92 258.97,149.92 258.79,150.1 258.79,151.34 259.22,151.78 259.48,151.78 259.88,152.18 260.57,152.18
+3.3V_ALW on BOTTOM (solid shape): 270.06,183.29 270.06,182.39 270.21,182.25 270.21,181.66 270.06,181.51 269.43,181.51 269.08,181.16 266.67,181.16 266.49,181.34 266.49,182.22 267.76,183.49 269.87,183.49
+3.3V_ALW on BOTTOM (solid shape): 230.16,81.01 230.66,81.01 230.66,81.54 230.93,81.54 230.93,81 232.37,81 232.81,80.56 232.81,78.52 232.3,78.02 231.16,78.02 229.25,79.92 229.25,80.84 229.42,81.01 229.86,81.01 229.86,81.54 230.16,81.54
+3.3V_ALW on BOTTOM (solid shape): 224.32,146.98 224.32,146.19 223.79,146.19 223.79,145.43 224.32,145.43 224.32,144.97 223.79,144.97 223.79,144.23 224.3,144.23 224.32,144.21 224.32,141.95 223.66,141.29 220.62,141.29 219.95,141.95 219.95,142.92 221.34,144.31 221.34,146.96 221.55,147.18 224.12,147.18
+3.3V_ALW on BOTTOM (solid shape): outline of 95 points within 95.95,127.06 105.17,141.9
+3.3V_ALW on VCC (solid shape): outline of 7063 points within 215.64,140.09 281.98,186.63
+3.3V_ALW on VCC (solid shape): outline of 28412 points within 63.14,99.25 213.91,157.24
+3.3V_ALW on IN2 (solid shape): 219.09,184.19 219.09,181.65 218.2,180.76 212.49,180.76 212.11,181.14 212.11,182.8 216.75,182.8 216.75,182.74 216.76,182.69 216.77,182.64 216.8,182.59 216.83,182.55 216.86,182.51 216.9,182.47 216.95,182.45 217,182.43 217.05,182.42 217.1,182.41 217.16,182.42 217.21,182.43 217.26,182.45 217.31,182.47 217.35,182.51 217.38,182.55 217.41,182.59 217.44,182.64 217.45,182.69 217.46,182.74 217.46,182.8 217.45,182.85 217.44,182.9 217.41,182.95 217.38,182.99 217.35,183.03 217.31,183.06 217.26,183.09 217.21,183.11 217.16,183.12 217.1,183.13 217.05,183.12 217,183.11 216.95,183.09 216.9,183.06 216.86,183.03 216.83,182.99 216.8,182.95 216.77,182.9 216.76,182.85 216.75,182.8 212.11,182.8 212.11,184.19 212.61,184.7 218.58,184.7
+3.3V_ALW on IN2 (solid shape): outline of 846 points within 210.76,78.22 234.04,120.05
+3.3V_ALW on IN2 (solid shape): outline of 1709 points within 200.96,140.35 223.54,156.54
+3.3V_ALW on IN3 (solid shape): outline of 221 points within 166.39,106.56 179.85,121.22
+3.3V_ALW2 on TOP (solid shape): 153.97,160.39 155.77,160.39 155.82,160.44 156.25,160.44 156.61,160.08 156.61,158.81 156.45,158.66 156.12,158.66 155.97,158.81 154.83,158.81 154.63,159.02 154.63,159.52 154.42,159.73 153.71,159.73 153.61,159.63 153.61,158.91 153.41,158.71 151.53,158.71 151.32,158.91 151.32,159.85 151.91,160.44 153.92,160.44
+3.3V_ALW_5048 on TOP (solid shape): 181.07,130.12 181.07,129.59 181.08,129.57 181.67,129.57 181.68,129.52 181.79,129.29 182.03,129.19 182.05,129.19 182.29,128.95 182.29,128.84 182.24,128.84 182.24,128.08 182.31,128.08 182.49,127.9 183.79,127.9 183.96,127.72 183.96,127.44 183.51,126.99 181.32,126.99 180.97,127.33 180.97,128.68 180.56,129.09 180.48,129.17 180.48,129.58 180.86,129.58 180.89,129.61 180.89,130.12 180.9,130.13 181.06,130.13
+3.3V_ALW_5075 on TOP (solid shape): 169.63,138.17 169.63,137.64 171.18,137.64 171.31,137.5 171.31,136.54 171.16,136.38 169.03,136.38 168.94,136.48 168.94,137.55 168.99,137.61 169.02,137.63 169.46,137.63 169.46,138.18 169.47,138.19 169.62,138.19
+3.3V_ALW_5075 on IN2 (solid shape): outline of 4307 points within 152.57,115.73 176.62,137.15
+3.3V_ALW_PCH on TOP (solid shape): 161.1,73.6 161.1,72.86 161.03,72.78 160.04,72.78 159.88,72.94 159.88,73.6 159.96,73.67 160.39,73.67 160.42,73.7 161,73.7
+3.3V_ALW_PCH on TOP (solid shape): 186.05,79.03 186.43,79.03 186.53,78.92 186.53,77.38 186.42,77.26 185.86,77.26 185.65,77.06 185.65,76.43 185.13,75.91 184.67,75.91 184.65,75.93 184.65,76.72 184.57,76.8 184.57,77 184.93,77.35 184.93,79.36 185.08,79.51 185.56,79.51
+3.3V_ALW_PCH on TOP (solid shape): 186.63,61.05 186.63,60.59 186.53,60.49 185.94,60.49 185.89,60.54 185.46,60.54 185.31,60.39 185.31,59.73 185.69,59.35 185.69,58.89 185.31,58.51 185.31,58.05 185.21,57.95 184.67,57.95 184.45,58.18 184.42,58.18 184.42,60.75 184.48,60.83 184.52,60.93 184.52,60.94 184.72,61.15 186.53,61.15
+3.3V_ALW_PCH on TOP (solid shape): outline of 181 points within 167.23,97.83 181.71,107.12
+3.3V_ALW_PCH on BOTTOM (solid shape): 195.01,63.49 195.01,62.6 194.78,62.37 193.56,62.37 193.41,62.52 193.41,63.54 193.44,63.54 193.56,63.66 194.83,63.66
+3.3V_ALW_PCH on BOTTOM (solid shape): 179.93,74.9 179.93,74.69 179.92,74.69 179.92,74.67 180.14,74.45 180.62,74.45 180.8,74.27 181.57,74.27 181.64,74.21 181.64,73.33 181.72,73.25 181.72,72.99 181.36,72.63 178.9,72.63 178.82,72.71 178.82,73.1 178.89,73.17 180.37,73.17 180.45,73.26 180.45,73.64 180.09,73.99 179.95,73.99 179.83,74.03 179.7,74.02 179.3,74.42 179.3,74.9 179.36,74.97 179.86,74.97
+3.3V_ALW_PCH on IN1 (solid shape): outline of 1378 points within 157.1,66.92 175.73,74.18
+3.3V_ALW_PCH on VCC: 179.57,61.23 173.68,67.12 173.68,69.78 175.17,71.28 175.17,76.32 173.68,77.82 173.68,81.11 175.18,82.61 181.06,82.61 183.48,80.2 185.56,80.2 185.99,79.76 185.99,74.63 186.98,73.65 191.36,73.65 192.04,74.33 192.04,88.97 189.5,91.5 189.77,91.5 190.01,91.74 190.01,92.08 189.77,92.32 188.72,92.32 188.54,92.13 188.36,92.3 187.57,92.27 186.71,93.13 186.71,93.98 186.47,94.22 186.13,94.22 185.89,93.98 185.89,93.94 184.8,95.03 182.06,95.03 178.65,98.44 178.65,99.86 178.94,100.14 190.13,100.14 199.86,90.41 199.86,73.55 194.81,68.49 186.88,68.49 185.99,67.6 185.99,61.66 185.56,61.23 185.11,61.23 184.85,61.32 184.59,61.23 ; 1 cut-out
+3.3V_ALWP on BOTTOM (solid shape): 232.76,152.84 232.76,148.04 230.76,146.04 230.76,140.86 230.32,140.42 225.11,140.42 224.48,141.06 224.48,144.39 223.94,144.39 223.94,144.82 224.5,144.82 224.5,145.58 223.94,145.58 223.94,146.04 224.48,146.04 224.48,147.89 224.68,148.09 228.54,148.09 228.92,148.47 228.92,152.85 229.17,153.11 232.49,153.11
+3.3V_AVCC on TOP (solid shape): 116.12,117.51 116.12,117.16 116.13,117.14 116.5,116.77 116.5,115.71 116.4,115.61 113.4,115.61 113.22,115.78 113.22,117.03 113.83,117.64 115.99,117.64
+3.3V_AVCC on TOP (solid shape): 117.88,121.41 117.88,120.42 118,120.31 118.25,120.31 118.35,120.2 118.35,119.57 118.28,119.49 118.28,118.27 118.1,118.1 117.64,118.1 117.53,118.21 117.53,119.38 117.39,119.52 117.21,119.52 117.16,119.57 117.16,119.95 117.62,120.41 117.62,121.42 117.69,121.5 117.8,121.5
+3.3V_AVCC on IN3 (solid shape): 120.36,119.93 120.36,116.62 119.98,116.24 114.82,116.24 114.52,116.55 114.52,117.66 114.53,117.7 114.57,117.71 114.93,118.07 114.57,118.43 114.53,118.44 114.52,118.48 114.52,119.93 114.9,120.31 119.98,120.31
+3.3V_CAM on TOP (solid shape): 99.94,161.15 99.94,160.46 99.79,160.31 97.65,160.31 97.55,160.41 97.55,161.15 97.68,161.28 99.81,161.28
+3.3V_CAM on BOTTOM (solid shape): 90.94,160.76 90.94,159.32 90.69,159.07 90.54,159.07 90.54,159.26 90.29,159.93 90.03,159.26 90.03,159.07 89.4,159.07 89.09,159.38 89.09,159.93 89.62,159.93 89.62,160.36 89.08,160.36 89.08,161.07 89.14,161.13 90.57,161.13
+3.3V_CAM_Q on BOTTOM (solid shape): 88.95,161.25 88.95,160.24 89.49,160.24 89.49,160.06 88.96,160.06 88.96,160.03 88.95,160.03 88.95,159.52 88.96,159.52 88.96,158.26 88.59,157.88 85.89,157.88 85.47,158.3 85.47,159.69 86.5,160.72 86.52,160.72 87.27,161.46 88.74,161.46
+3.3V_DVCC on TOP (solid shape): 124.32,128.92 124.32,125.61 124.17,125.46 122.22,125.46 122.19,125.44 122.01,125.44 121.99,125.46 121.99,125.67 122.04,125.72 122.04,128.89 122.24,129.09 124.15,129.09
+3.3V_DVCC on IN2 (solid shape): outline of 2577 points within 107.97,114.03 126.18,129.65
+3.3V_GPU on TOP (solid shape): 72.13,96.84 72,96.71 70.7,96.71 70.63,96.63 70.57,96.63 70.36,96.55 70.25,96.35 70.25,96.3 70.25,95.62 69.26,94.63 68.39,94.63 68.32,94.71 68.23,94.76 68.09,94.78 67.94,94.73 67.79,94.89 67.79,95.73 67.84,95.82 67.94,95.82 68.22,95.79 68.42,95.97 68.47,96.02 68.55,96.02 68.61,96 68.67,96 68.85,96 69.17,96.32 68.85,96.63 68.67,96.63 68.63,96.63 68.6,96.63 68.45,96.63 68.34,96.73 68.34,97.1 68.44,97.2 69.2,97.2 69.27,97.27 71.03,97.27 71.2,97.44 72.13,97.44
+3.3V_GPU on BOTTOM (solid shape): 88.79,77.44 88.79,76.74 88.55,76.5 87.67,75.62 87.67,75.62 87.28,75.23 85.76,75.23 85.54,75.45 85.54,75.88 86.6,76.94 86.6,77.11 86.68,77.19 87.78,77.19 88.09,77.51 88.73,77.51
+3.3V_GPU on BOTTOM (solid shape): 65.1,94.65 65.11,94.62 65.23,94.48 65.4,94.43 65.42,94.43 65.74,94.1 65.76,93.94 65.86,93.8 65.86,93.42 65.82,93.38 65.78,93.33 65.52,93.07 65.43,93.03 65.36,92.97 65.1,92.97 64.94,93.13 64.94,93.15 64.35,93.74 64.35,93.76 64.17,93.94 64.17,94.16 63.67,94.66 63.67,94.99 63.8,95.12 64.63,95.12
+3.3V_GPU on IN1 (solid shape): outline of 1088 points within 61.26,87.41 73.4,95.8
+3.3V_GPU on IN2 (solid shape): outline of 1154 points within 68.93,75.68 88.08,118.78
+3.3V_HDD on TOP (solid shape): 219.6,117.64 219.6,117.51 221.12,115.99 221.38,115.99 221.38,114.97 221,114.59 218.84,114.59 218.33,115.1 218.33,116.37 217.57,117.13 217.57,117.77 217.77,117.97 219.27,117.97
+3.3V_HDD on TOP (solid shape): 224.17,120.43 224.17,119.56 224.62,119.11 224.62,118.7 224.28,118.36 223.04,118.36 222.52,118.88 222.52,120.31 222.52,120.31 222.52,120.42 222.79,120.69 223.92,120.69
+3.3V_HDD on BOTTOM (solid shape): 224,121.34 224.44,121.34 224.44,121.88 224.96,121.88 225.06,121.78 225.06,118.27 224.81,118.02 223.66,118.02 223.54,118.15 223.54,119.16 223.41,119.29 222.97,119.29 222.79,119.47 222.71,119.65 222.53,119.73 222.36,119.9 222.36,121.65 222.59,121.88 224,121.88
+3.3V_HDD_C on BOTTOM (solid shape): 225.06,123.74 225.06,122.08 224.98,122 224.33,122 224.31,122 224.31,121.47 224.13,121.47 224.13,122 224.1,122 223.59,122 221.88,122 221.26,121.39 218.38,121.39 218.16,121.61 218.16,123.56 218.46,123.86 224.93,123.86
+3.3V_LAN on TOP (solid shape): 214.36,179.64 214.77,179.64 215.11,179.64 215.51,179.64 215.76,179.39 215.76,175.78 213.38,173.39 205.12,173.39 204.99,173.52 204.99,175.3 205.38,175.68 211.6,175.68 212.92,177 212.92,179.44 213.15,179.67 213.64,179.67 214.15,179.67 214.17,179.67 214.17,180.2 214.36,180.2
+3.3V_LAN on BOTTOM (solid shape): 336.52,175.02 336.52,174.87 336.46,174.81 334.86,174.81 334.51,174.46 333.67,174.46 333.49,174.64 333.49,174.97 333.62,175.09 336.44,175.09
+3.3V_LAN on IN2 (solid shape): outline of 1545 points within 190.41,155.05 206.01,175.68
+3.3V_LAN_OUT on TOP (solid shape): 198.63,146.57 198.63,145.36 198.75,145.23 198.75,144.98 198.56,144.79 198.53,144.79 198.31,144.86 198.1,144.79 197.67,144.79 197.61,144.85 197.61,145.17 198,145.56 198,146.58 198.05,146.63 198.56,146.63
+3.3V_LAN_OUT on IN3 (solid shape): outline of 971 points within 195.37,143.84 205.32,153.45
+3.3V_LANP on TOP (solid shape): 216.14,183.43 216.14,180.86 215.25,179.96 215.24,179.96 215.14,179.89 215.07,179.79 215.05,179.77 214.89,179.77 214.48,179.77 214.48,180.33 214.05,180.33 214.05,179.79 212.94,179.79 212.47,180.27 212.47,182.76 212.85,183.14 213.87,183.14 214.32,183.59 215.98,183.59
+3.3V_M on TOP (solid shape): 194.4,70.83 194.4,69.81 193.97,69.38 191.02,69.38 190.36,70.04 190.36,70.75 190.69,71.08 194.15,71.08
+3.3V_M on TOP (solid shape): 206.76,70.28 207.55,70.28 207.61,70.22 207.61,68.9 206.82,68.11 204.79,68.11 204.23,68.67 204.23,69.94 204.59,70.29 206.75,70.29
+3.3V_M on TOP (solid shape): 191.79,109.26 191.79,107.71 191.48,107.4 188.59,107.4 188.38,107.61 188.38,108.15 188.66,108.43 189.49,108.43 190.08,109.03 190.49,109.03 190.8,109.33 191.71,109.33
+3.3V_M on TOP (solid shape): outline of 611 points within 162.28,72.05 180.84,75.85
+3.3V_M on BOTTOM (solid shape): 206.54,82.74 206.54,80.38 206.14,79.97 203.9,79.97 203.7,80.17 203.7,80.83 203.91,81.05 205.06,81.05 205.4,81.39 205.4,82.74 205.45,82.79 206.49,82.79
+3.3V_M on IN2 (solid shape): 193.31,107.63 193.31,106.36 193.28,106.34 192.47,106.34 191.86,106.95 191.38,106.95 190.44,107.89 190.44,108.67 190.64,108.88 192.07,108.88
+3.3V_M on IN2 (solid shape): 205.93,81.09 205.93,79.16 205.63,78.85 204.74,78.85 204.74,79.7 204.18,80.26 204.18,80.3 203.06,81.42 203.06,82.38 203.27,82.59 204.43,82.59
+3.3V_M on IN2 (solid shape): 206.85,70.06 206.85,68.24 206.59,67.98 203.65,67.98 203.52,68.11 203.52,70.01 203.57,70.06 205.71,70.06 205.83,70.19 206.72,70.19
+3.3V_M on IN3 (solid shape): 191.51,70.73 191.51,70.14 191.38,70.01 189.42,70.01 188.89,70.55 188.89,71.18 189.12,71.41 190.82,71.41
+3.3V_M on IN3 (solid shape): 181.15,73.05 181.16,73.04 181.25,72.89 181.4,72.8 181.41,72.79 181.45,72.76 181.45,72.27 181.14,71.97 180.43,71.97 178.93,73.47 178.93,73.85 179.11,74.03 180,74.03 180.03,74.05 180.15,74.05
+3.3V_PCIE_WWAN on TOP (solid shape): 235.83,160.4 235.83,159.37 235.63,159.17 232.3,159.17 232.16,159.31 232.16,160.66 232.3,160.8 235.42,160.8
+3.3V_PCIE_WWAN on BOTTOM (solid shape): 235.93,160.44 235.93,159.72 235.6,159.39 233.32,159.39 233.06,159.65 233.06,160.73 233.19,160.85 235.52,160.85
+3.3V_PCIE_WWAN on BOTTOM (solid shape): 247.62,135.19 247.62,130.34 246.7,129.42 243.58,129.42 243.36,129.64 243.36,130.3 243.17,130.49 242.74,130.49 242.41,130.82 242.41,134.15 243.6,135.34 247.46,135.34
+3.3V_PCIE_WWAN on BOTTOM (solid shape): 238.75,145.6 238.75,144.33 241.03,142.06 243.27,142.06 243.33,141.99 243.33,141.61 243.08,141.36 243.07,141.36 241.88,140.17 239.89,140.17 239.39,140.68 239.39,141.29 236.74,143.93 236.74,145.58 237.02,145.86 238.5,145.86
+3.3V_PCIE_WWAN on BOTTOM (solid shape): 252.37,161.2 252.37,159.93 254.42,157.87 257.01,157.87 257.46,157.43 257.46,155.47 257.47,155.46 258.03,155.46 258.05,155.43 258.05,155.31 258.03,155.28 257.52,155.28 257.47,155.23 257.47,153.99 257.32,153.83 252.59,153.83 249.22,157.21 249.22,159.24 248.75,159.71 248.75,161.8 249.39,162.44 251.12,162.44
+3.3V_PCIE_WWAN on IN2 (solid shape): 245.66,137.81 245.66,131.3 245,130.64 242.76,130.64 240.27,133.13 240.27,142.02 240.43,142.18 241.29,142.18
+3.3V_PCIE_WWAN on IN3 (solid shape): outline of 744 points within 235.09,144.97 250.97,165.77
+3.3V_PCIE_WWANP on BOTTOM (solid shape): 260.24,156.5 260.24,154.93 260.62,154.55 260.62,153.45 260.59,153.43 259.55,153.43 259.48,153.35 257.98,153.35 257.65,153.68 257.65,155.13 258.21,155.13 258.21,155.59 258.18,155.61 257.62,155.61 257.62,156.55 257.78,156.7 260.04,156.7
+3.3V_RUN on TOP (solid shape): 114.48,115.29 114.48,113.94 114.9,113.52 114.9,113.04 114.75,112.89 113.91,112.89 113.17,113.63 113.17,115.2 113.35,115.38 114.39,115.38
+3.3V_RUN on TOP (solid shape): 170.98,164.5 170.98,162.42 170.88,162.32 170.04,162.32 169.74,162.62 169.74,164.12 168.62,165.24 168.62,165.85 168.65,165.87 169.61,165.87
+3.3V_RUN on TOP (solid shape): 245.71,144.06 245.71,143.14 245.33,142.76 244.19,142.76 244.06,142.89 244.06,143.18 243.7,143.54 243.7,144.06 243.92,144.28 245.48,144.28
+3.3V_RUN on TOP (solid shape): 97.5,18.4 97.5,17.21 97.17,16.88 97.17,13.83 96.99,13.65 96.16,13.65 95.88,13.93 95.88,18.53 95.95,18.6 97.3,18.6
+3.3V_RUN on TOP (solid shape): 112.69,114.82 112.69,112.83 112.67,112.8 111.59,112.8 111.42,112.97 111.42,114.13 111.22,114.34 110.56,114.34 110.49,114.4 110.49,114.78 110.57,114.86 112.65,114.86
+3.3V_RUN on TOP (solid shape): 164.86,165.82 164.86,165.19 165.15,164.9 165.15,163.04 164.99,162.88 164.33,162.88 164,163.21 164,164.68 163.41,165.26 163.41,165.87 163.49,165.95 164.74,165.95
+3.3V_RUN on TOP (solid shape): 215.98,143.51 216.34,143.33 216.7,143.17 216.7,142.2 216.5,142 214.21,142 214.06,142.15 214.06,143.27 214.32,143.52 215.97,143.52
+3.3V_RUN on TOP (solid shape): 166.94,100.49 166.94,99.76 166.82,99.63 165.07,99.63 164.56,99.12 164.35,99.12 164.25,99.22 164.25,100.37 164.43,100.54 166.89,100.54
+3.3V_RUN on TOP (solid shape): 160.82,166.13 160.82,165.29 160.62,165.09 160.06,165.09 159.76,164.78 159.76,164.58 159.68,164.5 159.68,163.03 159.55,162.9 158.92,162.9 158.66,163.16 158.66,164.91 158.13,165.44 158.13,166.13 158.26,166.25 160.7,166.25
+3.3V_RUN on TOP (solid shape): 134,112.43 134,109.74 133.67,109.41 133.29,109.41 133.26,109.43 133.26,110.02 132.73,110.02 132.73,109.46 132.68,109.41 132.5,109.41 131.84,110.07 131.84,110.88 131.23,111.49 131.23,112.28 131.51,112.56 133.87,112.56
+3.3V_RUN on TOP (solid shape): 182.67,126.28 182.67,124.73 182.52,124.57 182.04,124.57 181.82,124.65 181.6,124.57 181.09,124.57 180.94,124.73 180.94,126.28 181.12,126.45 182.49,126.45
+3.3V_RUN on TOP (solid shape): 195.9,156.6 195.9,155.27 195.71,155.07 194.94,155.07 194.75,154.88 194.75,154.57 194.56,154.38 193.8,154.38 193.67,154.5 193.67,155.7 193.98,156 193.98,156.01 194.25,156.28 194.35,156.28 194.45,156.27 194.55,156.28 194.69,156.28 194.88,156.47 194.88,156.66 194.94,156.73 195.77,156.73
+3.3V_RUN on TOP (solid shape): 222.47,61.68 224.5,61.68 226.1,60.08 226.1,59.41 225.78,59.09 224.78,59.09 224.58,58.89 223.84,58.89 223.69,59.04 223.69,59.98 223.47,60.2 222.3,60.2 221.85,59.74 221.85,59.13 221.76,59.04 221.58,59.04 221.53,59.09 221.53,59.6 221,59.6 220.97,59.57 220.97,59.12 220.89,59.04 220.64,59.04 220.54,59.14 220.54,62.32 220.82,62.6 221.55,62.6
+3.3V_RUN on TOP (solid shape): 298.31,163.51 298.31,162.44 297.53,161.66 297.53,161 297.4,160.87 295.19,160.87 295.06,160.74 295.01,160.74 295.01,160.69 294.94,160.62 294.94,159.35 295.01,159.27 295.39,159.27 295.43,159.23 295.74,159.23 295.78,159.27 296.05,159.27 296.07,159.24 296.39,159.24 296.41,159.27 296.86,159.27 296.89,159.24 297.2,159.24 297.23,159.27 297.37,159.27 297.68,159.57 297.68,160.59 297.81,160.72 300.04,160.72 300.17,160.59 300.17,160.34 299.56,159.73 299.56,159.47 299.2,159.12 298.24,159.12 297.32,158.2 293.31,158.2 292.98,158.53 292.98,161.66 292.92,161.72 292.36,161.72 292.03,162.05 292.03,162.99 292.19,163.16 294.45,163.16 294.55,163.05 294.55,161.84 294.66,161.73 296.82,161.73 297.96,162.88 297.96,163.46 298.04,163.55 298.28,163.55
+3.3V_RUN on TOP (solid shape): 188.57,170.67 188.57,170.09 188.88,169.79 188.88,168.42 188.88,167.03 188.66,166.81 188.26,166.81 188.05,167.02 188.05,167.7 187.92,167.84 187.89,167.91 187.92,167.98 188.01,168.12 188.02,168.29 188.01,168.45 187.92,168.59 188.01,168.73 188.02,168.9 187.83,169.26 187.42,169.2 187.06,169.2 186.45,169.81 186.43,169.81 186.25,169.99 185.31,169.99 185.17,170.13 184.72,170.13 184.57,170.27 184.57,170.9 184.61,170.94 188.31,170.94
+3.3V_RUN on TOP (solid shape): 188.94,146.39 188.94,143.17 188.71,142.94 186.99,142.94 186.81,143.12 186.81,145.43 186.3,145.93 186.12,145.93 186.02,146 186.05,146.12 185.82,146.8 185.58,146.12 185.62,146 185.52,145.93 183.66,145.93 183.58,146.01 183.58,146.38 184.12,146.38 184.12,146.81 183.58,146.81 183.58,147.08 183.68,147.18 184.14,147.18 184.45,147.48 187.85,147.48
+3.3V_RUN on TOP (solid shape): 215.81,132.73 215.81,131.51 216.6,130.72 220.41,130.72 220.52,130.61 221.41,130.61 221.49,130.53 221.51,130.5 221.5,130.46 221.72,129.89 222.12,130.35 222.14,130.44 222.22,130.48 223.17,130.48 224.17,129.48 224.17,121.83 223.99,121.65 219.33,121.65 219.28,121.7 219.28,121.97 219.83,121.97 219.83,122.45 219.28,122.45 219.28,125.83 219.57,126.12 219.57,127.01 219.37,127.21 219.07,127.21 218.99,127.29 218.99,127.7 220.32,127.7 220.91,127.69 220.95,128.29 220.93,128.33 220.94,128.36 220.95,128.37 220.91,128.96 220.31,128.95 220.15,128.79 218.49,128.79 217.9,128.2 217.9,127.34 217.77,127.21 217.11,127.21 217.01,127.32 217.01,128.79 216.6,129.2 214.06,129.2 213.43,129.83 213.43,132.72 213.79,133.08 215.46,133.08
+3.3V_RUN on TOP (solid shape): outline of 494 points within 197.51,75.53 215.1,83.72
+3.3V_RUN on TOP (solid shape): outline of 476 points within 159.88,74.09 171.22,76.59
+3.3V_RUN on TOP (solid shape): outline of 688 points within 169.76,74.67 186.88,83.22
+3.3V_RUN on TOP (solid shape): outline of 1656 points within 12.93,19.06 32.64,33.29
+3.3V_RUN on BOTTOM (solid shape): 79.32,88.32 79.32,87.97 79.13,87.78 79.13,86.83 78.94,86.64 78.17,86.64 77.28,87.53 77.28,88.23 77.55,88.49 79.15,88.49
+3.3V_RUN on BOTTOM (solid shape): 94.62,60.23 94.62,58.57 94.12,58.08 93.62,58.08 93.11,58.58 93.11,59.85 93.77,60.51 94.34,60.51
+3.3V_RUN on BOTTOM (solid shape): 105.71,124.78 106.68,124.78 107.2,124.25 107.2,123.02 107.05,122.87 106.09,122.87 104.66,124.29 104.66,124.67 104.82,124.83 105.65,124.83
+3.3V_RUN on BOTTOM (solid shape): 133.24,115.48 133.24,111.67 133.11,111.54 131.33,111.54 131.21,111.67 131.21,115.61 131.33,115.73 132.99,115.73
+3.3V_RUN on BOTTOM (solid shape): 90.54,137.49 90.54,135.74 90.3,135.5 86.26,135.5 86.02,135.74 86.02,137.18 86.22,137.39 87.7,137.39 88.04,137.73 90.3,137.73
+3.3V_RUN on BOTTOM (solid shape): 85.84,48.6 86.33,48.6 87.09,47.84 87.09,47.03 86.86,46.8 86.3,46.8 84.95,48.14 84.95,48.73 85.16,48.93 85.51,48.93
+3.3V_RUN on BOTTOM (solid shape): 88.63,144.56 88.63,143.21 88.46,143.04 86.63,143.04 86.38,143.29 86.38,144.12 86.61,144.35 87.3,144.35 87.74,144.79 88.4,144.79
+3.3V_RUN on BOTTOM (solid shape): 260.11,164.45 260.11,162.47 259.99,162.34 258.97,162.34 258.59,161.96 257.45,161.96 257.32,162.09 257.32,164.25 257.33,164.26 257.33,164.44 257.55,164.65 259.91,164.65
+3.3V_RUN on BOTTOM (solid shape): 15.44,29.49 16.05,29.49 16.28,29.26 18.54,29.26 18.99,28.81 18.99,28.43 18.96,28.4 16.29,28.4 16.28,28.4 14.4,28.4 14.23,28.58 13.35,28.58 13.1,28.82 13.1,29.79 13.25,29.93 15,29.93
+3.3V_RUN on BOTTOM (solid shape): 88.59,80.4 88.59,79.96 88.79,79.75 88.79,78.84 88.67,78.71 87.65,78.71 87.59,78.78 87.59,78.99 87.57,79.01 87.57,79.32 87.35,79.54 87.21,79.54 86.93,79.81 86.93,80.35 87.06,80.48 88.51,80.48
+3.3V_RUN on BOTTOM (solid shape): 191.13,169.51 191.13,166.94 191.05,166.86 190.52,166.86 190.44,166.94 189.16,166.94 188.99,167.11 188.99,168.04 188.99,168.04 188.99,168.22 189.09,168.32 189.72,168.32 189.83,168.35 189.91,168.43 189.97,168.47 190.04,168.47 190.57,168.84 190,169.16 189.85,169.16 189.8,169.21 189.04,169.21 189,169.25 189,169.43 189.07,169.51 190.29,169.51 190.47,169.68 190.95,169.68
+3.3V_RUN on IN1 (solid shape): 94.5,60.36 94.5,59.73 94.1,59.32 93.26,59.32 93.11,59.47 93.11,60.24 93.49,60.62 94.25,60.62
+3.3V_RUN on IN1 (solid shape): 97.81,75.35 97.81,74.46 97.55,74.21 96.54,74.21 96.41,74.33 96.41,75.48 96.54,75.6 97.55,75.6
