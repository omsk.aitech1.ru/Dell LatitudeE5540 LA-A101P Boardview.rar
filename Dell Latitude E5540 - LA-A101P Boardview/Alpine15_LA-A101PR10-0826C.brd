# Allegro board Alpine15_LA-A101PR10-0826C.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
FBA_CMD5: length 66.4
  TOP w0.102: v2(24.71,91.1) 25.11,91.49 25.11,92.09 25.68,92.66 26.84,92.66 UV7.T2 ; UV5.T2 26.83,108.41 25.67,108.41 25.09,107.84 25.09,107.24 v2(24.7,106.85)
  IN3 w0.091: v2(24.71,91.1) 24.8,91.1 25.09,91.39 25.09,92.91 25.03,92.98 25.03,96.06 24.5,96.59 24.5,99.37 24.57,99.44 v2(24.57,100.15) 24.57,101.28 24.47,101.39 24.17,101.39 24.07,101.49 24.07,101.79 24.17,101.89 24.47,101.89 24.57,101.99 24.57,102.3 24.47,102.4 24.17,102.4 24.07,102.5 24.07,102.81 24.17,102.91 24.47,102.91 24.57,103.01 24.57,106.72 v2(24.7,106.85)
  BOTTOM w0.102: v2(24.7,106.85) 24.7,105.82 25.82,104.7 UV4.T2 ; UV6.T2 25.83,88.95 24.71,90.07 v2(24.71,91.1)
  BOTTOM w0.122: UV1.D26 49.94,108.53 49.28,108.53 48.38,107.63 46.14,107.63 v1(42.58,104.07) 42.07,103.56 42.08,103.56 41.15,102.63 33.16,102.63 32.57,102.03 32.1,102.03 31.65,101.58 25.37,101.58 RV2447.1 24.57,100.83 v2(24.57,100.15)
FBA_CMD6: length 60.4
  TOP w0.102: UV7.R3 28.63,92.95 28.1,92.42 27.63,92.42 27.36,92.15 26.95,92.15 26.73,91.93 26.73,91.55 26.32,91.15 v2(26.32,91.02) ; v2(26.31,106.77) 26.31,106.9 26.72,107.3 26.72,107.68 26.94,107.9 27.35,107.9 27.61,108.17 28.09,108.17 28.62,108.7 UV5.R3
  IN3 w0.091: v2(26.31,106.77) 26.31,106.07 26.44,105.95 26.63,105.95 26.75,105.83 26.75,105.67 26.63,105.55 25.97,105.55 25.84,105.42 25.84,105.25 25.97,105.12 26.81,105.12 26.94,104.99 26.94,104.8 26.81,104.67 26.05,104.67 25.97,104.6 25.97,102.12 26.45,101.64 26.45,100.5 v2(26.38,100.42) 26.38,100.04 25.97,99.63 25.97,99.33 26.35,98.95 26.35,92.42 26.73,92.04 26.73,91.43 v2(26.32,91.02)
  BOTTOM w0.102: v2(26.31,106.77) 27.19,105.89 28.52,105.89 28.72,105.7 UV4.R3 ; UV6.R3 28.73,89.95 28.54,90.14 27.2,90.14 v2(26.32,91.02)
  BOTTOM w0.122: UV1.F25 50.97,106.44 50.51,106.9 50.09,106.9 49.9,107.09 49.29,107.09 49.03,106.83 46.41,106.83 41.45,101.88 34.95,101.88 34.36,101.28 32.42,101.28 31.96,100.82 v1(27.06,100.82) 26.78,100.82 v2(26.38,100.42)
FBA_CMD7: length 68.4
  TOP w0.102: v2(24.71,91.71) 24.71,92.14 25.55,92.98 26.63,92.98 27.84,94.18 28.3,94.18 UV7.R2 ; UV5.R2 28.29,109.93 27.82,109.93 26.62,108.73 25.54,108.73 24.7,107.89 v2(24.7,107.46)
  IN3 w0.091: v2(24.71,91.71) 24.7,91.72 24.7,95.93 24.13,96.5 v2(24.13,99.71) 23.74,100.1 23.74,102.94 24.24,103.45 24.24,107 v2(24.7,107.46)
  BOTTOM w0.102: UV6.R2 28.73,89.03 28.41,89.36 26.06,89.36 25.13,90.28 25.13,91.29 v2(24.71,91.71) ; UV4.R2 28.72,104.78 28.4,105.11 26.05,105.11 25.12,106.03 25.12,107.04 v2(24.7,107.46)
  BOTTOM w0.122: UV1.F26 50.2,106.44 49.81,106.83 49.37,106.83 49.14,106.6 48.46,106.6 48.32,106.46 46.57,106.46 v1(46.27,106.16) 41.61,101.5 35.11,101.5 34.52,100.91 32.57,100.91 32.08,100.41 29.87,100.41 29.35,99.89 26.1,99.89 25.92,99.71 v2(24.13,99.71)
FBA_CMD8: length 56
  TOP w0.102: UV7.P3 28.79,92.21 28.47,92.21 28.28,92.02 28.28,91.49 27.9,91.1 v2(27.9,91.07) ; UV5.P3 28.78,107.96 28.46,107.96 28.27,107.77 28.27,107.24 27.89,106.85 v2(27.89,106.82)
  IN1 w0.114: v2(27.96,99.42) 28.38,99.84 29.3,99.84 30.22,100.75 40.12,100.75 45.48,106.12 51.16,106.12 51.64,105.64 52.77,105.64 v2(53.17,106.04)
  IN3 w0.091: v2(27.9,91.07) 28.28,91.45 28.28,92.67 27.42,93.54 27.42,95.47 27.83,95.89 27.83,99.29 v2(27.96,99.42) 27.75,99.63 27.75,102.92 28.15,103.32 28.15,106.11 27.89,106.38 v2(27.89,106.82)
  BOTTOM w0.102: UV4.P3 29.52,105.76 28.98,106.3 28.41,106.3 v2(27.89,106.82) ; UV6.P3 29.53,90.01 28.99,90.55 28.42,90.55 v2(27.9,91.07)
  BOTTOM w0.122: UV1.F23 52.78,106.44 53.17,106.05 v2(53.17,106.04)
FBA_CMD9: length 52.1
  TOP w0.102: UV7.N3 29.87,92.49 29.87,91.58 29.47,91.18 v2(29.47,91.11) ; v2(29.46,106.86) 29.46,106.93 29.86,107.33 29.86,108.24 UV5.N3
  IN1 w0.114: v5(53.15,105.23) 52.72,104.8 50.35,104.8 49.82,105.33 45.67,105.33 40.4,100.07 31.08,100.07 v2(30.55,99.54)
  IN3 w0.091: v2(29.47,91.11) 29.88,91.52 29.88,92.22 28.36,93.75 28.36,95.25 28.85,95.74 28.94,95.74 29.41,96.21 29.41,97.34 30.55,98.48 v2(30.55,99.54) 30.55,100.4 29.17,101.78 29.17,102.96 29.55,103.34 29.55,106.77 v2(29.46,106.86)
  BOTTOM w0.102: UV6.N3 30.33,90.25 v2(29.47,91.11) ; UV4.N3 30.32,106 v2(29.46,106.86)
  BOTTOM w0.122: UV1.G22 53.57,105.64 53.16,105.23 v5(53.15,105.23)
FBA_CMD10: length 55.3
  TOP w0.102: v2(29.46,107.51) 29.46,107.44 29.08,107.06 29.08,106.45 29.86,105.68 29.86,105.04 UV5.P8 ; UV7.P8 29.87,89.29 29.87,89.93 29.09,90.7 29.09,91.31 29.47,91.69 v2(29.47,91.76)
  IN1 w0.114: v2(29.28,100.41) 29.97,101.1 39.98,101.1 45.36,106.48 51.28,106.48 51.71,106.05 v2(52.33,106.05)
  IN3 w0.091: v2(29.46,107.51) 29.08,107.13 29.08,104.88 28.76,104.56 28.76,101.72 29.28,101.2 v2(29.28,100.41) 29.4,100.29 29.4,99 29.58,98.82 29.58,97.98 28.99,97.4 28.99,96.29 28.89,96.19 28.89,96.08 28.15,95.35 28.15,93.66 29.47,92.34 v2(29.47,91.76)
  BOTTOM w0.102: v2(29.46,107.51) 29.86,107.91 29.86,109.16 UV4.P8 ; UV6.P8 29.87,93.41 29.87,92.16 v2(29.47,91.76)
  BOTTOM w0.122: v2(52.33,106.05) 52.73,105.65 UV1.G23
FBA_CMD11: length 52.1
  TOP w0.102: UV5.P7 28.87,106.15 28.75,106.15 28.29,106.61 28.29,106.97 28.67,107.35 v2(28.67,107.52) ; UV7.P7 28.88,90.4 28.76,90.4 28.31,90.86 28.31,91.22 28.69,91.6 v2(28.69,91.77)
  IN1 w0.114: v5(51.54,105.23) 51.01,105.76 45.61,105.76 40.26,100.41 30.38,100.41 29.39,99.42 v2(28.55,99.42)
  IN3 w0.091: v2(28.67,107.52) 28.27,107.11 28.27,106.45 28.36,106.36 28.36,103.22 28.07,102.93 28.07,99.89 28.55,99.42 v2(28.55,99.42) 28.16,99.03 28.16,95.93 27.62,95.39 27.62,93.62 28.69,92.56 v2(28.69,91.77)
  BOTTOM w0.102: UV4.P7 29.52,108.36 v2(28.67,107.52) ; v2(28.69,91.77) 29.53,92.61 UV6.P7
  BOTTOM w0.122: UV1.G24 51.93,105.61 51.55,105.23 v5(51.54,105.23)
FBA_CMD12: length 50.8
  TOP w0.102: UV7.M2 30.76,93.38 30.76,92.72 30.64,92.61 30.64,91.5 30.26,91.12 v2(30.26,91.05) ; v2(30.25,106.8) 30.25,106.87 30.63,107.25 30.63,108.36 30.75,108.47 30.75,109.13 UV5.M2
  IN3 w0.091: v2(30.25,106.8) 30.25,105.23 29.96,104.94 29.96,103.09 29.83,102.96 29.83,102.05 31.72,100.16 v2(31.72,99.52) 31.72,98.72 30.07,97.07 30.07,96.11 29.29,95.33 29.04,95.33 28.76,95.05 28.76,93.92 30.67,92.01 30.67,91.45 v2(30.26,91.05)
  BOTTOM w0.102: v2(30.25,106.8) 30.68,106.36 30.68,105.17 31.12,104.73 UV4.M2 ; v2(30.26,91.05) 30.69,90.61 30.69,89.42 31.13,88.98 UV6.M2
  BOTTOM w0.122: UV1.F27 49.45,106.36 48.54,106.36 48.26,106.08 46.73,106.08 41.77,101.12 35.27,101.12 34.63,100.49 v1(33.29,100.49) 32.69,100.49 v2(31.72,99.52)
FBA_CMD13: length 46.7
  TOP w0.102: UV5.L3 32.69,107.93 32.7,107.93 32.99,107.63 32.99,107.3 32.61,106.91 v2(32.61,106.76) ; v2(32.62,91.01) 33.02,91.4 33.02,92.05 32.12,92.95 UV7.L3
  IN3 w0.091: v2(32.62,91.01) 33.03,91.41 33.03,92.29 31.99,93.33 31.99,94.69 33.15,95.85 33.15,96.8 33.75,97.4 v2(33.75,99.66) 33.75,100.53 32.49,101.79 32.49,103.5 31.79,104.2 31.79,105.84 32.61,106.66 v2(32.61,106.76)
  BOTTOM w0.102: UV6.L3 31.93,89.91 32.62,90.6 v2(32.62,91.01) ; UV4.L3 31.92,106.07 v2(32.61,106.76)
  BOTTOM w0.122: UV1.G25 50.74,106.03 48.69,106.03 48.36,105.71 46.88,105.71 41.92,100.75 v1(36.21,100.75) 35.42,100.75 34.79,100.11 34.21,100.11 v2(33.75,99.66)
FBA_CMD14: length 44.6
  TOP w0.102: v2(31.84,91.71) 31.84,91.64 31.43,91.24 31.43,90.73 31.13,90.43 UV7.M7 ; UV5.M7 31.12,106.18 31.42,106.48 31.42,106.99 31.82,107.39 v2(31.82,107.46)
  IN3 w0.091: v2(31.82,107.46) 31.44,107.07 31.44,106.67 31.18,106.4 31.18,102.85 31.35,102.67 31.35,101.93 32.94,100.35 v2(32.94,99.65) 32.94,98.53 31.95,97.55 31.95,95.52 31.38,94.96 31.38,92.85 31.84,92.39 v2(31.84,91.71)
  BOTTOM w0.102: v2(31.84,91.71) 31.13,92.41 UV6.M7 ; v2(31.82,107.46) 31.12,108.16 UV4.M7
  BOTTOM w0.122: v2(32.94,99.65) 33.34,99.24 33.92,99.24 34.42,99.74 35.01,99.74 35.64,100.37 v1(38.43,100.37) 42.08,100.37 47,105.3 48.53,105.3 48.87,105.64 UV1.G27
FBA_CMD15: length 45.6
  TOP w0.102: v2(33.46,91.9) 32.73,92.63 UV7.K3 ; UV5.K3 32.72,108.38 v2(33.45,107.65)
  IN3 w0.091: v2(33.46,91.9) 33.46,92.15 32.2,93.41 32.2,94.59 33.5,95.9 33.5,96.69 34.2,97.38 34.2,97.64 34.48,97.91 v2(34.48,99.2) 34.48,100.3 32.82,101.95 32.82,103.45 31.99,104.28 31.99,105.46 33.06,106.53 33.06,107.25 v2(33.45,107.65)
  BOTTOM w0.102: UV4.K3 32.72,105.57 33.83,106.68 33.83,107.19 33.45,107.57 v2(33.45,107.65) ; v2(33.46,91.9) 33.46,91.82 33.84,91.44 33.84,90.93 32.73,89.82 UV6.K3
  BOTTOM w0.122: v2(34.48,99.2) 34.61,99.33 35.14,99.33 35.8,100 v1(40.91,100) 42.23,100 47.04,104.8 48.45,104.8 48.89,105.24 49.93,105.24 UV1.G26
FBA_CMD16: length 45.2
  TOP w0.102: v2(31.84,91.07) 32.22,91.45 32.22,92.02 31.58,92.66 31.58,93.23 31.93,93.58 UV7.L2
  IN1 w0.114: v2(52.32,101.92) 52.72,102.32 52.72,102.88 52.48,103.12 46.64,103.12 46.33,102.81 46.16,102.81 45.84,103.14 45.66,103.14 45.51,102.99 45.51,102.81 45.84,102.49 45.84,102.32 45.68,102.16 45.52,102.16 45.07,102.61 44.89,102.61 44.74,102.47 44.74,102.29 45.19,101.84 45.19,101.68 45.03,101.52 44.87,101.52 44.42,101.97 44.24,101.97 44.1,101.82 44.1,101.64 44.55,101.19 44.55,101.03 44.39,100.87 44.22,100.87 43.77,101.32 43.6,101.32 43.45,101.18 43.45,101 43.9,100.55 43.9,100.38 43.74,100.22 43.58,100.22 43.13,100.67 42.95,100.67 42.8,100.53 42.8,100.35 43.25,99.9 43.25,99.74 43.09,99.58 42.93,99.58 42.48,100.03 42.3,100.03 42.16,99.88 42.16,99.7 42.61,99.25 42.61,99.09 41.3,97.78 33.94,97.78 32.57,96.42 v2(32.36,96.42)
  IN3 w0.091: v2(31.84,91.07) 32.22,91.45 32.22,92.44 31.59,93.07 31.59,94.87 32.36,95.64 v2(32.36,96.42)
  BOTTOM w0.102: UV6.L2 31.93,89.07 31.52,89.48 31.52,90.75 v2(31.84,91.07)
  BOTTOM w0.122: v2(52.32,101.92) 52.32,101.89 51.93,101.5 UV1.M24
FBA_CMD18: length 46.6
  TOP w0.102: UV7.K1 32.41,94.23 32.41,93.62 32.6,93.43 32.9,93.43 33.12,93.21 33.12,92.8 33.86,92.06 33.86,91.67 v2(33.45,91.26)
  IN1 w0.114: v2(33.92,96.49) 34.87,97.44 41.44,97.44 44.62,100.62 44.78,100.62 45.36,100.05 45.52,100.05 45.68,100.21 45.68,100.37 45.11,100.95 45.11,101.11 45.27,101.27 45.43,101.27 46.01,100.69 46.17,100.69 46.33,100.85 46.33,101.02 45.75,101.59 45.75,101.75 45.92,101.92 46.08,101.92 46.65,101.34 46.82,101.34 46.98,101.5 46.98,101.66 46.4,102.24 46.4,102.4 46.7,102.7 47.01,102.7 47.13,102.59 47.13,102.36 47.24,102.24 47.47,102.24 47.58,102.36 47.58,102.59 47.7,102.7 49.18,102.7 49.3,102.59 49.3,102.24 49.43,102.12 49.63,102.12 49.76,102.24 49.76,102.77 49.88,102.9 50.15,102.9 50.27,102.77 50.27,102.29 50.44,102.12 50.81,102.12 50.88,102.19 51.44,102.74 v5(51.53,102.74)
  IN3 w0.091: v2(33.45,91.26) 33.52,91.26 33.89,91.63 33.89,92 32.55,93.35 32.55,94.64 33.92,96.01 v2(33.92,96.49)
  BOTTOM w0.102: v2(33.45,91.26) 33.45,90.93 32.41,89.88 32.41,88.47 UV6.K1 32.73,87.82
  BOTTOM w0.122: RV2439.1 32.68,85.66 v1(32.68,86.17) 32.73,86.22 32.73,87.82 ; UV1.K24 51.93,103.14 v5(51.53,102.74)
FBA_CMD19: length 51.4
  TOP w0.102: UV7.K9 32.67,88.21 32.67,88.56 32.41,88.82 32.41,89.94 33.06,90.59 33.29,90.59 33.59,90.89 33.64,90.89 33.85,91.11 v2(34.29,91.11)
  IN1 w0.114: v5(52.31,102.74) 52.31,102.47 52.16,102.32 51.32,102.32 50.9,101.9 47.86,101.9 45.44,99.48 45.28,99.48 44.77,99.99 44.6,99.99 44.44,99.83 44.44,99.67 44.96,99.15 44.96,98.99 44.8,98.84 44.62,98.84 44.06,99.41 43.89,99.41 43.73,99.25 43.73,99.08 44.3,98.52 44.3,98.34 44.16,98.19 43.98,98.19 43.41,98.76 43.25,98.76 43.09,98.6 43.09,98.44 43.65,97.87 43.65,97.69 43.51,97.55 43.33,97.55 42.76,98.11 42.6,98.11 42.44,97.95 42.44,97.79 42.81,97.42 42.81,97.24 42.66,97.1 42.48,97.1 42.12,97.47 41.95,97.47 41.59,97.1 36.93,97.1 36.79,96.96 v5(36.79,96.74) ; v2(34.29,91.11) 33.86,91.11 33.62,90.87 33.13,90.87 32.17,89.9 32.17,86.92 v2(33.16,85.93)
  IN3 w0.091: v2(34.29,91.11) 34.31,91.11 34.68,91.48 34.68,92.19 34.4,92.47 34.04,92.47 33.54,92.97 33.54,94.3 33.86,94.63 34.38,94.63 34.71,94.95 34.71,95.54 35.32,96.15 36.28,96.15 36.79,96.66 v5(36.79,96.74)
  BOTTOM w0.102: v2(34.29,91.11) 34.29,91.29 33.88,91.69 33.88,92.03 33.63,92.29 32.93,92.29 32.41,92.82 32.41,94.23 UV6.K9
  BOTTOM w0.122: v5(52.31,102.74) UV1.K23 ; v2(33.16,85.93) RV2437.1
FBA_CMD20: length 56.4
  TOP w0.102: UV7.T3 27.75,92.95 27.15,92.35 26.33,92.35 25.93,91.96 25.93,91.58 25.54,91.18 v2(25.54,91.02) ; UV5.T3 27.74,108.7 27.14,108.1 26.31,108.1 25.92,107.71 25.92,107.33 25.53,106.93 v2(25.53,106.77)
  IN3 w0.091: v2(25.54,91.02) 25.94,91.43 25.94,92.11 25.74,92.32 25.74,93.16 25.69,93.21 25.69,98.47 v2(25.54,98.62) 25.54,98.83 25.31,99.06 25.31,106.27 25.53,106.49 v2(25.53,106.77)
  BOTTOM w0.102: v2(25.53,106.77) 26.8,105.5 UV4.T3 ; UV6.T3 26.81,89.75 v2(25.54,91.02)
  BOTTOM w0.122: v2(25.54,98.62) v1(26.04,98.12) 26.49,97.68 31.79,97.68 33.37,96.1 36.74,96.1 37.54,96.91 42.87,96.91 47.44,101.48 UV1.M27
FBA_CMD21: length 61.4
  TOP w0.102: v2(25.53,107.49) 25.53,107.38 25.08,106.93 25.08,106.58 25.82,105.84 26.78,105.84 UV5.T8 ; v2(25.54,91.74) 25.54,91.63 25.09,91.18 25.09,90.83 25.84,90.09 26.79,90.09 UV7.T8
  IN3 w0.091: v2(25.53,107.49) 25.53,107.37 25.14,106.99 25.14,106.67 24.98,106.5 24.98,99.14 24.93,99.09 v2(24.93,98.51) 25.36,98.08 25.36,93.06 25.54,92.88 v2(25.54,91.74)
  BOTTOM w0.102: UV4.T8 27.53,109.5 v2(25.53,107.49) ; UV6.T8 27.54,93.75 v2(25.54,91.74)
  BOTTOM w0.122: UV1.M26 49.94,101.09 47.58,101.09 43.03,96.53 37.7,96.53 36.88,95.71 32.48,95.71 31.63,96.56 31.63,97.05 31.38,97.3 v1(29.35,97.3) 26.14,97.3 24.93,98.5 v2(24.93,98.51)
FBA_CMD22: length 58.6
  TOP w0.102: UV5.R8 29.09,105.08 29.09,105.64 28.78,105.95 28.66,105.95 28.43,106.19 27.95,106.19 27.51,106.63 27.51,106.98 27.89,107.36 v2(27.89,107.49) ; v2(27.9,91.74) 27.9,91.61 27.52,91.23 27.52,90.88 27.96,90.44 28.44,90.44 28.67,90.2 28.79,90.2 29.11,89.89 29.11,89.33 UV7.R8
  IN3 w0.091: v2(27.9,91.74) 27.95,91.74 28.08,91.87 28.08,92.49 27.97,92.6 27.83,92.6 27.72,92.49 27.72,92.35 27.6,92.23 27.46,92.23 27.21,92.47 27.21,92.66 27.34,92.79 27.5,92.79 27.61,92.9 27.61,93.05 27.5,93.16 27.34,93.16 27.21,93.29 27.21,95.67 27.5,95.96 27.5,98.05 v2(27.43,98.12) 27.43,98.13 27.43,102.96 27.32,103.07 27.32,103.65 27.7,104.03 27.7,106.12 27.51,106.31 27.51,107.11 v2(27.89,107.49)
  BOTTOM w0.102: v2(27.9,91.74) 28.12,91.74 28.66,92.28 28.79,92.28 29.11,92.6 29.11,93.37 UV6.R8 ; UV4.R8 29.09,109.13 29.09,108.35 28.78,108.03 28.64,108.03 28.11,107.49 v2(27.89,107.49)
  BOTTOM w0.122: v2(27.43,98.12) 27.46,98.09 v1(31.63,98.09) 31.92,98.09 33.01,97 36.36,97 36.65,97.28 42.71,97.28 47.33,101.9 50.71,101.9 UV1.M25
FBA_CMD23: length 55.5
  TOP w0.102: v2(27.11,91.74) 27.11,91.61 26.73,91.23 26.73,90.91 27.01,90.63 27.49,90.63 27.88,90.23 28.25,90.23 UV7.R7 ; v2(27.1,107.49) 27.1,107.36 26.72,106.98 26.72,106.66 27,106.38 27.47,106.38 27.87,105.98 28.24,105.98 UV5.R7
  IN3 w0.091: v2(27.11,91.74) 27.11,91.94 26.68,92.37 26.68,94.27 26.68,94.27 26.68,99.2 v2(26.41,99.46) 26.78,99.83 26.78,101.76 26.3,102.25 26.3,103.52 27.14,104.36 27.14,105.86 26.71,106.29 26.71,107.1 v2(27.1,107.49)
  BOTTOM w0.102: UV6.R7 27.99,92.21 27.58,92.21 v2(27.11,91.74) ; v2(27.1,107.49) 27.57,107.96 27.98,107.96 UV4.R7
  BOTTOM w0.122: v2(26.41,99.46) 26.9,98.97 30.66,98.97 30.9,98.73 31.81,98.73 33.16,97.37 36.21,97.37 36.49,97.66 v1(41.35,97.66) 42.56,97.66 47.65,102.75 49.92,102.75 UV1.K26
FBA_CMD24: length 62.1
  TOP w0.102: v2(27.1,106.82) 27.1,106.92 27.48,107.3 27.48,107.75 27.7,107.96 28.17,107.96 28.38,108.17 28.7,108.17 29.16,108.63 29.16,109.14 UV5.P2 ; v2(27.11,91.07) 27.11,91.17 27.49,91.55 27.49,92 27.71,92.21 28.18,92.21 28.39,92.42 28.71,92.42 29.17,92.88 29.17,93.39 UV7.P2
  IN1 w0.114: v5(53.15,103.57) 52.75,103.97 52.14,103.97 51.72,104.39 47.77,104.39 47.76,104.4 45.22,104.4 40.55,99.72 34.4,99.72 33.92,99.24 33.17,99.24 32.7,98.77 30.73,98.77 30.53,98.97 27.49,98.97 v2(27.01,99.46)
  IN3 w0.091: v2(27.11,91.07) 27.49,91.45 27.49,91.9 27.01,92.38 v2(27.01,99.46) 27.11,99.56 27.11,101.89 26.63,102.38 26.63,103.34 27.44,104.15 27.44,106 27.1,106.34 v2(27.1,106.82)
  BOTTOM w0.102: v2(27.1,106.82) 27.82,106.1 28.66,106.1 29.09,105.67 29.09,105.23 29.52,104.81 UV4.P2 ; v2(27.11,91.07) 27.84,90.35 28.68,90.35 29.11,89.92 29.11,89.37 UV6.P2
  BOTTOM w0.122: UV1.K22 53.15,103.58 v5(53.15,103.57)
FBA_CMD25: length 57.4
  TOP w0.102: UV5.N2 29.92,109.1 29.92,108.59 29.08,107.75 29.08,107.35 28.67,106.94 v2(28.67,106.78) ; v2(28.69,91.03) 28.69,91.19 29.09,91.6 29.09,92 29.93,92.84 29.93,93.35 UV7.N2
  IN1 w0.114: v5(52.33,103.56) 52.15,103.56 51.72,103.99 45.29,103.99 41.1,99.79 41.1,99.15 40.73,98.79 36.05,98.79 35.89,98.95 34.82,98.95 34.62,98.76 33.17,98.76 32.54,98.12 28.95,98.12 v2(28.57,98.5)
  IN3 w0.091: v2(28.67,106.78) 28.56,106.67 28.56,103.13 28.43,103 28.43,101.51 28.88,101.07 28.88,100.11 28.97,100.01 28.97,99.1 28.57,98.7 v2(28.57,98.5) 28.57,96.28 28.49,96.2 28.49,95.97 27.92,95.4 27.92,93.61 29.07,92.46 29.07,91.41 v2(28.69,91.03)
  BOTTOM w0.102: UV4.N2 30.32,104.71 29.92,105.11 29.92,105.87 29.29,106.5 28.95,106.5 v2(28.67,106.78) ; v2(28.69,91.03) 28.97,90.75 29.3,90.75 29.93,90.12 29.93,89.36 30.33,88.96 UV6.N2
  BOTTOM w0.122: v5(52.33,103.56) UV1.J23
FBA_CMD26: length 46.9
  TOP w0.102: v2(31.05,91.08) 31.05,91.17 31.46,91.58 31.46,92.15 31.13,92.48 UV7.M3 ; v2(31.04,106.83) 31.04,106.92 31.44,107.33 31.44,107.9 31.12,108.23 UV5.M3
  IN3 w0.091: v2(31.04,106.83) 30.87,106.67 30.87,104.96 30.36,104.45 30.36,103.26 30.55,103.07 30.55,102.26 32.53,100.29 v2(32.53,99.18) 32.53,98.59 31.57,97.64 31.57,95.5 30.36,94.29 30.36,93.58 31.46,92.48 31.46,91.49 v2(31.05,91.08)
  BOTTOM w0.102: UV4.M3 31.12,106.75 v2(31.04,106.83) ; v2(31.05,91.08) 31.13,91 UV6.M3
  BOTTOM w0.122: v2(32.53,99.18) 32.99,98.73 v1(34.05,98.73) 34.59,98.73 34.82,98.96 35.29,98.96 35.95,99.62 42.39,99.62 47.18,104.41 50.7,104.41 51.13,103.98 UV1.J25
FBA_CMD27: length 58.1
  TOP w0.102: UV7.N8 30.33,89.06 30.69,89.42 30.69,90.56 30.64,90.62 30.64,91.22 31.05,91.62 v2(31.05,91.72) ; UV5.N8 30.32,104.81 30.68,105.17 30.68,106.31 30.63,106.37 30.63,106.97 31.04,107.37 v2(31.04,107.47)
  IN1 w0.114: v2(51.53,103.56) 51.45,103.48 45.27,103.48 41.44,99.65 41.44,99.01 40.56,98.13 33.8,98.13 33.45,97.78 32.01,97.78 v2(31.09,96.85)
  IN3 w0.091: v2(31.05,91.72) 31.05,91.92 30.9,92.07 30.9,92.21 31.08,92.39 31.08,92.53 30.93,92.68 30.79,92.68 30.61,92.5 30.47,92.5 30.32,92.64 30.32,92.79 30.5,92.97 30.5,93.11 30.36,93.25 30.21,93.25 30.04,93.08 29.89,93.08 29.58,93.39 29.58,95.14 29.91,95.47 30.06,95.47 30.57,94.96 30.74,94.96 30.86,95.08 30.86,95.24 30.34,95.76 30.34,95.91 30.49,96.05 30.63,96.05 31.08,95.6 31.25,95.6 31.37,95.72 31.37,95.89 31.1,96.15 30.92,96.34 30.92,96.48 31.09,96.65 v2(31.09,96.85) 31.09,97.62 32.12,98.66 32.12,100.22 30.16,102.19 30.16,104.59 30.66,105.08 30.66,107.09 v2(31.04,107.47)
  BOTTOM w0.102: v2(31.05,91.72) 30.69,92.07 30.69,93.39 UV6.N8 ; v2(31.04,107.47) 30.68,107.82 30.68,109.14 UV4.N8
  BOTTOM w0.122: v2(51.53,103.56) UV1.J24
FBA_CMD28: length 47.2
  TOP w0.102: UV5.N7 30.32,105.98 29.86,106.44 29.86,106.95 30.25,107.34 v2(30.25,107.48) ; v2(30.26,91.73) 30.26,91.59 29.87,91.2 29.87,90.69 30.33,90.23 UV7.N7
  IN3 w0.091: v2(30.25,107.48) 29.84,107.07 29.84,105.92 29.75,105.83 29.75,103.24 29.5,102.99 29.5,101.91 31.13,100.28 v2(31.13,99.54) 31.13,98.6 29.74,97.21 29.74,96.07 29.21,95.54 28.95,95.54 28.56,95.15 28.56,93.83 30.26,92.13 v2(30.26,91.73)
  BOTTOM w0.102: UV6.N7 30.33,91.8 v2(30.26,91.73) ; UV4.N7 30.32,107.55 v2(30.25,107.48)
  BOTTOM w0.122: UV1.K27 47.53,103.16 v1(44.68,100.32) 42.4,98.03 36.34,98.03 36.05,97.75 33.32,97.75 31.96,99.1 31.55,99.1 31.13,99.51 v2(31.13,99.54)
FBA_CMD29: length 47.1
  TOP w0.102: v2(32.62,91.7) 32.62,91.56 32.23,91.17 32.23,90.05 UV7.L7 ; UV5.L7 31.92,106.15 32.22,106.45 32.22,106.92 32.61,107.31 v2(32.61,107.45)
  IN3 w0.091: v2(32.62,91.7) 32.62,92.41 31.79,93.24 31.79,94.79 32.8,95.8 32.8,96.66 32.67,96.79 32.53,96.79 32.4,96.92 32.4,97.13 32.53,97.26 33.13,97.26 33.14,97.26 33.26,97.38 33.26,97.59 33.14,97.72 32.98,97.72 32.85,97.84 32.85,97.98 33.18,98.31 v2(33.34,98.31) 33.34,100.44 32.16,101.62 32.16,103.54 31.58,104.11 31.58,106.04 32.22,106.67 32.22,107.18 32.49,107.45 v2(32.61,107.45)
  BOTTOM w0.102: UV6.L7 31.93,92.4 v2(32.62,91.7) ; UV4.L7 31.92,108.15 v2(32.61,107.45)
  BOTTOM w0.122: UV1.K25 50.72,103.57 47.4,103.57 42.25,98.41 v1(37.16,98.41) 36.18,98.41 35.89,98.12 33.53,98.12 v2(33.34,98.31)
FBA_CMD30: length 49.8
  TOP w0.102: UV7.J3 33.7,92.95 33.83,92.82 33.83,92.43 33.96,92.31 34.2,92.31 34.27,92.38 34.27,92.46 34.39,92.59 34.59,92.59 34.72,92.46 34.72,91.82 34.59,91.69 34.44,91.69 v2(34.27,91.86) ; UV5.J3 33.69,108.7 33.82,108.57 33.82,108.18 33.94,108.06 34.18,108.06 34.25,108.13 34.25,108.21 34.38,108.34 34.58,108.34 34.71,108.21 34.71,107.57 34.58,107.44 34.43,107.44 v2(34.26,107.61)
  IN3 w0.091: v2(34.27,91.86) 34.27,91.94 32.75,93.47 32.75,94.45 34.35,96.05 34.35,96.74 35.05,97.44 v2(35.05,98.54) 35.05,100.66 33.72,102 33.72,102.79 33.32,103.19 33.32,103.53 32.77,104.09 32.77,105.63 33.89,106.75 33.89,107.43 34.07,107.61 v2(34.26,107.61)
  BOTTOM w0.102: v2(34.27,91.86) 34.68,91.45 34.68,90.59 34.58,90.49 33.78,90.49 33.43,90.14 33.43,89.85 UV6.J3 ; UV4.J3 33.52,106.03 33.73,106.24 34.57,106.24 34.67,106.34 34.67,107.2 v2(34.26,107.61)
  BOTTOM w0.122: v2(35.05,98.54) 35.7,98.54 35.94,98.79 38.21,98.79 38.33,98.91 38.33,99.12 38.45,99.24 38.7,99.24 38.82,99.12 38.82,98.91 38.94,98.79 40.98,98.79 41.1,98.91 41.1,99.12 41.22,99.24 41.47,99.24 41.59,99.12 41.59,98.91 41.72,98.79 41.96,98.79 42.09,98.91 42.09,99.09 42.21,99.21 42.52,99.21 v1(46.28,102.97) 47.26,103.96 UV1.J27
FBA_D0: length 31
  IN3 w0.114: v5(57.33,107.75) 57.34,107.76 57.34,110.47 54.53,113.29 49.36,113.29 45.66,109.59 44.04,109.59 43.92,109.71 43.92,110.2 43.8,110.33 43.56,110.33 43.44,110.2 43.44,109.71 43.31,109.59 43.07,109.59 42.95,109.71 42.95,110.2 42.83,110.33 41.26,110.33 40.45,109.52 38.44,109.52 37.6,110.35 36,110.35 v2(35.57,109.92)
  BOTTOM w0.102: UV4.F8 35.92,109.57 v2(35.57,109.92)
  BOTTOM w0.122: UV1.E18 56.91,107.34 57.32,107.75 v5(57.33,107.75)
FBA_D1: length 32.5
  IN3 w0.114: v5(57.34,106.08) 56.27,107.15 56.27,109.49 54.81,110.95 54.81,111.48 53.72,112.57 49.63,112.57 45.95,108.89 45.15,108.89 45.03,108.77 45.03,108.19 44.9,108.06 44.66,108.06 44.54,108.19 44.54,108.77 44.42,108.89 44.17,108.89 44.05,108.77 44.05,108.19 43.92,108.06 43.69,108.06 43.56,108.19 43.56,108.77 43.44,108.89 43.2,108.89 43.07,108.77 43.07,108.19 42.95,108.06 42.71,108.06 42.59,108.19 42.59,108.77 42.47,108.89 37.65,108.89 37.44,108.68 36.69,108.68 v2(36.27,109.09)
  BOTTOM w0.102: UV4.F7 35.92,108.75 v2(36.27,109.09)
  BOTTOM w0.122: v5(57.34,106.08) 56.91,106.51 UV1.F18
FBA_D2: length 32.5
  IN3 w0.114: v5(58.17,106.95) 58.58,107.37 58.58,111.22 55.97,113.83 49.41,113.83 46.85,111.28 35.54,111.28 34.68,110.41 v2(34.68,109.93)
  BOTTOM w0.102: UV4.H8 34.32,109.55 34.68,109.91 v2(34.68,109.93) ; v5(58.17,106.95) 58.56,107.34 58.57,107.34
  BOTTOM w0.122: UV1.E16 58.57,107.34
FBA_D3: length 32.8
  IN3 w0.114: v2(33.95,109.09) 34.34,109.49 37.7,109.49 37.95,109.24 40.89,109.24 41.01,109.36 41.01,109.76 41.14,109.89 41.37,109.89 41.5,109.76 41.5,109.36 41.62,109.24 41.87,109.24 41.99,109.36 41.99,109.85 42.11,109.98 42.35,109.98 42.48,109.85 42.48,109.36 42.6,109.24 45.8,109.24 49.49,112.93 54.3,112.93 56.68,110.55 56.68,107.56 v5(57.33,106.91)
  BOTTOM w0.102: UV4.H7 34.32,108.72 v2(33.95,109.09)
  BOTTOM w0.122: UV1.F17 57.75,106.5 57.35,106.91 v5(57.33,106.91)
FBA_D4: length 28.8
  IN3 w0.114: v2(37.15,105.09) 37.74,105.09 38.13,105.48 38.75,105.48 38.95,105.69 38.95,106.63 39.08,106.76 39.73,106.76 39.86,106.63 39.86,105.7 39.98,105.58 40.22,105.58 40.34,105.7 40.34,106.67 40.47,106.8 40.7,106.8 40.83,106.67 40.83,105.7 40.96,105.58 41.19,105.58 41.32,105.7 41.32,106.55 41.44,106.67 41.68,106.67 41.81,106.55 41.81,105.75 41.93,105.63 42.17,105.63 42.29,105.75 42.29,106.55 42.42,106.67 46.2,106.67 49.51,109.97 49.51,110.39 49.69,110.58 52.69,110.58 54.73,108.54 v5(54.77,108.54)
  BOTTOM w0.102: v2(37.15,105.09) 36.74,105.5 UV4.E3
  BOTTOM w0.122: v5(54.77,108.54) 54.87,108.54 UV1.D20
FBA_D5: length 27.8
  IN3 w0.114: v5(54.8,107.79) 54.79,107.79 53.63,108.95 49.18,108.95 46.55,106.32 45.89,106.32 45.76,106.2 45.76,105.47 45.64,105.34 45.4,105.34 45.28,105.47 45.28,106.2 45.15,106.32 44.91,106.32 44.79,106.2 44.79,105.39 44.66,105.26 44.43,105.26 44.3,105.39 44.3,106.2 44.18,106.32 43.86,106.32 43.74,106.2 43.74,105.38 43.62,105.26 43.38,105.26 43.25,105.38 43.25,106.2 43.13,106.32 42.89,106.32 42.77,106.2 42.77,105.38 42.64,105.26 38.22,105.26 37.65,104.69 36.74,104.69 v2(36.35,104.29)
  BOTTOM w0.102: v2(36.35,104.29) 35.94,104.7 UV4.F2 ; 54.45,108.14 v5(54.8,107.79)
  BOTTOM w0.136: UV1.D21 54.45,108.14
FBA_D6: length 31
  IN3 w0.114: v5(55.69,106.1) 55.25,106.54 54.71,106.54 53.98,107.27 49.41,107.27 45.94,103.81 45.77,103.81 45.2,104.39 45.02,104.39 44.85,104.21 44.85,104.04 45.43,103.46 45.43,103.29 45.14,103 44.39,103 44.27,103.12 44.27,104.41 44.15,104.54 43.9,104.54 43.78,104.41 43.78,103.12 43.66,103 36.09,103 35.82,103.26 35.82,103.47 35.09,104.21 35.09,104.56 34.94,104.71 34.36,104.71 v2(33.96,105.11)
  BOTTOM w0.102: UV4.H3 34.32,105.38 34.05,105.11 v2(33.96,105.11)
  BOTTOM w0.122: UV1.F20 55.29,106.5 v5(55.69,106.1)
FBA_D7: length 29.7
  IN3 w0.114: v2(35.56,104.29) 35.95,103.9 38.07,103.9 39.08,104.91 40.75,104.91 40.87,104.79 40.87,103.55 40.99,103.43 41.24,103.43 41.36,103.55 41.36,104.79 41.48,104.91 41.72,104.91 41.85,104.79 41.85,103.55 41.97,103.43 42.21,103.43 42.33,103.55 42.33,104.79 42.46,104.91 42.7,104.91 42.82,104.79 42.82,103.55 42.94,103.43 43.19,103.43 43.31,103.55 43.31,104.79 43.43,104.91 45.7,104.91 48.9,108.12 53.65,108.12 v5(54.03,107.74)
  BOTTOM w0.102: v2(35.56,104.29) 35.15,104.7 UV4.G2
  BOTTOM w0.122: UV1.E21 v5(54.03,107.74)
FBA_D8: length 37.1
  TOP w0.102: UV5.F7 36.05,105.5 v2(36.59,106.03)
  IN1 w0.114: v5(59.81,106.93) 59.21,106.93 58.97,107.17 58.97,107.69 58.54,108.12 58.02,108.12 55.88,110.25 55.88,111.14 54.77,112.25 48.85,112.25 48.73,112.14 48.73,111.43 48.61,111.3 48.4,111.3 48.28,111.43 48.28,112.14 48.16,112.25 47.93,112.25 47.81,112.14 47.81,111.31 47.7,111.2 47.47,111.2 47.36,111.31 47.36,112.14 47.24,112.25 47.01,112.25 46.9,112.14 46.9,111.31 46.78,111.2 46.56,111.2 46.44,111.31 46.44,112.14 46.33,112.25 46.1,112.25 45.98,112.14 45.98,111.31 45.87,111.2 42.82,111.2 39.91,108.29 39.91,107.56 37.86,105.5 36.96,105.5 36.59,105.87 v2(36.59,106.03)
  BOTTOM w0.122: v5(59.81,106.93) 59.4,107.34 UV1.E15
FBA_D9: length 36.8
  TOP w0.102: UV5.H7 34.32,105.49 v2(34.72,105.09)
  IN1 w0.114: v5(58.99,108.52) 58.99,108.78 58.53,109.24 58.53,110.78 56.37,112.94 43.17,112.94 43.06,112.83 43.06,112.43 42.93,112.31 42.73,112.31 42.6,112.43 42.6,112.83 42.49,112.94 42.26,112.94 42.14,112.83 42.14,112.07 42.03,111.95 41.8,111.95 41.68,112.07 41.68,112.83 41.57,112.94 40.89,112.94 40.75,112.79 40.75,111.9 40.64,111.8 40.07,111.8 39,110.73 39,109.59 38.63,109.23 38.63,107.36 37.78,106.5 36.4,106.5 36.01,106.12 36.01,105.61 35.89,105.49 35.13,105.49 34.73,105.09 v2(34.72,105.09)
  BOTTOM w0.122: UV1.D15 59.36,108.14 58.99,108.5 v5(58.99,108.52)
FBA_D10: length 38
  TOP w0.102: UV5.F8 35.95,104.7 v2(36.35,105.09)
  IN1 w0.114: v5(58.98,106.1) 58.98,106.75 58.4,107.33 57.92,107.33 57.73,107.52 57.73,108 54.2,111.53 49.94,111.53 49.24,110.83 46.81,110.83 46.7,110.72 46.7,109.91 46.59,109.79 46.36,109.79 46.24,109.91 46.24,110.72 46.13,110.83 45.91,110.83 45.8,110.72 45.8,109.88 45.68,109.77 45.45,109.77 45.34,109.88 45.34,110.72 45.23,110.83 45,110.83 44.88,110.72 44.88,109.88 44.77,109.77 44.54,109.77 44.43,109.88 44.43,110.72 44.31,110.83 44.08,110.83 43.97,110.72 43.97,109.88 43.85,109.77 43.63,109.77 43.51,109.88 43.51,110.72 43.4,110.83 43.17,110.83 43.05,110.72 43.05,109.88 42.94,109.77 41.87,109.77 40.23,108.13 40.23,107.55 37.37,104.69 36.75,104.69 v2(36.35,105.09)
  BOTTOM w0.122: UV1.F15 59.38,106.5 v5(58.98,106.1)
FBA_D11: length 39.2
  TOP w0.102: UV5.H8 34.32,104.63 34.65,104.31 v2(34.66,104.31)
  IN1 w0.114: v2(34.66,104.31) 34.77,104.31 35.18,103.9 38.07,103.9 38.35,104.18 38.35,104.45 41.26,107.35 41.26,107.52 40.84,107.94 40.84,108.12 40.98,108.26 41.16,108.26 41.53,107.9 41.58,107.84 41.75,107.84 41.91,108 41.91,108.16 41.53,108.54 41.51,108.56 41.51,108.74 41.66,108.88 41.84,108.88 42.23,108.49 42.39,108.49 42.55,108.65 42.55,108.81 42.26,109.1 42.26,109.28 42.4,109.42 42.58,109.42 42.88,109.13 43.04,109.13 43.33,109.42 46.7,109.42 47.04,109.77 47.04,110.36 47.17,110.49 47.51,110.49 47.64,110.36 47.64,109.73 47.77,109.61 47.97,109.61 48.1,109.73 48.1,110.38 48.21,110.49 48.81,110.49 48.83,110.51 53.77,110.51 54.61,109.67 55.75,109.67 56.72,108.71 56.72,107.57 56.95,107.34 57.44,107.34 57.75,107.03 57.75,105.91 57.99,105.68 60.23,105.68 v5(60.65,106.1)
  BOTTOM w0.122: v5(60.65,106.1) 61.05,106.5 UV1.F13
FBA_D12: length 36.9
  TOP w0.102: v2(37.29,107.58) 37.25,107.58 36.72,108.11 UV5.E3
  IN1 w0.114: v5(60.65,109.34) 60.48,109.34 59.8,110.03 59.8,110.41 59.38,110.82 59.38,111.13 58.66,111.85 58.66,112.02 59.02,112.38 59.02,112.56 58.88,112.71 58.7,112.71 58.33,112.34 58.17,112.34 58.01,112.5 58.01,112.66 58.19,112.84 58.19,113.02 58.04,113.16 57.87,113.16 57.69,112.99 57.53,112.99 57.36,113.15 57.36,113.31 57.52,113.46 57.52,113.64 57.37,113.79 57.19,113.79 57.04,113.63 56.88,113.63 56.73,113.79 43.38,113.79 43.26,113.9 43.26,114.14 43.13,114.27 42.93,114.27 42.8,114.14 42.8,113.9 42.69,113.79 42.46,113.79 42.35,113.9 42.35,114.14 42.22,114.27 42.02,114.27 41.89,114.14 41.89,113.9 41.78,113.79 41.55,113.79 41.43,113.9 41.43,114.14 41.31,114.27 41.1,114.27 40.98,114.14 40.98,113.9 40.86,113.79 40.54,113.79 39.09,112.34 38.33,112.34 37.58,111.58 37.58,107.88 v2(37.29,107.58)
  BOTTOM w0.122: UV1.C13 61.05,108.94 v5(60.65,109.34)
FBA_D13: length 36.8
  TOP w0.102: v2(36.35,109.89) 35.95,109.5 UV5.F2
  IN1 w0.114: v2(36.35,109.89) 36.77,110.32 36.77,111.26 38.19,112.68 38.95,112.68 40.88,114.61 43.6,114.61 43.72,114.5 43.72,114.24 43.83,114.13 44.06,114.13 44.18,114.24 44.18,114.5 44.29,114.61 44.52,114.61 44.63,114.5 44.63,114.24 44.75,114.13 44.98,114.13 45.09,114.24 45.09,114.5 45.2,114.61 45.43,114.61 45.55,114.5 45.55,114.24 45.66,114.13 45.89,114.13 46,114.24 46,114.5 46.12,114.61 46.35,114.61 46.46,114.5 46.46,114.24 46.58,114.13 46.81,114.13 46.92,114.24 46.92,114.5 47.03,114.61 47.26,114.61 47.38,114.5 47.38,114.24 47.49,114.13 47.72,114.13 47.83,114.24 47.83,114.5 47.95,114.61 48.18,114.61 48.29,114.5 48.29,114.26 48.42,114.13 48.67,114.13 48.8,114.26 48.8,114.49 48.93,114.61 49.13,114.61 49.26,114.49 49.26,114.26 49.38,114.13 49.59,114.13 49.71,114.26 49.71,114.47 49.85,114.61 50.03,114.61 50.17,114.47 50.17,114.26 50.3,114.13 50.5,114.13 50.63,114.26 50.63,114.49 50.75,114.61 50.96,114.61 51.08,114.49 51.08,114.26 51.21,114.13 58.62,114.13 59.72,113.03 59.72,110.99 59.96,110.75 60.33,110.75 60.75,110.33 v5(60.75,110.13)
  BOTTOM w0.122: v5(60.75,110.13) 60.75,110.04 61.05,109.74 UV1.B13
FBA_D14: length 39.5
  TOP w0.102: UV5.H3 34.61,108.7 v2(35.14,108.17)
  IN1 w0.114: v5(60.65,107.74) 61.92,109.01 61.92,111.8 58.67,115.05 54.6,115.05 54.35,115.3 40.6,115.3 38.67,113.37 37.17,113.37 36.49,112.68 36.49,112.22 34.87,110.6 34.87,110.44 35.14,110.17 v2(35.14,108.17)
  BOTTOM w0.122: UV1.E13 61.05,107.34 v5(60.65,107.74)
FBA_D15: length 37.9
  TOP w0.102: UV5.G2 35.14,109.5 v2(35.55,109.09)
  IN1 w0.114: v5(60.65,108.54) 61.44,109.33 61.44,111.79 58.74,114.49 54.4,114.49 54.29,114.61 54.29,114.84 54.17,114.96 53.94,114.96 53.83,114.84 53.83,114.6 53.7,114.47 53.5,114.47 53.37,114.6 53.37,114.84 53.26,114.96 53.03,114.96 52.91,114.84 52.91,114.6 52.79,114.47 52.58,114.47 52.46,114.6 52.46,114.84 52.34,114.96 52.11,114.96 52,114.84 52,114.6 51.87,114.47 51.67,114.47 51.54,114.6 51.54,114.84 51.43,114.96 40.74,114.96 38.81,113.02 37.31,113.02 36.83,112.54 36.83,111.84 35.96,110.96 35.96,109.49 35.56,109.09 v2(35.55,109.09)
  BOTTOM w0.122: v5(60.65,108.54) 61.05,108.14 UV1.D13
FBA_D16: length 33.9
  TOP w0.102: v5(58.98,109.33) 58.98,109.33 59.59,109.93 59.59,110.5 59.1,110.99
  TOP w0.122: 59.1,110.99 59.1,111.93 59.54,112.37 59.54,113.22 56.63,116.13 55.74,116.13 55.12,115.52 46.84,115.52 v1(46.03,114.71) 43.57,112.25 43.57,110.32 42.18,108.93 40.75,108.93 39.41,107.59 39.22,107.4 38.23,107.4 38,107.63 38,108.45 38.25,108.7 UV5.C3
  BOTTOM w0.122: UV1.B15 59.38,109.74 58.98,109.33 v5(58.98,109.33)
FBA_D17: length 32.3
  TOP w0.102: 59.53,111.48 59.53,110.84 59.79,110.59 59.79,109.85 59.38,109.44 59.38,109.17 59.18,108.97 58.59,108.97 v5(58.15,108.53)
  TOP w0.122: 59.53,111.48 59.53,111.74 59.98,112.18 59.98,113.4 56.81,116.57 55.55,116.57 54.94,115.95 v1(49.48,115.95) 46.66,115.95 43.13,112.43 43.13,111 41.59,109.46 41.07,109.46 40.76,109.16 40.45,109.16 39.99,108.7 UV5.A3
  BOTTOM w0.122: v5(58.15,108.53) 58.56,108.94 UV1.C16
FBA_D18: length 33.3
  TOP w0.122: UV5.A2 40.02,109.6 40.49,109.6 42.18,111.29 42.18,112.72 46.29,116.83 54.41,116.83 55.13,117.55 v1(55.38,117.55) 57.07,117.55 57.61,117 57.79,117 58.19,117.41 58.36,117.41 58.53,117.23 58.53,117.06 58.13,116.66 58.13,116.49 58.39,116.23 58.6,116.23 59.1,116.73 59.38,116.73 60.85,115.26 60.85,111.66 60.39,111.19 v5(60.25,111.19)
  BOTTOM w0.102: v5(60.25,111.19) 60.42,111.19 UV1.A13
FBA_D19: length 33.1
  TOP w0.122: UV5.C2 38.65,109.17 40.14,109.17 40.35,109.38 40.67,109.38 41.19,109.9 41.41,109.9 42.62,111.1 42.62,112.54 46.47,116.39 v1(52.72,116.39) 54.67,116.39 55.39,117.11 56.88,117.11 58.86,115.14 59.03,115.14 59.18,115.29 59.35,115.29 59.53,115.11 59.53,114.94 59.38,114.79 59.38,114.62 59.55,114.45 59.72,114.45 60.07,114.79 60.25,114.79 60.42,114.63 60.42,114.45 60.07,114.1 60.07,113.93 60.42,113.58 60.42,112 v5(60.12,111.71)
  BOTTOM w0.122: v5(60.12,111.71) 60.12,111.71 59.39,110.97 UV1.A15
FBA_D20: length 33.3
  TOP w0.102: 39.82,105.87 39.51,105.55 39.51,105.3 39.38,105.17 37.85,105.17 UV5.D7
  TOP w0.122: v5(57.51,110.95) 57.61,111.05 57.61,112.12 56.31,113.42 v1(50.62,113.42) 48.79,113.42 48.46,113.09 48.29,113.09 47.8,113.58 47.62,113.58 47.46,113.41 47.46,113.23 47.95,112.74 47.95,112.57 47.77,112.4 47.6,112.4 46.99,113.01 46.81,113.01 46.65,112.84 46.65,112.66 47.26,112.05 47.26,111.88 47.08,111.71 46.91,111.71 46.35,112.27 46.17,112.27 46.01,112.1 46.01,111.92 46.57,111.36 46.57,111.19 46.39,111.02 46.22,111.02 45.93,111.32 45.75,111.32 45.58,111.15 45.58,110.97 45.88,110.67 45.88,110.5 42.59,107.22 41.17,107.22 39.82,105.87
  BOTTOM w0.136: UV1.B18 57.32,110.15 57.32,110.76 v5(57.51,110.95)
FBA_D21: length 31.2
  TOP w0.122: v5(57.13,111.32) 57.17,111.37 57.17,111.94 56.13,112.98 v1(54.81,112.98) 48.98,112.98 48.27,112.28 48.27,112.1 48.59,111.79 48.59,111.61 48.42,111.44 48.25,111.44 47.93,111.76 47.76,111.76 47.58,111.59 47.58,111.41 47.9,111.1 47.9,110.92 47.73,110.75 47.56,110.75 47.24,111.07 47.07,111.07 46.89,110.9 46.89,110.72 47.21,110.41 47.21,110.23 47.04,110.06 46.87,110.06 46.55,110.38 46.38,110.38 46.17,110.18 46.17,110.01 46.49,109.69 46.49,109.51 46.32,109.35 46.14,109.35 45.83,109.66 45.66,109.66 45.48,109.49 45.48,109.32 45.8,109 45.8,108.82 45.63,108.66 45.46,108.66 45.14,108.97 44.97,108.97 44.79,108.8 44.79,108.63 45.11,108.31 45.11,108.13 44.94,107.97 44.77,107.97 44.45,108.28 44.28,108.28 44.1,108.11 44.1,107.94 44.42,107.62 44.42,107.44 44.25,107.28 44.08,107.28 43.76,107.59 43.59,107.59 43.41,107.42 43.41,107.25 43.73,106.93 43.73,106.75 43.56,106.59 43.39,106.59 43.07,106.9 42.9,106.9 42.56,106.57 40.99,106.57 UV5.A7
  BOTTOM w0.122: v5(57.13,111.32) 56.74,110.93 56.74,110.71 UV1.A18
FBA_D22: length 31.5
  TOP w0.122: v5(55.94,112.54) 55.42,112.02 54.47,112.02 54.35,112.14 54.35,112.42 54.23,112.54 53.99,112.54 53.86,112.42 53.86,112.14 53.74,112.02 53.5,112.02 53.38,112.14 53.38,112.42 53.25,112.54 53.01,112.54 52.89,112.42 52.89,112.14 52.77,112.02 52.52,112.02 52.4,112.14 52.4,112.42 52.28,112.54 52.04,112.54 51.91,112.42 51.91,112.14 51.79,112.02 51.55,112.02 51.43,112.14 51.43,112.42 51.3,112.54 51.06,112.54 50.94,112.42 50.94,112.14 50.82,112.02 50.57,112.02 50.45,112.14 50.45,112.42 50.33,112.54 50.08,112.54 49.96,112.42 49.96,112.14 49.84,112.02 49.62,112.02 49.22,112.42 49.04,112.42 48.88,112.26 48.88,112.08 49.15,111.81 49.15,111.55 v1(45.78,108.17) 43.49,105.89 43.31,105.89 43,106.21 42.82,106.21 42.65,106.04 42.65,105.86 42.97,105.54 42.97,105.37 42.68,105.08 42.19,105.08 42.06,105.21 42.06,106 41.94,106.13 41.7,106.13 41.58,106 41.58,105.21 41.45,105.08 41.21,105.08 41.09,105.21 41.09,105.86 40.96,105.99 40.73,105.99 40.6,105.86 40.6,105.21 40.48,105.08 39.68,105.08 39.29,104.7 UV5.B8
  BOTTOM w0.122: v5(55.94,112.54) 55.94,111.34 56.11,111.17 UV1.A19
FBA_D23: length 31.3
  TOP w0.122: UV5.C8 38.74,104.28 38.74,103.72 39.36,103.11 41.33,103.11 41.92,103.7 41.92,103.87 41.56,104.23 41.56,104.4 41.73,104.57 41.9,104.57 42.26,104.21 42.44,104.21 v1(42.97,104.75) 45.34,107.12 45.51,107.12 45.9,106.73 46.07,106.73 46.25,106.91 46.25,107.08 45.86,107.47 45.86,107.64 46.03,107.81 46.2,107.81 46.59,107.42 46.76,107.42 46.94,107.6 46.94,107.77 46.55,108.16 46.55,108.33 46.72,108.5 46.89,108.5 47.28,108.11 47.45,108.11 47.63,108.29 47.63,108.46 47.24,108.85 47.24,109.02 49.78,111.56 55.72,111.56 v5(56.33,112.16)
  BOTTOM w0.122: v5(56.33,112.16) 56.33,111.39 56.5,111.22 56.5,109.33 UV1.C19
FBA_D24: length 23.1
  BOTTOM w0.122: UV1.B24 51.62,109.74 51.49,109.87 51.49,111.06 50.73,111.82 48.56,111.82 48.27,111.53 48.03,111.53 47.93,111.63 47.78,111.63 47.66,111.52 47.66,111.37 47.81,111.22 47.81,111.07 47.61,110.87 47.44,110.87 46.86,111.45 46.68,111.45 46.51,111.28 46.51,111.11 47.09,110.53 47.09,110.35 46.92,110.18 46.75,110.18 v1(46.35,110.58) 46.17,110.76 45.99,110.76 45.82,110.59 45.82,110.42 46.4,109.84 46.4,109.66 43.26,106.52 42.26,106.52 41.48,105.74 41.31,105.74 40.96,106.09 40.78,106.09 40.62,105.92 40.62,105.74 40.96,105.4 40.96,105.23 40.8,105.07 39.56,105.07 39.43,105.2 39.43,105.37 39.56,105.5 UV4.A3
FBA_D25: length 24.7
  BOTTOM w0.122: UV4.C2 38.32,104.77 37.98,105.11 37.98,105.9 38.84,106.76 40.74,106.76 41.82,107.83 41.99,107.83 v1(42.2,107.62) 42.42,107.4 42.6,107.4 42.77,107.57 42.77,107.75 42.33,108.18 42.33,108.35 42.51,108.52 42.68,108.52 43.26,107.94 43.44,107.94 43.6,108.11 43.6,108.29 43.02,108.87 43.02,109.04 46.5,112.51 50.64,112.51 52.33,110.82 52.33,109.07 52.46,108.94 UV1.C23
FBA_D26: length 21.4
  BOTTOM w0.122: UV4.A2 41.06,104.7 41.07,104.71 41.24,104.71 41.53,104.43 41.57,104.39 41.75,104.39 41.91,104.55 41.91,104.73 41.59,105.06 41.59,105.23 41.76,105.4 41.93,105.4 42.26,105.08 42.44,105.08 42.6,105.24 42.6,105.42 42.31,105.71 42.31,105.89 42.5,106.08 42.68,106.08 42.94,105.82 43.18,105.82 v1(44.48,107.12) 46.17,108.81 46.34,108.81 46.69,108.46 46.87,108.46 47.04,108.62 47.04,108.8 46.69,109.15 46.69,109.32 46.86,109.5 47.03,109.5 47.36,109.17 47.54,109.17 47.7,109.33 47.7,109.51 47.38,109.84 47.38,110.01 47.55,110.19 47.72,110.19 47.76,110.14 48.4,109.51 48.58,109.51 48.75,109.67 48.75,109.85 48.07,110.53 48.07,110.7 48.95,111.58 50.09,111.58 UV1.A25
FBA_D27: length 22.3
  BOTTOM w0.102: 50.43,112.06 50.79,112.06 51.93,110.92 UV1.A24
  BOTTOM w0.122: 50.43,112.06 46.67,112.06 45.11,110.5 45.11,110.33 45.7,109.75 45.7,109.58 45.52,109.4 45.35,109.4 44.77,109.99 44.6,109.99 44.42,109.81 44.42,109.64 45.01,109.06 45.01,108.89 44.83,108.71 44.66,108.71 v1(44.27,109.11) 44.08,109.3 43.91,109.3 43.73,109.12 43.73,108.95 44.32,108.37 44.32,108.2 43.08,106.96 41.59,106.96 41,106.38 39.18,106.38 38.32,105.51 UV4.C3
FBA_D28: length 24
  BOTTOM w0.122: UV4.A7 40.45,108.7 42.71,110.96 42.71,111.13 42.34,111.5 42.34,111.68 42.5,111.85 42.68,111.85 43.05,111.48 43.23,111.48 43.4,111.65 43.4,111.82 43.11,112.11 43.11,112.29 43.28,112.46 43.45,112.46 43.72,112.2 43.89,112.2 44.06,112.36 44.06,112.54 43.55,113.05 43.55,113.23 43.71,113.4 43.89,113.4 44.43,112.86 44.61,112.86 44.78,113.03 44.78,113.2 44.31,113.67 44.31,113.85 44.48,114.01 44.66,114.01 45.12,113.55 45.3,113.55 45.76,114.01 v1(51,114.01) 51.69,114.01 54.36,111.34 54.36,110.61 UV1.A21
FBA_D29: length 24.9
  BOTTOM w0.122: UV4.B8 39.36,109.5 39.69,109.17 40.15,109.17 41.92,110.93 41.92,111.11 41.4,111.63 41.4,111.8 41.73,112.13 41.73,112.7 42.1,113.07 42.28,113.07 42.68,112.66 42.86,112.66 43.03,112.83 43.03,113.01 42.62,113.41 42.62,113.59 42.79,113.76 42.97,113.76 43.12,113.6 43.29,113.6 43.47,113.78 43.47,113.95 43.31,114.1 43.31,114.28 43.47,114.44 43.65,114.44 43.8,114.29 44.12,114.29 44.28,114.45 v1(48.46,114.45) 51.87,114.45 52.93,113.39 54.59,111.74 54.59,110.94 54.82,110.71 54.82,110.25 54.43,109.86 UV1.B21
FBA_D30: length 25.7
  BOTTOM w0.122: UV4.C8 38.29,109.5 37.98,109.81 37.98,110.93 38.64,111.59 39.38,111.59 v1(41.32,113.52) 43.17,115.38 52.19,115.38 55.38,112.19 55.38,111.65 55.71,111.32 55.71,109.38 UV1.C20
FBA_D31: length 25.5
  BOTTOM w0.122: UV1.C21 54.88,109.39 54.88,109.92 55.07,110.11 55.07,110.81 54.81,111.07 54.81,111.38 54.91,111.48 54.91,112.03 v1(54.1,112.84) 52.02,114.93 43.34,114.93 39.55,111.14 39.19,111.14 38.94,110.88 38.94,110.63 38.68,110.38 38.68,109.3 38.43,109.04 37.98,109.04 37.64,108.7 UV4.D7
FBA_D32: length 26.5
  IN1 w0.114: v5(53.98,98.63) 54.25,98.63 54.49,98.39 54.49,97.6 54.26,97.37 51.36,97.37 49.45,95.46 49.45,94.28 49.07,93.9 47.97,93.9 43.18,89.1 37.77,89.1 37.54,88.87 37.54,88.41 37.28,88.15 35.96,88.15 v2(35.57,88.54)
  BOTTOM w0.102: v5(53.98,98.63) 53.61,99 UV1.R22 ; UV6.G2 35.16,88.95 v2(35.57,88.54)
FBA_D33: length 23.8
  IN1 w0.114: v2(51.55,98.62) 51.55,98.63 48.08,95.16 47.78,95.16 43.6,90.98 38.05,90.98 37.64,90.56 37.03,90.56 36.77,90.3 36.77,90.01 36.5,89.74 36.14,89.74 35.95,89.55 35.95,89.25 35.64,88.94 34.58,88.94 34.3,89.23 34.3,89.74 v2(33.94,90.09)
  BOTTOM w0.102: UV6.H3 34.29,89.75 v2(33.94,90.09)
  BOTTOM w0.122: v2(51.55,98.62) 51.54,98.62 51.92,99 UV1.R24
FBA_D34: length 22.3
  IN1 w0.114: v5(53.16,98.63) 53.16,98.34 52.41,97.59 51.28,97.59 48.42,94.72 48.31,94.72 43.11,89.52 37.89,89.52 37.3,88.94 36.76,88.94 v2(36.36,89.34)
  BOTTOM w0.102: v5(53.16,98.63) 53.57,98.22 UV1.T22 ; UV6.F2 35.96,88.95 v2(36.36,89.34)
FBA_D35: length 27
  IN1 w0.114: v2(53.13,99.42) 52.78,99.07 52.78,98.27 52.36,97.85 51.21,97.85 48.3,94.94 48.05,94.94 43.74,90.63 43.21,90.63 43.09,90.52 43.09,89.99 42.97,89.87 42.76,89.87 42.64,89.99 42.64,90.52 42.52,90.63 42.29,90.63 42.18,90.52 42.18,89.99 42.05,89.87 41.85,89.87 41.72,89.99 41.72,90.52 41.61,90.63 41.38,90.63 41.26,90.52 41.26,89.98 41.14,89.85 40.93,89.85 40.81,89.98 40.81,90.52 40.69,90.63 40.46,90.63 40.35,90.52 40.35,89.93 40.22,89.8 40.02,89.8 39.89,89.93 39.89,90.52 39.78,90.63 38.49,90.63 37.19,89.34 v2(37.16,89.34)
  BOTTOM w0.102: v2(37.16,89.34) 36.75,89.75 UV6.E3
  BOTTOM w0.122: UV1.R23 52.73,99.02 v2(53.13,99.42)
FBA_D36: length 26.1
  IN1 w0.114: v2(33.96,93.34) 34.39,92.91 37.6,92.91 38.01,93.32 43.07,93.32 43.34,93.59 43.5,93.59 43.88,93.21 44.06,93.21 44.2,93.35 44.2,93.53 43.82,93.92 43.82,94.08 43.98,94.24 44.14,94.24 44.57,93.81 44.75,93.81 44.89,93.96 44.89,94.14 44.47,94.56 44.47,94.72 44.63,94.89 44.79,94.89 45.22,94.46 45.4,94.46 45.54,94.6 45.54,94.78 45.11,95.21 45.11,95.37 45.28,95.53 45.44,95.53 45.86,95.11 46.04,95.11 47.95,97.01 47.95,97.91 49.27,99.23 49.68,99.23 50.71,100.26 v5(50.73,100.26)
  BOTTOM w0.102: v2(33.96,93.34) 34.33,92.97 UV6.H7
  BOTTOM w0.122: v5(50.73,100.26) 51.13,100.66 UV1.N25
FBA_D37: length 26.9
  IN1 w0.114: v2(49.93,100.26) 48.63,100.26 48.36,100 48.36,99.1 47.14,97.88 47.14,97.72 47.54,97.31 47.54,97.15 47.38,96.99 47.22,96.99 46.81,97.39 46.65,97.39 46.49,97.23 46.49,97.07 46.89,96.66 46.89,96.5 46.73,96.34 46.57,96.34 46.17,96.75 46,96.75 45.84,96.58 45.84,96.42 46.25,96.02 46.25,95.86 46.09,95.69 45.92,95.69 45.52,96.1 45.36,96.1 43.86,94.6 43.32,94.6 43.21,94.49 43.21,93.95 43.08,93.82 42.88,93.82 42.75,93.95 42.75,94.49 42.63,94.6 42.41,94.6 42.29,94.49 42.29,93.79 42.16,93.66 41.96,93.66 41.83,93.79 41.83,94.49 41.72,94.6 41.49,94.6 41.38,94.49 41.38,93.66 41.25,93.54 41.05,93.54 40.92,93.66 40.92,94.49 40.81,94.6 39.44,94.6 38.72,93.88 38.12,93.88 37.98,93.74 36.68,93.74 v2(36.28,93.34)
  BOTTOM w0.102: UV6.F7 35.93,92.99 v2(36.28,93.34)
  BOTTOM w0.122: v2(49.93,100.26) 50.17,100.5 50.33,100.66 UV1.N26
FBA_D38: length 27.3
  IN1 w0.114: v5(52.33,100.26) 51.69,100.9 48.06,100.9 47.67,100.51 47.67,100.35 47.93,100.09 47.93,99.91 47.79,99.77 47.61,99.77 47.35,100.03 47.19,100.03 47.03,99.87 47.03,99.71 47.42,99.31 47.42,99.13 47.28,98.99 47.1,98.99 46.7,99.38 46.54,99.38 46.38,99.22 46.38,99.06 46.77,98.67 46.77,98.49 46.63,98.34 46.45,98.34 46.06,98.74 45.9,98.74 45.73,98.57 45.73,98.41 46.13,98.02 46.13,97.84 45.98,97.7 45.8,97.7 45.41,98.09 45.25,98.09 42.93,95.77 37.91,95.77 37.49,95.34 35.23,95.34 34.65,94.76 v2(34.65,94.14)
  BOTTOM w0.102: v2(34.65,94.14) 34.65,94.11 34.33,93.8 UV6.H8
  BOTTOM w0.122: v5(52.33,100.26) 52.33,100.6 52.41,100.68 UV1.N23
FBA_D39: length 26.9
  IN1 w0.114: v2(51.53,100.26) 51.13,100.66 49.7,100.66 49.52,100.48 48.5,100.48 48.15,100.12 48.15,99.37 45.91,97.13 45.74,97.13 45.34,97.54 45.18,97.54 45.02,97.37 45.02,97.21 45.42,96.81 45.42,96.65 45.26,96.49 45.1,96.49 44.7,96.89 44.53,96.89 44.37,96.73 44.37,96.57 44.77,96.16 44.77,96 44.61,95.84 44.45,95.84 44.05,96.24 43.89,96.24 43.73,96.08 43.73,95.92 44.13,95.52 44.13,95.35 43.97,95.19 43.8,95.19 43.4,95.6 43.24,95.6 43.07,95.42 42.81,95.42 42.69,95.31 42.69,95.06 42.58,94.94 42.35,94.94 42.24,95.06 42.24,95.31 42.12,95.42 41.89,95.42 41.78,95.31 41.78,95.06 41.67,94.94 41.44,94.94 41.32,95.06 41.32,95.31 41.21,95.42 40.98,95.42 40.87,95.31 40.87,95.06 40.75,94.94 40.52,94.94 40.41,95.06 40.41,95.31 40.29,95.42 38.21,95.42 37.32,94.54 35.88,94.54 v2(35.52,94.19)
  BOTTOM w0.102: UV6.F8 35.93,93.82 35.57,94.19 v2(35.52,94.19)
  BOTTOM w0.122: v2(51.53,100.26) 51.93,100.66 UV1.N24
FBA_D40: length 20
  TOP w0.122: v5(52.34,96.93) 52.03,96.93 51.6,96.5 50.39,96.5 49.99,96.09 46.82,96.09 43.69,92.97 43.52,92.97 43.25,93.24 43.07,93.24 42.91,93.07 42.91,92.89 43.18,92.63 43.18,92.45 43.01,92.29 42.83,92.29 v1(42.66,92.45) 42.49,92.62 42.32,92.62 42.14,92.45 42.14,92.28 42.39,92.03 42.39,91.85 42.23,91.69 42.05,91.69 41.8,91.93 41.63,91.93 41.38,91.69 38.61,91.69 38.33,91.96 UV7.C3
  BOTTOM w0.122: UV1.V23 52.73,96.54 v5(52.34,96.93)
FBA_D41: length 20.3
  TOP w0.122: v5(53.97,96.94) 53.55,97.36 52.14,97.36 51.52,96.74 50.1,96.74 49.89,96.53 46.63,96.53 v1(44.88,94.78) 43.78,93.68 43.6,93.68 43.27,94.02 43.09,94.02 41.2,92.12 40.05,92.12 39.89,91.96 39,91.96 38.68,92.28 38.68,93.4 UV7.C2
  BOTTOM w0.122: UV1.V22 53.57,96.54 v5(53.97,96.94)
FBA_D42: length 21.6
  TOP w0.122: v2(52.37,98.62) 52.2,98.62 51.34,97.76 50.59,97.76 50.46,97.88 50.46,98.41 50.34,98.53 50.1,98.53 49.98,98.41 49.98,97.88 49.85,97.76 49.61,97.76 49.49,97.88 49.49,98.41 49.37,98.53 49.12,98.53 49,98.41 49,97.88 48.88,97.76 48.64,97.76 48.51,97.88 48.51,98.41 48.39,98.53 48.15,98.53 48.03,98.41 48.03,97.88 47.9,97.76 47.66,97.76 47.54,97.88 47.54,98.41 47.42,98.53 47.17,98.53 47.05,98.41 47.05,97.88 46.93,97.76 46.68,97.76 46.56,97.88 46.56,98.41 46.44,98.53 46.2,98.53 46.08,98.41 46.08,97.88 45.95,97.76 45.59,97.76 v1(44.65,96.82) 40.83,93 39.99,93 UV7.A3
  BOTTOM w0.102: UV1.T23 52.73,98.26 v2(52.37,98.62)
FBA_D43: length 22.9
  TOP w0.122: UV7.A2 40.67,93.75 40.79,93.63 40.79,93.41 40.66,93.28 39.7,93.28 39.57,93.16 39.57,92.79 39.79,92.56 41.01,92.56 43.18,94.73 43.35,94.73 43.69,94.39 43.87,94.39 44.04,94.56 44.04,94.74 43.7,95.08 43.7,95.25 43.87,95.42 44.04,95.42 44.38,95.08 44.56,95.08 44.73,95.25 44.73,95.43 44.39,95.77 44.39,95.94 44.56,96.11 44.73,96.11 45.07,95.77 45.25,95.77 45.42,95.94 45.42,96.12 45.08,96.45 45.08,96.63 45.24,96.79 45.42,96.79 45.68,96.52 46,96.52 46.45,96.97 v1(46.87,96.97) 51.44,96.97 52.21,97.74 v5(53.18,97.74)
  BOTTOM w0.122: UV1.U22 53.56,97.36 v5(53.18,97.74)
FBA_D44: length 19.1
  TOP w0.122: v5(51.53,94.46) 51.04,94.95 48.38,94.95 48.08,94.65 48.08,94.31 v1(47.13,93.36) 45.2,91.43 45.2,91.29 45.3,91.18 45.3,91.01 45.13,90.84 44.95,90.84 44.85,90.94 44.68,90.94 44.51,90.77 44.51,90.6 44.61,90.49 44.61,90.32 44.41,90.12 39.83,90.12 39.53,89.82 39.53,89.64 39.19,89.29 38.21,89.29 37.96,89.55 37.96,89.84 37.83,89.97 37.66,89.97 37.53,89.84 UV7.D7
  BOTTOM w0.122: UV1.Y24 51.61,94.88 51.53,94.8 v5(51.53,94.46)
FBA_D45: length 19.8
  TOP w0.122: UV7.A7 40,89.68 40.62,89.68 40.74,89.56 40.74,89.04 40.87,88.92 41.1,88.92 41.23,89.04 41.23,89.56 41.35,89.68 41.59,89.68 41.71,89.56 41.71,89.08 41.84,88.95 42.07,88.95 42.2,89.08 42.2,89.56 42.32,89.68 42.57,89.68 42.69,89.56 42.69,89.08 42.82,88.95 43.05,88.95 43.18,89.08 43.18,89.56 43.3,89.68 43.54,89.68 43.66,89.56 43.66,89.08 43.79,88.95 44.02,88.95 44.15,89.08 44.15,89.56 44.27,89.68 44.59,89.68 v1(44.91,89.99) 48.97,94.06 51.7,94.06 52.12,94.48 v5(52.33,94.48)
  BOTTOM w0.122: v5(52.33,94.48) 52.33,94.44 UV1.AA24
FBA_D46: length 20.9
  TOP w0.122: UV7.C8 38.71,88.58 38.71,88.02 39.37,87.36 v1(43.38,87.36) 44.11,87.36 48.74,91.99 49.2,91.99 49.62,92.41 50.84,92.41 51.13,92.7 51.13,92.97 51.38,93.22 51.56,93.22 52.11,93.77 52.49,93.77 52.71,93.99 53.19,93.99 53.57,94.36 UV1.Y22 v5(53.98,95.29)
  BOTTOM w0.122: UV1.Y22 v5(53.98,95.29)
FBA_D47: length 21.4
  TOP w0.122: v5(53.13,94.46) 52.85,94.46 52.45,94.06 52.02,94.06 51.4,93.44 51.29,93.44 51.09,93.24 49.69,93.24 49.41,92.96 49.41,92.52 49.3,92.41 48.54,92.41 47.77,91.64 47.7,91.64 47.57,91.77 47.57,91.78 47.42,91.78 v1(47.11,91.47) 46.8,91.16 46.8,90.99 46.87,90.92 46.87,90.75 46.7,90.57 46.53,90.57 46.46,90.64 46.29,90.64 46.11,90.47 46.11,90.3 46.18,90.23 46.18,90.06 46.01,89.88 45.84,89.88 45.77,89.95 45.6,89.95 45.42,89.78 45.42,89.61 45.49,89.54 45.49,89.37 45.32,89.19 45.15,89.19 45.08,89.26 44.91,89.26 44.73,89.09 44.73,88.92 44.8,88.85 44.8,88.68 44.64,88.51 42.89,88.51 42.76,88.39 42.76,88.01 42.64,87.89 42.4,87.89 42.28,88.01 42.28,88.39 42.15,88.51 41.91,88.51 41.79,88.39 41.79,88.01 41.67,87.89 41.42,87.89 41.3,88.01 41.3,88.39 41.18,88.51 40.95,88.51 40.13,89.33 39.67,89.33 39.29,88.95 UV7.B8
  BOTTOM w0.122: UV1.AA23 52.73,94.06 v5(53.13,94.46)
