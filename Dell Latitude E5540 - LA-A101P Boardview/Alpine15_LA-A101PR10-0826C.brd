# Allegro board Alpine15_LA-A101PR10-0826C.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+1.05V_M: length 18.1
  TOP w0.102: v2(98.29,69.89) v6(98.29,70.57)
  TOP w0.254: CC46.1 160.85,71.7 160.85,72.12 160.59,72.38 160.11,72.38 v2(159.71,71.97)
  TOP w0.381: RC272.1 170.49,71.56 170.16,71.23 169.9,71.23 v2(169.13,70.46)
  TOP w0.508: v3(154.63,72.63) 152.47,72.63 CC47.1
  IN1 w0.254: v2(163.73,70.12) 162.43,71.42 159.95,71.42 v3(159.76,71.23)
  BOTTOM w0.203: UC1.AG14 160.05,70.67 159.76,70.97 v3(159.76,71.23) 159.76,71.92 v2(159.71,71.97)
  BOTTOM w0.254: UC1.AG8 163.73,69.82 v2(163.73,70.12) UC1.AF9 UC1.AE9
  BOTTOM w0.305: v2(161.26,69.4) 160.9,69.76 UC1.AG13
  vias: v2(95.82,70.11) v2(95.82,69.48) v2(96.43,70.11) v2(96.43,69.48) v2(96.74,68.77) v2(96.89,67.63) v2(97.03,69.92) v2(97.43,68.29) v2(97.6,69.54) v2(97.7,70.17) v2(97.65,68.9) v2(98.01,68.34) v2(98.24,69.28) v2(156.66,107.68) v2(157.24,107.68) v2(163.39,106.79) v2(163.69,106.29) v2(164,106.79) v2(164.3,106.29) v2(164.86,106.89) v2(164.89,106.29) v2(165.52,106.92) v2(165.51,106.29) v3(172.15,99.96) v3(172.25,100.62)
+1.05V_M_JTAG: length 19.5
  IN2 w0.508: v3(103.44,82.94) 103.32,83.07 101.29,83.07 v3(99.85,84.51)
  BOTTOM w0.508: v3(99.85,84.51) RC10.2 RC18.2 ; RC20.2 102.62,73.64 RC16.2 103.54,73.69 104.51,74.66 v1(104.51,76) 104.51,77.56 103.05,79.02 103.05,79.96 103.83,80.73 103.83,81.34 103.44,81.72 v3(103.44,82.94) 103.25,82.75 RC17.2
+1.05V_MODPHY: length 14.7
  TOP w0.508: v3(153.28,103.58) 152.5,103.58 152.04,104.05 v6(152.04,104.77) 152.04,107.23 152.34,107.53 C75.1 ; v3(157.13,106.3) 158.04,105.38 LC2.1
  IN2 w0.508: v3(157.13,106.3) 157.13,106.56 156.66,107.03 153.91,107.03 153.61,106.73 153.61,103.91 v3(153.28,103.58)
+1.05V_MODPHY_PCH: length 2.8
  BOTTOM w0.254: v2(162.37,77.74) 162.37,77.65 v2(161.88,77.16) ; v2(162.37,77.74) 162.37,77.92 UC1.L10 163.11,78.66 UC1.K9 ; v2(162.37,77.74) UC1.M9
  vias: v1(169.27,85.36) v3(162.41,101.74) v3(162.63,101.13) v3(163.26,101.18) v3(163.92,101.15) v3(166.11,86.63) v3(166.27,86.01) v3(166.44,87.29) v3(166.73,86.52)
+1.05V_MP: length 23.3
  IN1 w0.254: v2(92.2,65.33) 92.2,64.44 91.68,63.92 84.34,63.92 83.43,63 79.37,63 77.11,65.26 77.11,67.79 v2(78.25,68.93)
  BOTTOM w0.203: v2(78.25,68.93) 78.16,68.93 77.89,68.67 77.89,68.34 78.16,68.07 PU150.22
  vias: v1(94.97,75.49) v2(94.07,78.02) v2(94.38,78.55) v2(94.66,78.02) v2(94.96,78.55) v2(95.32,80.15) v2(95.27,78.02) v2(95.6,78.55) v2(95.85,80.45) v2(95.85,79.87) v2(95.85,78.02) v3(92.61,70.31) v3(92.61,69.62) v3(92.61,68.99) v3(92.61,68.3) v3(93.24,70.31) v3(93.24,69.62) v3(93.24,68.99) v3(93.24,68.3) v3(93.9,70.33) v3(93.9,69.62) v3(93.9,68.99) v3(93.9,68.3)
+1.5V_RUN: length 112.7
  TOP w0.254: U91.19 188.1,99.35 188.26,99.5 188.26,100.67 187.75,101.18 v3(187.7,101.18)
  TOP w0.508: RC254.1 163.07,100.38 161.08,100.38 160.86,100.16 160.86,100.05 160.81,100 160.81,98.04 160.52,97.75 v3(160.14,97.75)
  IN1 w0.508: v3(160.14,97.75) 160.32,97.57 161.01,97.57 161.78,96.81 165.61,96.81 166.3,97.5 182.88,97.5 v3(185.26,99.88)
  IN2 w2.032: 233.18,42.06 233.18,57.3 227.6,62.88 227.6,72.43 228.74,73.57 228.74,74.84 ; 228.21,78.29 228.21,79.08 226.63,80.66 221.53,80.66
  BOTTOM w1.016: 194.45,98.44 198.14,94.75 198.14,91.6 199.1,90.64 200.05,90.64 203.05,87.64 208.3,87.64 210.99,84.95 215.66,84.95 219.52,81.09 219.55,81.09
  vias: v3(107.83,13.28) v3(107.8,12.65) v3(108.51,13.28) v3(108.51,12.65) v3(185.24,100.57) v3(193.39,98.72) v3(193.39,97.73) v3(220.44,80.86) v3(220.96,80.39) v3(229.38,78.65) v3(229.38,78.02) v3(229.38,77.38) v3(229.38,76.62) v3(232.02,16.9) v3(232.07,16.14) v3(232.78,16.95) v3(232.83,16.29) v6(228.25,77.93)
+1.05V_RUN: length 255.6
  TOP w0.279: JXDP1.43 97.37,47.86 97.58,47.66 v3(98.19,47.66) ; CC10.1 86.58,48.78 87.47,47.89 87.47,47.88 89.47,47.88 JXDP1.44
  TOP w0.508: v2(156.23,131.52) 156.35,131.39 R374.2 ; CC37.1 163.3,71.51 v2(163.73,71.07) ; v3(159.45,97.75) 159.45,97.18 LC6.1 ; v2(159.92,135.88) 159.92,135.36 R335.1 ; CC11.1 99.21,46.64 v3(98.19,47.66) ; v2(119.73,83.88) 119.15,83.3 117.67,83.3 116.98,83.98 116.98,85.16 117.57,85.75 v3(117.57,86.75) ; LC3.1 161.94,97.37 v3(162.32,97.75) 161.64,98.44 LC5.1 ; v2(120.6,77.07) 120.6,77.06 120.92,76.75 122.25,76.75 123.17,75.83 129.3,75.83 130.42,74.71 131.97,74.71 132.72,73.96 132.72,72.44 133.01,72.15 133.01,71.63 131.49,71.63 131.28,71.84 129.68,71.84 129.07,72.45 121.58,72.45 119.74,70.61 118.68,70.61 117.83,71.46 117.83,73.3 117.3,73.84 v3(117.3,74.1) ; R403.1 v3(169.43,135.29) ; RC280.1 85.66,50.51 v3(86.58,49.59) CC10.1 ; CC31.1 163.82,77.78 v2(163.88,77.72)
  TOP w1.016: 133.01,71.63 137.46,71.63 142.24,76.41 152.14,76.41 152.49,76.06
  IN1 w0.457: v2(163.73,71.07) 162.91,71.9 162.91,72.1 162.12,72.88 159.45,72.88 158.72,72.15 158.72,71.64 158.2,71.12 v2(158.2,70.85)
  IN2 w0.508: v3(156.15,99.88) 157.32,99.88 v3(159.45,97.75) ; v3(117.3,74.1) 117.3,73.84 117.85,73.29 117.85,71.75 114.95,68.86 114.95,63.74 98.88,47.66 v3(98.19,47.66) 88.51,47.66 v3(86.58,49.59) ; v2(120.6,77.07) 119.39,77.07 118.06,78.4 118.06,80.85 v2(118.13,80.91) 119.73,82.51 v2(119.73,83.88)
  IN3 w2.032: 146.37,127.82 146.37,128.87 160.16,142.66 160.16,155.05 162.04,156.93 162.04,156.97 162.85,157.77 162.88,157.77 163.24,158.13 163.24,161.15 163.98,161.89 163.98,163.36 163.95,163.4 163.95,163.99 164.2,164.25 164.26,164.25 165.07,165.05 165.07,165.11 165.09,165.14 165.09,168.14 166.74,169.8 172.94,169.8
  BOTTOM w0.254: v2(159.43,80.32) 159.77,79.98 UC1.H15 ; UC1.J17 158.8,79.33 v2(158.48,79.66) ; v2(161.33,80.29) 161.43,80.29 UC1.H11 ; v2(161.33,79.61) 161.61,79.33 UC1.J11 ; UC1.T21 156.45,75.54 v2(156.08,75.91) 156.45,76.28 UC1.R21 ; UC1.AE8 163.55,70.9 v2(163.73,71.07) ; UC1.AG16 159.21,69.76 158.85,69.4 158.85,69.4 v2(158.83,69.39) 158.45,69.76 UC1.AG17 ; v2(156.05,69.97) 155.8,70.22 UC1.AF22
  BOTTOM w0.305: v2(163.88,77.72) 163.55,77.39 UC1.N8
  BOTTOM w0.381: v2(163.92,76.8) 163.91,76.79 UC1.P9
  BOTTOM w0.508: v3(117.57,86.75) 117.11,86.75 116.73,86.37 RC242.2 ; RC118.1 121.23,82.77 120.77,83.23 RC119.1 v2(119.73,83.88) ; RC253.1 RC122.1 118.42,81.2 v2(118.13,80.91) ; RC120.1 v2(120.6,77.07)
  BOTTOM w1.016: 157.75,131.61 157.5,131.36 157.52,131.33 157.52,126.11 157.37,125.96 157.37,125.01 157.52,124.86 157.52,119.52 157.32,119.32 157.32,111.41 156.76,110.85 156.76,109.63 159.43,106.96 161.5,106.96 163.57,104.9 163.57,103.8
  vias: v2(163.31,103.16) v2(163.3,102.58) v2(163.87,102.97) v2(163.86,102.38) v2(164.46,102.7) v2(165.04,102.7) v2(165.62,102.7) v3(147.84,126.33) v3(147.87,125.61) v3(147.87,124.95) v3(147.89,124.19) v3(147.87,123.53) v3(175.05,169.53) v3(175.58,170.32) v3(175.73,169.68) v3(176.22,170.17) v3(190.62,75.35) v3(190.72,74.71) v3(190.85,81.8) v3(190.85,81.06) v3(190.82,80.33) v3(190.82,79.64) v3(191.25,75.35) v3(191.35,74.71) v6(153.83,75.96)
+1.5V_RUNP: length 17.6
  TOP w0.305: v2(226.46,83.91) 226.97,84.42 232.15,84.42 v1(233.21,85.48) 234.92,87.19 234.92,91.66 235.14,91.88 v2(235.14,92.65)
  BOTTOM w0.254: v2(235.14,92.65) PR202.1 PC202.1
+1.5V_THERMAL: length 18.1
  TOP w0.102: v3(163.65,97.65) 163.65,96.69 v1(163.86,96.48)
  TOP w0.508: v3(163.65,97.65) 163.65,98.1 RC254.2
  IN2 w0.508: 159.97,84.38 161.64,86.04 162.35,86.04 162.83,86.52 162.83,89.09 163.49,89.75 163.49,97.49 v3(163.65,97.65)
  BOTTOM w0.254: UC1.J15 159.72,79.33 v2(159.43,79.62)
+1.05V_VCCST: length 141.3
  TOP w0.508: v3(82.82,82.97) 82.82,83.22 85.66,86.07 v6(89.16,86.07) 89.96,86.07 90.92,87.03 v3(91.81,87.03) ; v3(118.13,85) 118.13,84.01 v2(118.2,83.93) 118.78,84.51 121.51,84.51 v2(122.04,83.98) ; CC26.1 152.13,70.99 CC50.1 152.07,70.12 v3(152.03,70.07) ; v3(116.54,76.25) 116.45,76.16 115.59,76.16 RC114.1
  IN2 w0.508: v3(152.03,70.07) 152.03,74.59 154.04,76.61 154.04,79.44 154.58,79.97 154.58,82.56 155.34,83.32 155.34,84.61 155.79,85.07 155.79,89.37 157.39,90.97 157.39,93.18 158.11,93.89 158.11,96.79 157.24,97.65 156.68,97.65 v3(156.35,97.98) ; v3(152.03,70.07) 152.05,70.09 v2(153.71,70.09) ; v3(152.03,70.07) 151.53,70.07 150.37,71.23 139.08,71.23 138.01,70.17 135.45,70.17 134.59,69.3 ; v3(80.79,84.39) 81.4,84.39 v3(82.82,82.97) ; 129.91,69.71 129.91,70.19 128.57,71.54 123.33,71.54 121.86,73.01 121.86,73.52 120.63,74.75 119.99,74.75 119.07,75.68 117.11,75.68 v3(116.54,76.25) 116.54,77.47 117.3,78.23 117.3,81.4 118.2,82.31 v2(118.2,83.93) 115.38,83.93 112.31,80.86 108.32,80.86 106.98,82.21 100.85,82.21 v3(98.57,84.49)
  BOTTOM w0.381: v2(153.71,70.09) 153.71,70.17 154.02,70.47 154.87,70.47 UC1.AE23 155.24,70.84 155.35,70.84 UC1.AE22 155.59,71.09 155.59,71.61 155.54,71.67 UC1.AC22
  BOTTOM w0.508: v2(118.2,83.93) 118.2,83.78 117.69,83.27 RC255.1 ; v3(98.57,84.49) 97.68,85.38 93.46,85.38 v3(91.81,87.03) ; PR331.1 82.67,85 PC319.1 82.67,83.12 v3(82.82,82.97) ; R24.1 122.62,84.42 122.19,83.98 v2(122.04,83.98) ; RC243.2 117.67,85.46 v3(118.13,85) ; PR330.1 v3(80.79,84.39) ; RC113.1 118.94,77.07 118.94,76.31 RC249.1 118.72,76.25 118.51,76.03 RC244.1 116.76,76.03 v3(116.54,76.25)
+1.05V_VMM_VDD: length 6.9
  TOP w0.203: U6.G3 v5(179.86,155.92) ; U6.E9 v5(177.91,160.47) ; U6.E7 v5(177.91,158.52) ; U6.H7 v5(180.51,158.52) ; U6.F12 v5(178.56,162.42) ; U6.H8 v5(180.51,159.82) ; U6.E8 v5(177.91,159.82) ; U6.C9 v5(176.61,160.47) ; U6.G12 v5(179.86,162.42) ; U6.C8 v5(176.61,159.82) ; U6.E3 v5(177.91,155.92) ; U6.E6 v5(177.91,157.87) ; U6.H6 v5(180.51,157.87) ; U6.H9 v5(180.51,160.47)
  TOP w0.254: U6.E5 v5(177.91,157.22)
  vias: v1(186.11,164.63) v3(179.29,170.67) v3(179.59,171.54) v3(179.87,170.95) v3(184.67,164.65) v3(185.13,165.11) v5(172.28,156.45) v5(172.28,155.89)
+1.05V_VMM_VDDTX: length 10.5
  TOP w0.203: U6.H3 v5(180.51,155.92) 180.84,155.59 U6.J2 ; U6.C6 v5(176.61,157.87) ; U6.D3 v5(177.26,155.92) ; U6.J3 v5(181.16,155.92) ; U6.F3 v5(178.56,155.92) ; U6.E12 v5(177.91,162.42) ; v5(177.91,161.12) 178.24,160.8 U6.E10 ; U6.D12 v5(177.91,161.77) ; U6.C7 v5(176.61,158.52)
  TOP w0.279: U6.J10 v5(181.16,161.12) ; U6.H11 v5(180.51,161.77) ; U6.K10 v5(181.81,161.12) ; U6.K8 v5(181.81,159.82) ; U6.K9 v5(181.81,160.47)
  TOP w0.508: C23.1 v1(172.78,157.04) 173.14,156.68 v3(173.14,155.97) ; v3(172.86,155.23) 172.61,154.98 C24.1
+1.8V_RUN_CARD: length 56.9
  TOP w0.102: v3(9.61,68.04) v6(10.28,68.04)
  IN2 w0.508: v3(14.29,55.21) 13.96,54.88 13.96,36.36 12.84,35.24 12.84,32.17 13.68,31.33 15.26,31.33 v2(15.81,30.78)
  IN3 w0.508: v3(9.61,68.04) 9.61,68.03 7.89,66.31 v3(3.95,66.31)
  BOTTOM w0.508: v3(9.61,68.04) C246.1 10.8,68.99 C247.1 14.29,65.51 v3(14.29,55.21) ; 19.19,29.37 18.8,29.76 C229.1 18.36,29.97 17.55,30.78 C228.1 v2(15.81,30.78) ; JSD1.14 v3(3.95,66.31)
+1.35V_MEM: length 96.4
  TOP w0.381: U5.5 228.27,29.03 CD23.1
  TOP w0.508: CD23.1 228.11,29.36 228.46,29.72 228.46,30.29 ; 228.46,30.29 228.21,30.54 227.39,30.54 227.34,30.59 225.08,30.59 224.76,30.27 224.76,29.26 224.42,28.92 221.61,28.92 219.91,30.62 215.84,30.62 213.55,32.9 211.55,32.9 210.56,33.9 207.15,33.9 204.49,36.56 ; 228.46,30.29 228.46,31.96 QD1.1 ; RC130.1 v3(158.4,23.81) ; 106.57,11.49 v3(106.57,12.36) RD3.1 ; RC67.1 v3(99.58,12.33) 99.58,11.52 99.51,11.44
  IN3 w0.508: v2(75.99,12.99) 75.99,14.39 76.14,14.54 76.14,26.25 77.23,27.34 v3(77.87,27.34)
  BOTTOM w0.178: UC1.AN33 148.24,66.34 v2(147.97,66.08)
  BOTTOM w0.203: UC1.AY40 144.11,61.89 144.11,61.39 v2(144.56,60.93) ; UC1.AY35 147.26,61.9 147.26,61.39 v2(147.72,60.93) ; UC1.AY44 140.93,61.86 140.93,61.18 141.19,60.93 v2(141.42,60.93) ; UC1.AR48 138.96,64.71 v2(138.9,64.71)
  BOTTOM w0.229: v2(138.26,61.37) 137.84,61.78 UC1.AY50
  BOTTOM w0.254: UC1.AJ37 v2(145.77,69.5) ; v2(152.27,69.5) 152.69,69.5 UC1.AH26 ; UC1.AJ33 v2(148.37,69.5) ; UC1.AP43 142.08,65.69 v2(141.75,65.36) ; UC1.AJ31 v2(149.67,69.5)
  BOTTOM w0.356: JDIMM2.124 201.78,17.31 v2(201.33,16.86) ; JDIMM2.82 189.18,16.84 v3(189.73,16.29) ; JDIMM2.112 v2(198.18,16.82) ; 197.88,27.81 JDIMM2.111 ; JDIMM2.94 192.78,16.34 v3(193.03,16.09) ; JDIMM2.87 190.68,27.72 v2(190.58,27.82) ; v3(194.76,16.12) 194.58,16.3 JDIMM2.100 ; v2(186.85,27.96) 186.95,27.96 187.08,27.83 JDIMM2.75 ; JDIMM2.123 201.48,27.51 v2(201.72,27.75) ; v2(192.89,28.06) 192.89,27.96 192.48,27.54 JDIMM2.93 ; JDIMM1.118 v2(125.48,16.76) ; JDIMM2.118 v2(199.98,16.82) ; JDIMM2.106 v2(196.38,16.82) ; JDIMM2.81 188.88,27.49 188.41,27.96 v2(188.31,27.96) ; v2(193.71,28.06) 194.28,27.49 JDIMM2.99 ; JDIMM2.76 187.38,16.71 187.93,16.17 v3(188.61,16.17) ; JDIMM2.105 196.08,27.93 v2(196.01,28) ; 199.68,27.81 JDIMM2.117 ; JDIMM2.88 v3(190.98,16.36)
  BOTTOM w0.508: v2(136.76,56.98) 137.12,57.34 137.82,57.34 ; v3(77.87,27.34) 77.87,26.88 RC217.1
  vias: v2(74.72,12.99) v2(74.72,12.36) v2(74.72,11.72) v2(74.72,11.09) v2(75.35,12.99) v2(75.35,12.36) v2(75.35,11.72) v2(75.35,11.09) v2(75.99,12.36) v2(75.99,11.72) v2(75.99,11.09) v2(76.22,10.5) v2(76.62,12.36) v2(76.62,11.72) v2(76.62,11.09) v2(76.85,10.5) v2(77.26,12.36) v2(77.26,11.72) v2(77.26,11.09) v2(77.44,10.48) v2(77.84,12.36) v2(77.84,11.09) v2(77.89,11.7) v2(78.5,11.67) v2(109.97,13.07) v2(110,12.48) v2(110.02,11.87) v2(110,11.16) v2(110.66,13.07) v2(110.68,12.48) v2(110.68,11.85) v2(110.68,11.21) v2(111.32,13.07) v2(111.32,12.48) v2(111.32,11.85) v2(111.32,11.21) v2(111.62,16.88) v2(111.82,28.03) v2(111.93,13.09) v2(111.95,12.48) v2(111.95,11.85) v2(111.95,11.21) v2(112.26,16.85) v2(112.56,13.07) v2(112.59,12.48) v2(112.59,11.85) v2(112.59,11.21) v2(112.88,16.84) v2(113.2,13.07) v2(113.22,12.48) v2(113.22,11.85) v2(113.22,11.21) v2(113.48,16.85) v2(113.72,12.17) v2(114.06,16.83) v2(114.68,16.82) v2(115.04,27.92) v2(116.37,28.1) v2(116.48,16.84) v2(118.25,28.1) v2(118.28,16.82) v2(119.12,16.75) v2(120.13,28) v2(120.08,16.8) v2(120.67,16.78) v2(121.38,28.03) v2(121.88,16.84) v2(122.47,16.83) v2(123.68,16.84) v2(124.02,28.46) v2(124.3,16.83) v2(124.68,27.9) v2(126.89,16.65) v2(127.29,28) v2(128.3,20.32) v2(139.54,57.02) v2(141.44,58.67) v2(143.17,58.59) v2(143.16,57.97) v2(146.08,57.59) v2(146.08,56.96) v2(149.12,34.33) v2(161.23,20.48) v2(165.04,30.82) v2(199.37,28.01) v3(141.27,13.58) v3(141.91,13.55) v3(142.31,12.96) v3(142.54,13.55) v3(142.96,12.97) v3(143.22,13.55) v3(143.59,12.97) v3(143.91,13.55) v3(144.26,12.98) v3(144.54,13.55) v3(144.89,12.98) v3(145.19,13.55) v3(152.5,16.82) v3(152.5,16.19) v3(153.26,16.82) v3(153.26,16.19) v3(154.02,16.82) v3(154.02,16.19) v3(154.72,16.82) v3(154.72,16.19) v3(154.72,15.49) v3(155.48,16.82) v3(155.48,16.19) v3(155.48,15.49) v3(156.24,16.82) v3(156.24,16.19) v3(156.24,15.49) v6(129.28,15.43)
+1.35V_MEN_P: length 63.9
  TOP w0.762: 65.78,12.57 65.78,10.78 65.32,10.32 45.99,10.32 45.36,10.96 45.36,12.41
  IN2 w0.254: v2(69.85,12.8) 65.98,8.93 45.96,8.93 44.85,10.04 38.29,10.04 v2(37.63,10.71)
  BOTTOM w0.203: PU100.5 37.61,11.94 36.95,11.28 PC114.1
  BOTTOM w0.254: PR105.2 PC113.2 37.87,9.69 PC114.1 37.05,10.71 v2(37.63,10.71)
  vias: v1(67.75,10.59) v2(44.34,12.99) v2(44.92,12.99) v2(66.01,13.82) v2(66.2,13.17)
+3.3V_ALW: length 819.7
  TOP w0.254: v3(178.53,118.71) 178.49,118.67 RP18.1 ; RP2.5 152.66,127.41 v3(152.42,127.16) 152.67,126.91 RP2.6 ; RP16.2 162.2,133.44 v3(161.94,133.69) 161.7,133.45 RP16.3 ; v3(161.03,133.69) 161.03,133.51 161.2,133.35 RP16.4 ; RP2.7 152.65,126.41 v3(152.42,126.17) 152.68,125.91 RP2.8 ; RP17.7 162.57,114.36 162.5,114.29 162.5,113.96 v3(162.75,113.7) 162.89,113.84 162.89,114.18 163.07,114.36 RP17.8 ; RP15.7 156.23,127.42 155.96,127.15 v3(155.96,126.92) RP15.8
  TOP w0.305: v3(104.29,130.82) 104.3,130.81 105.67,130.81 106.13,131.27 JUDB1.7
  TOP w0.381: UC4.5 186.79,56.89 186.81,56.87 187.49,56.87 187.98,56.38 CC24.1 ; PU502.5 149.76,143.67 150,143.92 PC502.2 ; PU405.5 127.12,133.79 127.45,133.46 PC433.1 v3(128.08,132.75) 128.97,132.75 129.44,133.22 PR449.1 ; PU500.5 146.7,147.33 PC500.2
  TOP w0.406: U87.5 143.6,111.05 143.78,110.88 143.78,110.45 C459.2
  TOP w0.508: R402.1 v3(173.5,133.39) ; R343.1 164.74,133.08 v3(164.74,133.39) ; v3(212.79,184.21) 212.79,184.34 211.09,186.04 204.92,186.04 204.2,185.33 200.77,185.33 200.41,184.96 R272.2 ; v2(131.76,140.47) 131.33,140.04 PR8.1 ; v2(187.06,132.93) 186.88,132.75 R481.2 186.83,132.12 R293.1 ; R388.1 220.21,90.72 v3(220.01,90.51) ; R322.1 R302.1 v3(203.14,120.22) ; v3(207.25,102.17) 206.72,102.7 C375.1 206.72,104.55 JKB1.7 ; v3(158.45,135.27) R492.1 R491.1 ; v3(171.06,139.05) 171.64,139.05 172.36,139.76 173.17,139.76 ; v3(320.79,176.49) 320.79,173.77 318.81,171.79 318.81,167.8 315.66,164.65 312.87,164.65 312.44,165.09 R479.2 311.88,165.62 311.57,165.31 v3(311.57,165.26) ; RC267.1 193.77,67.73 194.2,67.3 194.54,67.3 v3(194.53,67.3) ; v3(220.03,92.62) R398.1 R395.1 ; R36.1 201.44,133.26 v2(201.44,133.51) ; v3(223.61,96.76) 224.43,97.57 R397.1 ; v2(111.13,143.64) 111.57,143.2 PU403.8 ; R296.1 201.46,119.24 200.82,119.88 v2(200.82,120) 200.05,120 R283.1 R292.1 R286.1 ; v3(146.22,144.26) 146.47,144 146.47,142.76 PR506.1 ; R288.1 R285.1 187.12,115.15 v2(186.38,114.41) ; R298.1 v2(190.62,132.85) ; C459.2 v3(143.19,108.22) ; PR553.2 136.6,157.37 136.3,157.67 135.33,157.67 v2(134.79,157.12) ; v2(195.47,132.37) 195.47,132.37 195.24,132.14 194.84,132.14 R284.1 ; v3(72.78,95.28) 72.66,95.16 R389.1 ; R478.2 224.68,39.23 223.76,38.31 R428.1 223.54,37.96 222.47,36.89 218.86,36.89 v3(218.84,36.92) ; R432.1 209.49,140.7 v3(209.54,140.65) ; v3(190.89,64.85) 190.89,64.56 191.4,64.05 191.86,64.05 193.13,62.78 193.13,60.29 191.02,58.18 191.02,57.82 189.83,56.63 v3(189.83,55.03) 190.14,54.72 RC264.1 189.14,54.22 188.06,55.3 CC24.1 ; v3(211.32,153.35) 211.2,153.23 211.2,153.16 211,152.96 PR58.1 ; R396.1 221.76,99.85 v3(222.42,99.19) ; R477.2 v3(101.62,176.77) ; R295.1 R291.1 191.38,114.79 191.38,114.33 v3(191.53,114.17) ; R380.1 v3(154.88,123.94) ; R289.1 v3(197.45,132.16) ; R490.2 110.33,126.76 v3(110.87,127.3) ; v3(150.79,146.52) 150.81,146.49 PR500.2 ; R317.2 v2(201.36,126.15) ; v2(169.92,133.36) 170.07,133.21 R340.1 R363.1 ; R391.1 189.12,134.99 v3(189.22,134.89) ; v2(150.61,143.78) 150.61,144.21 150.41,144.41 PC502.2 ; v3(208.65,151.5) 207.94,150.79 C404.1 207.74,151.81 U47.5 ; v2(145.81,150.71) PR504.1 ; v3(183.02,117.23) 182.69,117.56 R282.1 ; PR2.1 v2(133.21,145.8) ; v3(125.06,159.08) 124.78,158.8 PR567.2 ; PC500.2 v2(146.7,149.08) ; v3(341.39,161.58) R476.2
  IN1 w0.508: v3(220.01,90.51) 220.03,90.54 v3(220.03,92.62) 220.03,94.6 222.19,96.76 v3(223.61,96.76) 223.61,98 v3(222.42,99.19) 222.42,100.7 218.91,104.2 208.4,104.2 207.25,103.06 v3(207.25,102.17) ; v3(48.12,79.01) 55.18,71.94 61.61,71.94 64.18,69.38 67,69.38 67.53,68.85 75.76,68.85 78.63,71.72 80.58,71.72 v3(81.93,73.06) 83.43,74.56 94.4,74.56 95.9,76.06 95.9,77.38 v3(95.93,77.41) ; v3(194.53,67.3) 193.56,66.33 191.4,66.33 190.55,65.48 190.55,65.19 v3(190.89,64.85)
  IN2 w0.508: v3(194.53,67.3) 197.22,69.99 197.22,77.25 198.3,78.33 200,78.33 200.65,77.68 201.69,77.68 202.17,78.17 202.17,79.84 200.04,81.98 199.13,81.98 198.01,83.1 198.01,84.05 197.82,84.24 197.82,88.54 197.53,88.84 197.53,94.96 194.02,98.46 194.02,98.94 192.78,100.19 192.78,103.06 188.13,107.71 188.13,108.95 187.37,109.71 187.37,111.26 186.76,111.87 186.76,114.02 v2(186.38,114.41) ; v3(218.84,36.92) 216.35,39.41 215.2,39.41 208.89,45.72 205.3,45.72 199.29,51.73 193.13,51.73 v3(189.83,55.03) ; v2(201.36,126.15) 200.78,125.56 200.78,123.68 203.14,121.32 v3(203.14,120.22) 202.02,120.22 201.8,120 v2(200.82,120) ; v3(94.63,139.99) 94.15,139.51 93.16,139.51 90.21,142.45 87.21,142.45 86.34,143.33 84.83,143.33 84.41,143.75 84.41,147.17 86.53,149.29 86.53,155.37 84.22,157.68 84.22,160.69 87.84,164.31 87.84,169.38 89.25,170.79 90.83,170.79 96.82,176.77 v3(101.62,176.77) ; v3(72.78,95.28) 72.35,95.28 69.94,92.87 69.94,90.77 68.65,89.47 68.65,86.98 65.09,83.43 59.88,83.43 58.41,84.9 50.72,84.9 48.12,82.3 v3(48.12,79.01) 47.54,78.42 39.92,78.42 37.68,76.19 v3(26.81,76.19) 26,77 26,79.01 23.31,81.7 23.31,87.77 21.11,89.97 21.11,95.95 21.89,96.73 21.89,108.19 22.65,108.95 22.65,111.57 22.32,111.9 22.32,114.79 25.9,118.38 25.9,119.48 v3(25.89,119.48) 26.1,119.7 61.71,119.7 62.93,118.48 v3(65.42,118.48) ; v3(320.79,176.49) 320.79,177.84 319.8,178.83 319.27,178.83 316.91,176.47 v3(316.2,176.47) 316.2,177.2 315.69,177.71 282.24,177.71 v3(281.47,178.47) ; v3(341.39,161.58) 340.91,161.58 338.42,164.07 328.69,164.07 328.29,164.48 312.36,164.48 v3(311.57,165.26)
  IN3 w0.508: v3(143.19,108.22) 143.76,108.79 146.17,108.79 146.99,107.96 150.21,107.96 151.07,108.83 166.44,108.83 166.69,108.57 ; v3(26.81,76.19) 26.81,76.16 26.08,75.42 26.08,67.7 21.91,63.54 4.33,63.54 3.37,62.57 3.37,31.6 18.47,16.5 32.25,16.5 32.7,16.95 v3(33.04,16.95) ; v2(111.13,143.64) 108.93,143.64 102.78,137.5 v3(99.46,137.5)
  BOTTOM w0.381: C458.2 90.86,140.33 U86.5
  BOTTOM w0.508: 96.16,137.96 95.65,137.96 94.63,138.98 v3(94.63,139.99) ; v3(152.42,126.17) 152.42,124.01 153.06,123.37 154.31,123.37 v3(154.88,123.94) ; C458.2 90.85,139.71 v6(92.67,137.89) 93.62,136.94 96.28,136.94 ; v3(168.39,107.17) 168.39,108.61 167.37,109.63 167.37,111.19 v3(166.87,111.7) 166.23,111.06 164.05,111.06 162.75,112.36 v3(162.75,113.7) ; v3(209.54,140.65) 209.54,141.54 211.29,143.29 215.48,143.29 216.7,142.07 220.36,142.07 ; v3(25.89,119.48) RV2805.1 ; v3(95.93,77.41) 96.25,77.41 96.28,77.43 96.51,77.43 96.71,77.63 CV87.1 96.57,77.85 UV14.5 ; v2(134.79,157.12) 134.24,157.67 127.94,157.67 127.29,158.32 125.82,158.32 v3(125.06,159.08) ; R228.2 313.88,175.91 314.11,175.68 315.79,175.68 316.2,176.08 v3(316.2,176.47) ; PR156.1 81.93,72.5 v3(81.93,73.06) ; v3(33.04,16.95) PR104.1
  vias: v2(181.17,130.89) v2(181.88,130.96) v2(221.2,143.34) v2(221.2,142.68) v2(221.68,144.46) v2(221.83,143.67) v2(221.83,143.09) v2(221.81,142.5) v2(221.96,145.07) v2(222.44,142.5) v2(222.55,145.38) v2(222.55,144.66) v2(222.49,143.67) v2(222.47,143.09) v3(96.54,128.08) v3(97.2,128.08) v3(97.91,128.05) v3(98.64,128.08) v3(169.03,107.17) v3(169.6,106.89) v3(170.17,107.23) v3(170.32,138.98) v3(170.75,138.49) v3(178.53,119.98) v3(178.53,119.34) v3(178.53,118.07) v3(194.21,111.11) v3(194.2,109.05) v3(194.84,111.11) v3(194.83,109.05) v3(201.84,146.24) v3(202.07,152.59) v3(202.07,151.95) v3(202.38,145.86) v3(203.37,154.01) v3(203.4,153.38) v3(203.42,152.74) v3(203.45,152.11) v3(205.07,154.65) v3(205.34,154.05) v3(211.17,119.67) v3(211.17,119.01) v3(211.17,118.32) v3(211.85,119.67) v3(211.85,119.01) v3(211.85,118.32) v3(212.36,129.32) v3(212.39,128.69) v3(212.97,129.63) v3(213,128.99) v3(213.43,184.21) v3(218.13,181.32) v3(218.15,181.95) v3(232.17,80.43) v3(232.17,79.79) v3(232.17,79.16) v3(232.17,78.52) v3(254.91,164.25) v3(254.91,163.61) v3(254.91,162.98) v3(255.54,164.25) v3(255.54,163.61) v3(255.54,162.98) v3(259.07,150.96) v3(259.07,150.3) v3(259.73,150.96) v3(259.71,150.3) v3(260.34,150.33) v3(260.37,150.96) v3(262.45,150.86) v3(262.42,150.23) v3(267.71,182.18) v3(267.68,181.52) v3(268.42,181.44) v3(268.47,182.13) v3(269.13,182.13) v3(269.13,181.47) v6(97.45,134.96) v6(231.37,78.55)
+3.3V_ALW2: length 545.2
  TOP w0.203: PU51.3 210.82,156.41 v3(210.64,156.23)
  TOP w0.33: PU506.5 151.12,168.96 150.14,167.98 150.14,166.5 149.71,166.06 149.23,166.06 v3(149.04,165.87)
  TOP w0.381: PU506.5 151.12,169.5 150.49,170.13 PC515.1 ; CC82.1 191.55,62.05 UC7.5
  TOP w0.508: PR508.1 152.16,162.6 152.67,162.09 v3(152.67,160.31) ; v2(135.5,147.15) 135.07,147.15 134.68,147.54 PR550.1 136.11,148.27 137.86,150.02 v2(137.86,152.09) PR557.1 ; R367.2 156.66,119.04 156.36,119.04 155.84,119.04 155.61,119.26 153.96,119.26 153.81,119.42 v2(153.69,119.42) 151.47,119.42 148.56,122.33 147.32,122.33 v6(146.44,123.21) 144.92,124.73 v3(144.92,126.34) ; PR446.1 110.94,138.18 v3(110.81,138.31) ; PR526.2 137.81,139.42 v2(137.81,139.74) ; PR505.1 145.6,153.83 145.88,154.11 PR532.1 v2(147.37,154.11) ; v3(141.27,139.84) PR539.2 141.27,137.55 142.83,135.99 143.23,135.99 144.28,134.95 v3(144.28,134.59) ; PR440.1 122.71,136.47 v2(123.08,136.1) ; PC515.1 PR568.2 ; v3(178.96,111.21) 177.64,109.89 166.39,109.89 165.84,109.34 165.38,109.34 165.16,109.12 165.16,108.69 164.76,108.29 R108.1 164.48,108.11 v3(163.95,107.58) ; PC51.2 210.25,153.11 v2(210.57,153.42) ; CC82.1 v3(191.58,61.33) ; v3(154.75,152.64) 155.44,152.64 PR518.2 155.77,151.55 155.01,151.55 154.37,150.91 PR522.1 154.02,149.82 155.24,148.6 163.08,148.6 v3(163.45,148.97) ; PR521.1 150.94,156.25 v3(150.61,156.58) ; PU503.5 156.27,155.02 PC507.1 155.26,155.3 v3(155.77,155.82) ; v3(130.29,146.65) PR538.1
  IN1 w0.508: v2(147.37,154.11) 145.99,154.11 145.1,153.22 138.37,153.22 137.86,152.71 v2(137.86,152.09) ; v3(144.28,134.59) 144.28,133.67 144.92,133.02 v3(144.92,126.34) ; v3(152.67,160.31) 152.67,158.63 v3(150.61,156.58) ; v3(71.11,122.24) 67.02,122.24 66.28,121.5 38.92,121.5 35.16,117.74 26.61,117.74 22.14,113.27 22.14,112.1 20.69,110.65 20.69,108.18 20,107.48 20,107.4 19.45,106.84 18.69,106.84 18.18,106.34 18.18,100.11 18.15,100.09 18.15,99.91 16.65,98.41 15.46,98.41 14.01,96.96 14.01,91.2 15.38,89.83 15.38,87.03 16.43,85.97 16.43,74.3 18.25,72.48 19.24,72.48 21.09,70.63 21.09,59.19 9.03,47.13 9.03,18.45 v2(8.96,18.38)
  IN2 w0.508: v2(210.57,153.42) 209.85,154.14 209.85,155.71 210.36,156.23 v3(210.64,156.23) ; v3(118.05,132.75) 118.02,132.73 104.56,132.73 103.29,131.46 98.4,131.46 90.81,123.86 82.29,123.86 79.78,121.36 75.29,121.36 74.41,122.24 v3(71.11,122.24) ; v3(178.96,111.21) 178.96,110.22 183.71,105.47 183.71,103.7 184.53,102.87 184.53,101.6 184.95,101.18 185.49,101.18 185.89,100.78 185.89,97.07 186.55,96.4 189.14,96.4 192.45,93.1 192.45,86.68 192.12,86.35 192.12,84.01 193.07,83.06 193.07,74.62 191.42,72.97 191.42,70.97 191.46,70.93 191.48,70.93 191.84,70.57 191.84,70.55 192.47,69.91 192.47,62.22 v3(191.58,61.33) ; v3(152.67,160.31) 152.67,157.26 153.91,156.02 155.57,156.02 v3(155.77,155.82) 155.77,153.66 v3(154.75,152.64)
  IN3 w0.508: v2(135.5,147.15) 134.99,146.65 v3(130.29,146.65) ; v3(150.61,156.58) 149.84,156.58 v2(147.37,154.11) ; v3(155.74,106.26) 155.74,106.55 156.12,106.93 157.67,106.93 158.91,108.16 163.44,108.16 163.95,107.66 v3(163.95,107.58) ; v3(141.27,139.84) 141.27,139.54 140.81,139.08 138.07,139.08 137.81,139.33 v2(137.81,139.74) 137.25,140.3 133.85,140.3 133.39,139.84 126.81,139.84 v2(123.08,136.1) 121.94,134.96 120.26,134.96 v3(118.05,132.75) 118.02,132.73 114.09,132.73 112.92,133.9 112.92,136.21 v3(110.81,138.31)
  BOTTOM w0.508: v2(153.69,119.42) 153.23,119.42 152.87,119.06 152.87,117.94 153.64,117.18 153.64,113.79 153.38,113.54 153.38,112.8 154.4,111.78 154.4,107.81 155.74,106.46 v3(155.74,106.26) ; v3(152.67,160.31) 152.67,160.41 149.48,163.6 149.48,165.43 v3(149.04,165.87) ; v3(163.45,148.97) 163.74,148.68 165.32,148.68 165.85,149.21 168.88,149.21 169.84,148.25 176.42,148.25 178.93,150.76 183.16,150.76 184.66,152.26 187.49,152.26 188.64,151.12 190.82,151.12 192.12,152.41 192.12,156.5 195.93,160.31 207.64,160.31 209.77,158.18 209.77,156.68 210.22,156.23 v3(210.64,156.23) ; RTCD1.3 8.96,18.14 v2(8.96,18.38) ; v2(135.5,147.15) 136.59,146.05 136.59,140.96 v2(137.81,139.74)
+3.3V_ALW_5048: length 59.6
  TOP w0.254: U37.A54 198.62,122.39 C331.1 ; v2(194.36,127.45) 194.36,127.6 194.08,127.87 U37.B5
  TOP w0.279: C332.1 183.76,127.77 185.72,127.77 186.1,127.39 U37.A17 ; C330.1 193.44,116.45 193.44,117.77 193.33,117.87 U37.A43
  TOP w0.305: v2(188.86,122.18) 188.86,122.18 188.86,121.98 188.52,121.64 U37.B30
  TOP w0.457: C330.1 192.8,116.32 v3(192.8,117) ; C331.1 198.92,123 v2(198.47,123)
  TOP w0.508: v2(184.28,120.59) 184.14,120.73 C329.1
  IN1 w0.508: v2(181.91,128.69) 193.12,128.69 v2(194.36,127.45) 195.01,128.1 196.26,128.1 197.07,127.3 197.07,126.35 197.55,125.87 197.55,123.91 v2(198.47,123)
  IN2 w0.508: v2(188.86,122.18) 188.86,122.02 188.39,121.55 185.08,121.55 184.28,120.75 v2(184.28,120.59)
  IN3 w0.508: v3(192.8,117) 192.8,116.75 191.91,115.86 187.32,115.86 184.28,118.9 v2(184.28,120.59) 183.64,121.23 183.64,122.35 182.92,123.07 182.92,127.01 v3(181.88,128.05)
  vias: v1(181.23,127.77)
+3.3V_ALW_5075: length 17.3
  TOP w0.279: U38.A41 165.94,129.89 165.74,130.09 165.74,131.04 v3(165.93,131.23) ; U38.A26 172.6,124.39 v2(172.74,124.52) ; v2(160.01,125.82) 160.08,125.89 U38.A52
  TOP w0.305: v2(167.43,117.45) 167.44,117.47 U38.A11 ; U38.B35 170.19,128.48 170.56,128.85 ; U38.B3 163.19,119.37 163.54,119.72 v2(163.54,119.9)
  TOP w0.508: C356.1 155.85,119.93 v3(156.1,119.67) ; v3(165.93,131.23) 166.26,131.56 C355.1 ; R461.1 153.09,118.17 153.55,118.63 v3(153.55,118.73) ; C354.1 158.05,130.47 158.39,130.14 v3(158.39,129.98) ; 170.56,128.85 170.96,129.25 v1(170.96,130.5) C351.1 v3(171.72,131.79) ; v3(173.88,127.77) 174.59,127.77 C350.1 ; C349.1 168.16,115.48 167.68,115.96 v2(167.4,115.96) ; R336.1 176.19,123.99 v3(176.34,123.84)
  vias: v3(170.17,136.82) v3(170.8,136.82)
+3.3V_ALW_PCH: length 225.4
  TOP w0.305: JAPS1.1 v3(226.08,72.59)
  TOP w0.381: v3(204.93,49.3) 204.58,48.94 v6(198.71,48.94) 175.39,48.94 171.61,52.73 171.61,53 171.09,53.52 RC3.1
  TOP w0.457: v3(190.52,55.66) 191.15,55.03 RC261.1
  TOP w0.508: v3(192.68,53.36) 191.82,54.22 RC261.1 ; RC30.1 184.88,76.24 RC190.1 RC74.1 RC192.2 RC186.2 ; v3(194.71,63.36) 194.71,63.41 195.09,63.79 195.09,65.87 v3(194.94,66.03) 194.94,66.23 194.63,66.53 194.59,66.53 194.54,66.59 193.67,66.59 193.41,66.84 RC265.1 ; v3(212.56,71.89) 208.04,71.89 207.03,70.88 203.75,70.88 203.19,70.32 199.86,70.32 198.82,71.36 v3(195.77,71.36) ; CC44.1 159.53,68.92 v2(159.66,68.79) ; v3(119.68,64.53) 119.68,63.41 107,50.74 104.05,50.74 102.73,49.41 RC102.2 ; RC28.1 184.93,73.14 184.78,72.99 v3(184.78,72.45) ; v3(154.65,71.03) 154.68,71 156.4,71 156.8,71.41 v2(157.47,71.41)
  IN1 w0.508: v3(154.65,71.03) 147.9,71.03 147.18,70.31 134.62,70.31 133.77,71.16 132.32,71.16 130.29,69.13 124.27,69.13 v3(119.68,64.53) ; v3(194.71,63.36) 194.71,60.95 193.92,60.16 191.74,60.16 190.54,61.35 190.08,61.35 189.75,61.68 188.48,61.68 187.72,60.92 v3(184.85,60.92) 184.85,61.48 184.55,61.78 183.1,61.78 v2(182.54,62.34)
  IN2 w0.381: v3(192.68,53.36) 192.68,53.77 192.87,53.97 202.43,53.97 204.64,51.76 204.64,49.59 v3(204.93,49.3)
  IN2 w0.457: v3(190.52,55.66) 189.55,56.63 187.7,56.63 186.55,57.77 185.31,57.77 v3(184.87,58.22)
  IN2 w0.508: v3(226.08,72.59) 225.68,72.59 224.93,73.34 224.93,74.33 223.03,76.24 220.39,76.24 v3(220.08,76.54)
  IN3 w0.508: v3(194.94,66.03) 195.19,66.03 195.77,66.61 v3(195.77,71.36) 193.03,74.1 185.39,74.1 184.78,73.49 v3(184.78,72.45)
  BOTTOM w0.254: v2(157.47,71.41) 157.44,71.41 157.06,71.03 UC1.AE20 156.86,71.03 UC1.AE21 ; UC1.AH14 159.95,69.08 159.66,68.78 v2(159.66,68.79) ; UC1.AC9 UC1.AA9 163.1,72.99 162.37,72.99 ; v3(184.78,72.45) 184.67,72.45 184.31,72.08 184.25,72.06 RP3.8
  BOTTOM w0.381: v3(173.98,68.39) 173.81,68.22 RC27.1 ; v2(160.09,73.44) 161.48,73.44 161.94,72.99 162.37,72.99
  BOTTOM w0.508: v3(220.08,76.54) 218.76,76.54 214.11,71.89 v3(212.56,71.89) ; v2(182.54,62.34) 182.21,62.01 RC175.2 ; 181.37,74 RC230.1 180.2,74.28 179.95,74.28 RC98.1 ; 179.09,72.88 RC37.2 RC36.2
  vias: v2(181.5,73.14) v3(174.39,68.9) v3(174.92,69.28) v3(175.56,69.23) v3(181.21,99.54) v3(184.8,76.95)
+3.3V_ALW_PCH_U41: length 4.7
  TOP w0.127: v1(169.87,142.19) 169.65,141.97 R411.2
  TOP w0.457: C387.1 167.61,142.15 166.28,142.15 165.91,141.78 U41.1
  TOP w0.508: C387.1 R411.2
+3.3V_ALWP: length 32.6
  TOP w0.127: v2(226.25,144.39) v1(225.53,144.39)
  TOP w0.254: PR51.1 208.83,155.21 207.84,155.21 v2(207.64,155.01)
  IN3 w0.254: v2(207.64,155.01) 207.64,153.75 207.97,153.43 208.75,153.43 210.86,151.32 210.86,143.75 211.52,143.09 215.38,143.09 216.63,141.85 223.71,141.85 v2(226.25,144.39)
+3.3V_AVCC: length 0.7
  TOP w0.508: v3(116.22,116.6) C444.1
  vias: v1(114.02,117.22) v3(115.05,117.44) v3(115.36,116.88) v3(115.88,117.26) v3(117.51,119.92) v3(117.8,118.86) v3(117.97,119.47) v3(118.13,120.08)
+3.3V_CAM: length 10.5
  TOP w0.127: 99.01,161.09 99.52,161.09 v6(100.77,162.33)
  BOTTOM w0.508: v3(98.11,160.57) 97.8,160.87 C451.1 96.28,160.87 95.6,160.18 90.24,160.18
+3.3V_CAM_Q:
  vias: v1(87.02,160.67)
+3.3V_DVCC: length 7.4
  TOP w0.203: v3(122.24,123.94) 122.06,123.76 U52.18 ; 122.32,125.74 121.94,125.36 U52.22
  TOP w0.508: v3(123.38,124.37) v3(122.75,124.37) 122.67,124.37 v3(122.24,123.94) ; R2582.2 R2584.2 111.04,123.45 R2591.2 v3(109.62,122.92) ; v3(108.68,122.92) R2590.2
  vias: v1(122.61,127.43) v3(122.58,128.56) v3(123.21,128.56) v3(123.21,127.9) v3(123.19,127.24)
+3.3V_GPU: length 37.5
  TOP w0.381: CV226.1 64.99,94.12 65.8,94.12 CV3054.1
  TOP w0.508: CV226.1 64.33,94.45 v3(63.95,94.83) ; RV2404.2 67.4,105.74 RV34.2 67.46,106.19 69.16,106.19 69.67,106.69 71.29,106.69 v2(71.64,107.05) ; CV3053.1 v3(71.59,91.2) ; RZ41.1 v2(61.72,87.66)
  BOTTOM w0.406: QC9.5 66.57,122.77 66.7,122.65 ; 66.7,122.65 RV49.1 ; 66.7,122.65 66.57,122.52 QC9.2
  BOTTOM w0.508: v3(75.71,115.99) 75.27,115.55 RV94.2 ; RV2647.1 v3(76.04,109.76) ; R347.2 75.91,98.26 75.91,97.7 75.52,97.31 v3(75.07,97.31) ; v2(70.05,118) 70.2,118.14 70.2,121.98 69.53,122.65 RV49.1 68.35,122.7 RV50.1 ; v3(76.06,107.35) 75.82,107.1 RV2651.1 ; RV35.2 v3(72.3,117.84) 72.61,117.52 QC8.2 QC8.5 ; RV2653.1 v3(76.07,111.65) ; v2(69.23,115.38) 68.25,115.38 RV48.2 ; RV2446.2 v2(70.88,115.77) ; RV2649.1 v3(76.09,113.45) ; v3(75.03,103.58) QC6.5
  vias: v1(68.37,94.99) v3(72.36,88.81) v3(72.36,88.18) v3(72.36,87.54) v3(86.07,76.03) v3(86.88,76.03) v3(87.68,76.06) v5(68.93,95.28)
+3.3V_HDD: length 6.3
  TOP w1.524: 224.02,118.55 224.02,116.5 223.96,116.44 223.96,116.26 223.05,115.35 220.36,115.35 220.36,115.35
  vias: v2(223.23,119.93) v2(223.66,120.38) v2(223.71,119.57) v6(222.74,120.23)
+3.3V_HDD_C: length 1.3
  BOTTOM w0.127: C113.1 224.71,124.24 v1(225,124.52)
+3.3V_LAN: length 184.5
  TOP w0.254: U23.4 v3(193.92,167.88) ; U23.30 196.42,173.62 196.56,173.77 196.56,174.74 v2(196.82,174.99) ; v3(190.77,171.23) 190.92,171.38 U23.39 ; U23.8 v3(195.92,167.88) ; U23.21 201.79,171.38 201.92,171.51 201.92,171.98 C193.1 ; U23.14 198.92,167.99 v3(199.08,167.83) ; U23.1 v3(192.42,167.63)
  TOP w0.406: C198.1 201.79,157.68 U24.5
  TOP w0.508: C198.1 201.54,157.93 v2(201.54,158.38) ; C188.1 207.41,144.16 206.96,143.71 R181.1 205.68,143.52 v3(204.99,143.52) ; v3(192.95,143.52) R176.2 R178.1 ; C482.1 v3(334.41,174.79) ; C193.1 202.76,172.33 203.09,172.66 v3(203.09,173.75) ; R172.1 R171.1 v2(197.42,156.28)
  IN1 w0.508: v3(235.37,183.43) 239.94,178.85 263.26,178.85 v3(264.79,177.33) ; v3(195.39,142.56) 194.43,143.52 v3(192.95,143.52)
  IN2 w0.508: v3(215.31,179.31) 218.05,179.31 222.62,183.88 234.92,183.88 v3(235.37,183.43) ; v3(264.79,177.33) 265.29,176.82 267.73,176.82 268.11,177.2 275.33,177.2 280.74,171.79 308.7,171.79 311.42,174.51 333.49,174.51 v3(333.77,174.79)
  IN3 w0.508: v3(195.39,142.56) 196.23,143.39 203.59,143.39 203.72,143.52 v3(204.99,143.52) ; v2(197.42,156.28) 197.42,154.24 191.81,148.63 191.81,144.66 v3(192.95,143.52)
  BOTTOM w0.457: v2(196.82,174.99) 196.56,174.99 195.8,174.23 195.8,173.96 195.8,173.96 195.8,173.84 195.8,173.84 195.8,173.27 195.49,172.96 C194.1
  BOTTOM w0.508: v3(190.77,171.23) C192.1 ; v3(202.63,167.91) C206.1
  vias: v3(205.15,174.71) v3(205.4,175.35) v6(214.33,176.57)
+3.3V_LAN_OUT: length 7.1
  TOP w0.102: C182.1 205.67,147.29 v6(206.43,148.04)
  TOP w0.203: U21.15 202.79,147.67 v2(202.94,147.52) ; v2(199.53,153.05) 199.71,152.87 U21.29
  TOP w0.254: v2(203.01,149.27) U21.19
  TOP w0.508: C182.1 205.87,146.06 R181.2 v2(204.98,145.11)
  vias: v2(197.86,145.04) v2(198.5,145.11)
+3.3V_LANP:
  vias: v1(213.41,182.42)
+3.3V_M: length 82.4
  TOP w0.203: v2(172.51,70.88) 172.65,70.88 173.89,72.12 173.89,72.45
  TOP w0.508: v3(212.74,70.27) 212.44,70.57 v6(210.42,70.57) 208.12,70.57 207.23,69.68
  TOP w1.524: 204.51,69.15 198.08,69.15 197.01,70.22 192.65,70.22
  IN2 w1.27: 205.38,79.69 205.38,75.2 203.98,73.81 203.98,69.79 204.26,69.51 ; 192.4,107.35 197.15,102.6 197.15,98.99 200.78,95.36 200.78,90.8 201.23,90.34 201.23,86.07 203.45,83.85 203.45,82.25 203.75,81.95 203.8,81.95
  IN3 w1.016: 180.38,72.78 181.22,71.94 183.48,71.94 184.6,70.83 189.25,70.83
  BOTTOM w0.254: UC1.Y8 163.55,73.75 v2(163.73,73.93)
  BOTTOM w0.508: U2.8 192.86,70.34 192.04,71.16 C6.1 v3(191.23,70.32) ; U1.8 212.94,67.22 C5.1 213.27,67.27 213.66,67.65 213.66,69.35 v3(212.74,70.27) ; v2(178.04,75.5) 177.99,75.55 R1.1 ; R2.1 172.54,70.07 172.54,70.8 172.51,70.83 v2(172.51,70.88)
  vias: v3(179.16,73.65) v3(179.8,73.65) v3(190.59,70.32) v3(190.8,108.19) v3(191.22,107.72) v3(204.13,80.81) v3(204.79,80.83) v3(206.59,69.89) v3(206.59,69.23) v3(206.59,68.39)
+3.3V_PCIE_WWAN: length 11.4
  TOP w0.508: C252.1 C250.1 v2(240.6,141.86)
  BOTTOM w0.508: JMINI2.52 245.09,164.9 C248.1 v3(246.02,164.93) ; v3(247.31,164.27) 247.71,163.87 R226.2 247.85,163.46 Q30.5 ; R216.1 v2(246.52,154.88) ; R480.2 v3(246.22,162.65) ; R217.1 v2(246.51,157.55) ; JMINI2.24 v3(240.81,153.7)
  vias: v2(235.5,160.37) v2(235.5,159.76) v2(236.97,145.43) v2(237.56,145.43) v3(240.55,141.21) v3(241.24,141.06) v3(241.87,141.01) v3(243.09,133.4) v3(243.78,133.4) v3(244.57,133.4) v3(245.38,133.4) v3(249.32,161.3) v3(249.32,160.65) v3(249.32,160.02) v3(249.38,159.39) v3(249.95,161.88) v3(249.95,161.24) v3(249.95,160.61) v3(249.96,159.97) v6(234.88,159.89)
+3.3V_PCIE_WWANP:
  vias: v1(259.77,156.45)
+3.3V_RUN: length 1023.1
  TOP w0.254: U83.13 300.65,167.73 300.9,167.98 ; v3(98.06,141.95) JLVDS1.38
  TOP w0.305: JPWR1.3 313.75,168.14 313.96,167.93 C1189.1
  TOP w0.381: v2(160.33,77.44) 160.29,77.41 159.6,77.41 CC59.1
  TOP w0.406: Q122.2 Q122.5
  TOP w0.432: v3(16.86,109.17) 17,109.17 17.31,108.85 Q122.5
  TOP w0.457: v3(186.1,76.87) 186.58,76.39 186.58,75.92
  TOP w0.508: v3(180.33,170.09) 181.42,170.09 181.79,170.45 R44.2 ; CC9.1 194.86,56.17 v3(194.86,55.53) ; CC9.1 195.33,56.43 197.55,58.65 v3(197.55,62.17) ; CC9.1 194.42,56.43 UC3.5 ; v3(169.99,158.03) R232.2 R40.2 170.72,158.94 R42.2 170.72,160.79 R91.2 ; v3(211.34,124.5) 211.84,124.5 212.15,124.19 RC286.1 ; R484.1 188.75,132.19 188.78,132.16 R419.1 187.89,132.29 187.89,132.88 v3(188.03,133.01) ; v2(149.93,24.95) 149.51,25.37 CD24.1 CD25.1 ; 187.29,143.72 187.06,143.5 187.06,141.33 185.34,139.61 v3(184.88,139.61) ; C2972.1 301.29,169.31 300.41,170.19 R2633.1 R2635.1 R2636.1 ; C2972.1 301.25,168.89 301.25,168.33 300.9,167.98 ; C2972.1 302.23,168.75 v3(302.23,166.86) ; v2(224.39,27.87) 224.49,27.77 RD10.2 CD60.1 CD61.1 227.22,27.44 227.63,27.04 228.37,27.04 228.42,27.09 v3(228.44,27.09) ; v3(202.1,58.44) RC38.2 ; v3(296.13,166.87) 296.13,167.27 295.34,168.06 295.34,169.67 295.86,170.19 R2637.1 ; R2631.1 301.77,159.65 301.46,159.34 v3(300.99,159.34) ; R69.2 R55.2 173.09,150.58 171.69,149.19 R64.1 167.78,148.93 164.51,148.93 163.36,150.07 162.55,150.07 162.12,149.64 U7.8 160.85,149.64 160.26,150.23 C34.1 R65.1 158.92,151.09 158.54,151.47 v3(158.54,151.73) ; v3(102.38,112.41) 106.68,112.41 107.34,113.07 v3(107.34,113.31) 107.13,113.52 R170.1 R168.1 ; RC147.1 RC284.1 RC193.1 RC218.1 RC291.1 RC282.1 RC199.2 RC140.1 175.66,98.21 176.55,99.1 177.21,99.1 178.32,97.98 RC290.1 178.76,97.65 179.01,97.4 180.36,97.4 180.97,96.79 v3(180.97,95.44) 180.97,94.6 180.58,94.22 RC166.1 RC137.1 RC289.1 RC149.1 RC285.1 175.99,94.4 RC283.1 ; v3(143.55,134.68) 143.02,134.68 140.39,137.31 R360.1 ; v3(176.11,117.77) 175.73,117.77 R376.1 ; R54.2 188.56,162.34 v3(189.22,161.68) ; C2990.1 187.39,166.59 v3(187.39,166.6) 188.12,166.6 188.31,166.79 R556.1 ; v3(176.29,125.18) 175.99,124.88 R408.1 R35.1 ; v3(199.58,83.21) 200.61,84.24 C268.1 201.2,84.24 202.06,85.1 JBIO1.1 ; L49.1 v3(125.86,128.21) ; R473.1 v3(12.72,113.19) ; v3(314.65,166.41) 314.52,166.53 C1189.1 ; v3(201.64,124.54) 201.98,124.88 R304.1 ; R358.1 164.21,112.72 164.21,113.12 v2(164.28,113.19) 164.66,113.58 164.66,113.9 164.52,114.03 164.52,114.05 164.35,114.22 R362.1
  TOP w1.016: 216.18,142.81 217.35,141.64 218.58,141.64 225.95,141.64 227.52,143.22 238.7,143.22 239.28,143.8 244.44,143.8
  TOP w1.27: 221.33,61.53 221.33,69.24 212.77,77.8 212.77,78.43 209.77,78.43 209.72,78.37
  IN1 w0.508: v3(298.97,159.34) 299.63,158.69 300.99,158.69 ; 300.99,158.69 v3(300.99,159.34) ; 300.99,158.69 300.99,157.33 300.63,156.96 300.63,155.31 v2(300.65,155.28) ; v3(194.86,55.53) 194.86,56.31 197,58.44 v3(202.1,58.44) ; 172.99,76.92 173.17,77.1 173.19,77.08 175.62,77.08 v2(175.8,76.9) ; v3(199.84,80.56) 199.93,80.64 199.93,82.87 v3(199.58,83.21) ; v2(164.28,113.19) 164.63,112.84 172.87,112.84 173.54,113.5 v3(173.54,113.51) ; v3(188.03,133.01) 189.93,131.1 193.79,131.1 194.23,130.67 194.23,129.91 194.73,129.41 196.26,129.41 196.71,129.86 199.13,129.86 200.42,128.56 200.42,125.74 201.63,124.54 v3(201.64,124.54) ; v3(163.41,156.4) 163.21,156.4 v3(158.54,151.73) ; v3(143.55,125.69) v3(143.55,134.68)
  IN1 w1.016: 93.62,60.36 93.28,60.7 93.28,65.61 93.28,65.62 93.28,66.03 94.99,67.73 94.99,72.65 96.66,74.33
  IN1 w1.524: 76.07,23.42 77.84,25.18 80.27,25.18 81.14,24.31 81.14,21.3 82.96,19.49 82.96,17.53 85.32,15.17 87.71,15.17 88.64,14.25 90.88,14.25 ; 74.82,23.2 73.22,23.2 69.49,19.47 65.24,19.47 v3(64.35,18.58) 62.83,20.1 58.09,20.1 57.4,20.79 57.4,22.15 56,23.56 48.33,23.56 47.06,24.83 40,24.83 37.28,22.11 34.76,22.11
  IN2 w0.508: v3(184.88,139.61) 184.88,137.53 183.53,136.18 183.53,134.58 185.54,132.57 ; v3(186.1,76.87) 186.1,76.36 186.38,76.08 v3(186.38,73.37) ; v2(149.93,24.95) 149.93,25.19 154.44,29.7 222.16,29.7 223.98,27.87 v2(224.39,27.87) ; 101.62,77.89 102.53,76.97 109.97,76.97 111.12,78.12 115.26,78.12 v2(116.14,79.01) ; v3(98.06,141.95) 94.53,141.95 91.96,144.51 88.54,144.51 v3(88.36,144.33) ; v2(51.5,28.78) 51.54,28.78 51.88,29.12 51.88,31.12 v2(51.31,31.69) 53.74,34.12 60.69,34.12 63.44,31.38 62.78,30.72 62.78,28.56 v3(63.56,27.77) ; v3(125.86,128.21) 126.56,127.52 v3(126.56,124.29) ; 315.33,170.27 318.79,173.72 336.55,173.72 336.6,173.77 336.67,173.77 v3(336.92,174.03) ; 183.66,83.2 183.48,83.37 180.92,83.37 178.22,80.68 175.25,80.68 v3(174.62,80.05)
  IN2 w1.016: 184.39,83.35 184.39,85.62 v3(183.89,86.13) 180.97,89.05 v3(180.97,95.44) 180.97,96.99 176.98,100.98 176.98,101.21
  IN3 w0.508: v3(177.14,77.74) 177.14,75.58 176.09,74.52 176.09,71.77 v2(177.92,69.94) ; v3(197.55,62.17) 194.71,65.01 194.02,65.01 193.59,65.44 193.59,69.25 194.1,69.76 194.1,71.92 192.65,73.37 v3(186.38,73.37) ; v3(186.1,76.87) 186.1,77.28 186.67,77.85 186.67,81.56 ; v3(164.76,99.66) 165.65,99.66 165.93,99.94 170.65,99.94 172,101.28 174.18,101.28 176.04,103.14 ; v3(16.86,109.17) 16.86,109.77 v2(20.08,112.99)
  IN3 w1.016: 87.47,46.72 87.7,46.72 88.87,45.55 88.87,36.33 86.91,34.38 86.91,29.35 89.55,26.71 92.93,26.71 94.66,24.98 94.66,23.86 96.05,22.47 98.11,22.47 99.46,21.12 99.46,19.44 98.7,18.68 98.06,18.68 97.25,17.87
  IN3 w1.524: 144.49,129.3 144.49,130.49 151.93,137.93 151.93,145.99 154.52,148.58 154.52,150.58 157.04,153.1 157.04,163.82 158.64,165.42
  BOTTOM w0.102: 187.04,172.91 186.83,172.71 186.48,172.71 C2988.1
  BOTTOM w0.203: U39.23 186.73,171.82 186.45,172.1 C2988.1 ; PU300.21 87.06,90.12 v2(87.26,90.32) 87.06,90.52 PU300.20 ; U27.13 19.26,24.4 19.11,24.25 18.58,24.25 ; C210.1 27.57,26.8 v2(26.96,26.8) U27.42 ; v3(187.39,166.6) 187.13,166.86 U39.4 ; U27.11 20.99,23.1 20.66,22.77 19.96,22.77 19.45,22.26 ; U27.23 19.26,28.4 18.92,28.74
  BOTTOM w0.254: v3(336.92,174.03) 336.5,174.45 JIO1.15 ; CC41.1 97.86,73.8 97.86,75.39 99.37,76.9 UC6.14 ; RP9.1 RP9.2 RP9.3 RP9.4 177.05,77.65 v3(177.14,77.74) ; v3(183.89,86.13) 183.73,85.97 RP8.1 RP8.2 RP8.3 RP8.4 ; v2(163.76,74.89) 163.55,74.68 UC1.V8 163.52,74.41 163.11,74 UC1.W9 ; UC1.K16 UC1.K14 160.33,78.83 v2(160.33,77.44) ; UC1.U8 163.55,75.39 UC1.T9 162.49,75.84 162.02,75.37 v2(162.02,75.31)
  BOTTOM w0.356: v2(224.39,27.87) 224.28,27.76 JDIMM2.199 ; v2(149.93,24.95) 149.78,25.1 JDIMM1.199
  BOTTOM w0.381: U30.5 247.6,149.4 C338.1
  BOTTOM w0.508: v2(177.92,69.94) 177.61,69.94 177.41,70.14 RC12.2 RC170.2 RC11.2 ; CC41.1 97.22,74.1 v3(97.22,74.64) ; R212.1 17.52,25.03 17.91,24.65 C226.2 ; v2(51.31,31.69) 51.44,31.82 PR626.1 ; C226.2 17.71,24.06 C224.2 16.73,24.06 15.48,25.32 L35.1 15.33,25.32 v3(14.66,25.98) ; C226.2 18.58,24.25 ; v3(173.96,168.82) 174.46,168.31 L5.1 ; v3(16.86,109.17) 16.86,109.13 15.79,109.13 15.41,109.51 R460.1 ; PR603.1 63.52,27.82 v3(63.56,27.77) 63.56,26.93 ; v3(225.98,60.05) 226.78,60.05 231.74,55.09 231.74,48.63 231.36,48.25 229.91,48.25 229.45,47.79 229.45,45.93 230.52,44.87 231.94,44.87 232.45,44.36 232.45,40.22 231.41,39.18 231.41,37.68 231.05,37.32 231.05,34.91 230.06,33.92 230.06,27.39 229.76,27.09 v3(228.44,27.09) ; 21.76,111.77 23.1,110.43 23.1,84.11 27.19,80.02 v6(33.11,80.02) 44.69,80.02 49.5,75.22 63.95,75.22 68.09,71.08 68.09,65.06 72.66,60.49 82.06,60.49 83.47,59.07 86.37,59.07 87.75,57.7 ; 21.76,111.77 21.76,112.53 21.3,112.99 v2(20.08,112.99) 19.07,114.01 13.53,114.01 v3(12.72,113.19) ; 21.76,111.77 21.27,111.29 R475.2 18.86,111.29 18.21,110.64 QZ22.2 ; v3(253.71,148.6) 248.4,148.6 C338.1 ; 102.16,124.75 C456.1 RC315.2 ; L2.2 180.23,169.99 v3(180.33,170.09) ; v3(187.16,173.87) 187.16,173.04 187.04,172.91 ; RC81.1 185.13,82.03 v3(185.26,81.9) ; v2(172.65,74.88) 173.09,74.43 RC222.1 RC138.1 ; v3(211.34,124.5) 212.82,123.02 212.82,115.61 216.25,112.18 216.25,105.62 217.64,104.23 223.94,104.23 R126.1 ; v3(177.14,77.74) 177.17,77.76 RC55.1 RC80.1 178.25,79.49 RC183.1 ; C440.1 84.66,156.62 Q126.3 85.89,156.06 86.33,155.62 86.33,150.44 84.83,148.94 84.83,146.01 86.6,144.23 87.62,144.23 v3(87.72,144.33) ; RC148.1 175.3,76.9 v2(175.8,76.9) ; 63.56,26.93 PR600.1 ; 63.56,26.93 63.56,19.37 v3(64.35,18.58) ; RC259.1 114.93,82.74 114.93,80.22 v2(116.14,79.01) ; v3(214.24,132.47) 213.15,132.47 205.55,124.88 201.98,124.88 v3(201.64,124.54) ; v3(17.78,19.79) C225.2 17.78,20.94 18.43,21.58 C212.1 18.71,21.61 18.71,21.75 19.21,22.26 19.45,22.26 ; v2(300.65,155.28) 301.23,155.28 R150.1 ; RC185.1 174.23,79.67 v3(174.62,80.05) ; v3(180.39,76.67) 180.39,77.13 180.83,77.56 CC8.1 181.95,77.76 UC2.5
  BOTTOM w1.016: 89.86,136.35 91.2,135 91.2,126.48 92.93,124.75 105.02,124.75 105.91,123.86 ; 85.36,48.5 84.73,49.14 84.73,54.67 87.75,57.7 92.47,57.7 93.49,58.71 ; 87.65,143.29 88.1,142.84 88.1,139.23 88.69,138.64 88.69,137.5
  vias: v2(13.35,29.63) v2(13.35,28.99) v2(77.64,88.23) v2(77.64,87.64) v2(87.19,80.2) v2(87.77,80.2) v2(88.36,80.2) v2(175.89,103.88) v2(176.47,103.88) v2(177.08,103.86) v2(193.95,155.51) v2(194.28,155.99) v3(31.44,22.31) v3(32.07,22.62) v3(32.12,21.88) v3(86.81,47.69) v3(86.81,47.05) v3(94,59.6) v3(94.25,60.24) v3(96.16,16.29) v3(96.5,16.84) v3(96.92,16.29) v3(97.22,75.3) v3(101.08,112.38) v3(101.72,112.38) v3(106.98,123.91) v3(106.98,123.28) v3(111.62,113.84) v3(111.64,113.17) v3(112.36,113.85) v3(112.41,113.11) v3(113.58,114.16) v3(113.91,113.52) v3(114.24,114.13) v3(114.57,113.32) v3(131.64,114.26) v3(131.56,111.92) v3(132.22,111.92) v3(132.27,114.26) v3(132.91,114.26) v3(132.99,111.92) v3(143.55,124.98) v3(143.55,124.29) v3(160.59,166.1) v3(160.57,165.34) v3(163.69,165.62) v3(169.66,165.37) v3(171.31,118.58) v3(171.49,119.21) v3(171.95,118.76) v3(181.35,125.82) v3(181.32,125.18) v3(183.2,108.39) v3(183.68,107.91) v3(184.19,107.4) v3(185.89,81.94) v3(189.22,160.72) v3(189.3,167.32) v3(189.86,167.65) v3(198.62,80.9) v3(199.25,80.9) v3(211.34,127.67) v3(211.34,127.04) v3(211.34,126.4) v3(211.34,125.77) v3(211.34,125.13) v3(214.49,142.3) v3(214.87,132.47) v3(215.2,142.3) v3(244.64,143.14) v3(245.25,143.6) v3(257.57,163.74) v3(257.83,164.38) v3(258.21,163.74) v3(258.46,164.38) v3(258.84,163.74) v3(259.1,164.38) v3(259.48,163.74) v3(259.73,164.38) v3(292.47,162.69) v3(293.11,162.69)
+3.3V_RUN_AIN: length 10.9
  TOP w0.102: v2(21.08,31.86) v6(21.08,32.45)
  BOTTOM w0.203: C214.1 21.08,21.24 21.08,21.93 21.79,22.64 U27.9 ; U27.27 21.39,30.12 21.1,30.42 21.1,31.15 21.65,31.71 21.65,32.23 C215.1
  BOTTOM w0.381: C215.1 21.08,32.29 v2(21.08,31.86)
  BOTTOM w0.508: v2(14.32,23.35) 14.34,23.38 C213.1 14.34,24.59 14.08,24.85 L35.2 ; C214.1 v2(20.52,20)
+3.3V_RUN_AUDIO: length 13.3
  TOP w0.102: v3(271.54,164.96) v6(271.54,165.61)
  TOP w0.508: v3(315.28,156.25) 316.45,156.25 L37.2 316.02,157.03 v3(315.23,157.03)
  BOTTOM w0.254: U17.3 306.71,156.55 306.71,157.3 306.49,157.52 306.49,158.51 C120.1 ; C119.1 309.89,158.43 309.89,157.28 309.73,157.12 U17.9
  BOTTOM w0.508: C120.1 305.24,158.68 C118.1 304.52,158.72 v2(304.26,158.46) ; C119.1 310.44,158.68 C405.1 311.38,159.04 v3(311.38,157.9)
  vias: v3(270.55,163.97) v3(271.01,164.48) v3(271.29,163.71)
+3.3V_RUN_AUDIOP:
  vias: v1(268.41,179.37)
+3.3V_RUN_CARD: length 48.2
  TOP w0.102: v3(33.45,51.38) v6(33.45,52.03)
  IN1 w1.016: 17.54,28.61 17.42,28.74 17.42,32.3 17.92,32.8 19.85,32.8 20.59,33.54 20.59,50.2 27.32,56.93 32.78,56.93 34.05,55.66 34.05,54.49 33.45,53.89 v3(33.45,51.38)
  BOTTOM w0.508: v3(33.45,51.38) C240.1 C239.1
  vias: v2(17.48,27.93) v2(18.1,27.93) v3(33.47,50.48)
+3.3V_RUN_FFS: length 7.1
  TOP w0.102: 215.09,126.94 v1(214.32,126.94)
  TOP w0.254: U15.1 217.81,123.01 217.99,122.83 217.99,122.47 217.57,122.05 v3(217.57,121.6)
  TOP w0.305: C101.1 215.6,126.38 U15.8 ; C101.1 215.57,126.94 215.09,126.94 v3(215.04,126.99) ; C101.1 216.1,126.41 U15.7 ; U15.14 215.6,121.96 215.48,121.84 v3(215.48,121.63)
+3.3V_RUN_TPM: length 6.5
  TOP w0.381: C384.1 C202.1 183.3,134.43 U25.24 ; C203.1 179.47,134.85 180.05,135.43 U25.19
  TOP w0.508: C203.1 v3(178.76,134.28) ; C384.1 v3(184.29,134.96)
  vias: v1(181.42,145.81) v3(181.94,145.68) v3(181.98,144.92)
+3.3V_RUN_VDDA: length 11.9
  TOP w0.203: U6.C10 v5(176.61,161.12) ; U6.K6 v5(181.81,157.87) ; U6.H5 v5(180.51,157.22) ; U6.K7 v5(181.81,158.52) ; U6.H12 v5(180.51,162.42)
  TOP w0.508: C13.1 181.47,168.47 v3(181.47,167.75) 181.53,167.7 182.18,167.7 182.34,167.55 C15.1
  BOTTOM w0.508: v3(181.47,167.75) 181.14,168.09 L2.1 180.04,167.9 C16.1 180.04,166.01 C14.1 v1(180.28,163.44) 180.51,163.2 v5(180.51,162.42)
+3.3V_RUN_VDDIO: length 8.3
  TOP w0.102: v1(178.55,168.03) C27.1
  TOP w0.203: U6.C11 v5(176.61,161.77) ; U6.C12 v5(176.61,162.42) ; U6.K4 v5(181.81,156.57) ; U6.K11 v5(181.81,161.77) ; U6.K12 v5(181.81,162.42) ; U6.J4 v5(181.16,156.57) ; U6.C3 v5(176.61,155.92) ; U6.C4 v5(176.61,156.57)
  TOP w0.254: U6.K3 181.49,156.25 v5(181.81,156.57)
  TOP w0.508: v3(176.65,168.29) 176.65,169.01 177.05,169.41 C29.1 C27.1
+3.3V_SUS: length 399.3
  TOP w0.102: v6(155.07,129.09) 155.48,128.69 v3(155.95,128.69)
  TOP w0.254: RP15.6 156.36,127.92 155.95,128.33 v3(155.95,128.69) 156.21,128.42 RP15.5
  TOP w0.508: v3(139.46,108.5) 140.48,107.48 146.75,107.48 C3003.1 C3002.1 R3000.1 ; C633.1 86.35,15.25 86.35,17.03 v3(86.45,17.13)
  IN1 w1.016: 203.27,14.21 203.24,14.18 180,14.18 178.48,15.71 162.04,15.71 159.55,18.2 135.45,18.2 134.66,17.41 134.66,15.89 133.72,14.95 123.79,14.95
  IN2 w0.508: v3(91.66,20.87) 91.84,20.87 92.73,19.98 92.73,19.32 93.11,18.93 107.03,18.93 107.59,18.38 120.82,18.38 121.29,17.9 121.29,16.43 v3(121.96,15.76) ; v3(122.9,15.76) 123.08,15.94 123.08,17.84 121.81,19.11 108.16,19.11 106.51,20.77 106.01,20.77 105.96,20.71 103.63,20.71 102.96,21.38 102.96,21.91 101.74,23.13 93.8,23.13 92.27,21.6 v3(91.66,21.6)
  IN2 w1.016: 207.48,59.63 207.84,59.98 207.84,59.98 207.84,74.54 206.65,75.73 206.65,81.28 204.72,83.2 204.72,84.49 204.21,85 204.21,85 203.47,85.74 203.47,88.78 202.5,89.75 202.5,90.87 202.07,91.3 202.07,97.54 199.66,99.96 199.66,100.44 199.66,100.44 199.66,101.39 199.66,101.58 199.66,101.77 199.66,102.33 193.26,108.73 193.26,111.38 192.77,111.87 191.71,111.87 191.35,112.23
  IN3 w0.508: v3(139.46,108.5) 140.38,107.58 146.09,107.58 146.96,106.71 151.76,106.71 152.73,107.68 v2(155.81,107.68) ; 189.2,110.58 188.94,110.32 188.28,110.32 187.52,109.56 182.04,109.56 177.44,104.96 175.12,104.96 172.15,102 171.82,102 170.54,100.72 v3(169.68,100.72)
  IN3 w1.016: 205.98,13.78 225.82,13.78 229.94,17.89 229.94,23.58 229.81,23.71 229.81,25.43 230.57,26.19 230.57,27.7 230.01,28.26 230.01,32.09 223.23,38.87 221.78,38.87 220.06,40.6 220.06,44.79 218.96,45.88 217.32,45.88 213.76,49.45 213.76,51.2 213.57,51.39 213.57,51.39 212.21,52.75 212.21,54.67 207.51,59.37 207.38,59.37
  BOTTOM w0.508: v3(169.68,100.72) 169.68,101.15 169.04,101.79 163.23,101.79 160.08,104.94 160.01,104.94 159.18,105.77 158.29,105.77 157.95,106.11 157.95,106.53 157.53,106.95 156.54,106.95 v2(155.81,107.68) 155.24,108.25 155.24,113.15 154.27,114.11 154.27,119.16 155.46,120.36 156.19,120.36 156.63,120.8 156.63,124.34 156.57,124.41 156.57,124.56 156.48,124.65 156.48,126.33 156.57,126.42 156.57,128.07 v3(155.95,128.69) ; v3(86.45,17.13) 86.45,18.38 87.27,19.19 87.27,20.46 87.65,20.84 87.65,21.86 88,22.21 91.05,22.21 v3(91.66,21.6)
  vias: v2(206.49,59.61) v2(206.85,60.12) v3(189.58,111.14) v3(190.24,111.14) v3(204.26,14.01) v3(204.92,14.01)
