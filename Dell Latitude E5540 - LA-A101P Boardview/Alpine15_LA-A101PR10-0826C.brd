# Allegro board Alpine15_LA-A101PR10-0826C.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
GND on IN1 (solid shape): 191.71,156.73 191.71,155.15 191.56,155 190.95,155 190.8,154.85 190.8,154.09 190.95,153.94 191.71,153.94 191.86,153.78 191.86,152.23 191.58,151.95 189.2,151.95 187.62,153.53 187.62,156.76 187.8,156.93 191.51,156.93
GND on IN1 (solid shape): 204.76,143.22 204.99,143.14 205.22,143.22 205.55,143.22 205.91,142.86 205.91,139.71 205.55,139.36 201.77,139.36 201.36,139.76 201.36,142.89 201.69,143.22
GND on IN1 (solid shape): 20.2,64.76 20.2,60.39 10.04,50.23 9.52,50.23 9.21,50.53 9.21,51.62 12.79,55.21 13.91,55.21 13.91,55.15 13.92,55.1 13.94,55.04 13.97,54.99 14.01,54.95 14.05,54.91 14.09,54.88 14.14,54.85 14.19,54.84 14.25,54.83 14.3,54.82 14.36,54.83 14.41,54.84 14.47,54.87 14.51,54.89 14.56,54.93 14.59,54.97 14.62,55.02 14.65,55.07 14.66,55.12 14.67,55.18 14.67,55.23 14.66,55.29 14.65,55.34 14.62,55.39 14.59,55.44 14.56,55.48 14.51,55.52 14.47,55.55 14.41,55.57 14.36,55.58 14.3,55.59 14.25,55.59 14.19,55.58 14.14,55.56 14.09,55.53 14.05,55.5 14.01,55.46 13.97,55.42 13.94,55.37 13.92,55.32 13.91,55.26 13.91,55.21 12.79,55.21 16.18,58.6 16.18,64.82 16.55,65.19 19.78,65.19
GND on IN1 (solid shape): outline of 118 points within 78.4,63.26 83.96,70.88
GND on IN1 (solid shape): 9.71,97.6 12.53,97.6 13.07,97.06 13.07,89.45 13.57,88.94 13.57,85.63 13.3,85.36 12.7,85.36 12.7,85.21 12.66,85.2 12.5,85.14 12.37,85.03 12.26,85.01 12.2,85.11 12.2,86.14 12.68,86.98 11.94,87.6 1.05,87.6 1.05,89.53 6.63,89.53 7.16,89.75 7.38,90.28 7.38,91.78 7.16,92.31 6.63,92.53 1.05,92.53 1.05,94.75 7.74,94.75 7.89,94.49 8.14,94.31 8.26,94.27 8.38,94.25 8.96,94.44 9.2,95 9.2,97.57 9.2,97.62 9.71,97.62
GND on IN1 (solid shape): outline of 232 points within 1.39,36.71 14.55,65.19
GND on IN1 (solid shape): outline of 1799 points within 103.76,91.43 126.97,102.15
GND on IN1 (solid shape): outline of 2227 points within 0.25,0.25 344.65,190.65
GND on VCC (solid shape): outline of 38792 points within 0.25,0.25 344.65,190.65
GND on IN2 (solid shape): 151.96,96.53 151.96,93.53 151.22,92.8 148.58,92.8 148.12,93.26 148.12,96.63 148.25,96.76 151.73,96.76
GND on IN2 (solid shape): 225.77,45.4 225.77,42.2 225.26,41.69 221.02,41.69 220.82,41.9 220.82,44.59 220.41,45 220.41,45.73 220.49,45.81 225.36,45.81
GND on IN2 (solid shape): 67.43,114.41 67.43,111.62 66.87,111.06 63.67,111.06 62.4,112.33 62.4,114.82 62.58,115 66.84,115
GND on IN2 (solid shape): 204.86,143.17 204.99,143.14 205.13,143.17 205.43,143.17 205.86,142.73 205.86,142.25 205.45,141.85 205.45,139.23 205.32,139.1 202.05,139.1 201.39,139.76 201.39,142.86 201.69,143.17
GND on IN2 (solid shape): 94.42,106.19 94.45,106.19 94.53,106.11 94.53,98.61 93.31,97.4 84.77,97.4 84.04,98.13 84.04,99.32 90.16,105.45 91.58,105.45 92.26,106.13 92.26,106.14 92.92,106.79 93.82,106.79
GND on IN2 (solid shape): 82.79,68.85 82.79,65.47 81.35,64.02 81.35,63.41 81.14,63.21 79.7,63.21 78.04,64.86 78.04,67.52 77.44,68.13 77.44,68.96 77.89,68.96 77.89,68.9 77.9,68.85 77.92,68.8 77.94,68.75 77.97,68.71 78.01,68.67 78.05,68.64 78.09,68.61 78.14,68.59 78.19,68.58 78.25,68.57 78.3,68.58 78.35,68.59 78.4,68.61 78.45,68.64 78.49,68.67 78.53,68.71 78.56,68.75 78.58,68.8 78.6,68.85 78.6,68.9 78.6,68.96 78.6,69.01 78.58,69.06 78.56,69.11 78.53,69.15 78.49,69.19 78.45,69.23 78.4,69.25 78.35,69.27 78.3,69.28 78.25,69.29 78.19,69.28 78.14,69.27 78.09,69.25 78.05,69.23 78.01,69.19 77.97,69.15 77.94,69.11 77.92,69.06 77.9,69.01 77.89,68.96 77.44,68.96 77.44,69.84 78.06,70.46 81.18,70.46
GND on IN2 (solid shape): 191.81,156.58 191.81,154.73 191.75,154.63 191.64,154.65 191.04,154.37 191.64,154.09 191.75,154.1 191.81,154.01 191.81,152.69 191.48,152.36 188.51,152.36 186.1,154.77 186.1,156.58 186.38,156.86 191.53,156.86
GND on IN2 (solid shape): 9.71,97.6 12.4,97.6 12.7,97.3 12.7,89.61 13.47,88.84 13.47,85.34 13.38,85.25 12.7,85.25 12.7,85.21 12.66,85.2 12.5,85.14 12.37,85.03 12.26,85.01 12.2,85.11 12.2,86.14 12.68,86.98 11.94,87.6 1.05,87.6 1.05,89.53 6.63,89.53 7.16,89.75 7.38,90.28 7.38,91.78 7.16,92.31 6.63,92.53 1.05,92.53 1.05,94.75 7.74,94.75 7.89,94.49 8.14,94.31 8.26,94.27 8.38,94.25 8.96,94.44 9.2,95 9.2,97.52 9.2,97.61 9.71,97.61
GND on IN2 (solid shape): outline of 231 points within 1.39,36.71 28.62,64.93
GND on IN2 (solid shape): outline of 257 points within 22.96,40.05 30.24,65.19
GND on IN2 (solid shape): outline of 2231 points within 0.25,0.25 344.65,190.65
GND on IN3 (solid shape): 20.39,41.7 20.39,40.6 20.18,40.39 18.38,40.39 16.88,41.9 4.79,41.9 4.26,42.43 4.26,56.12 4.86,56.72 5.36,56.72
GND on IN3 (solid shape): 67.68,114.69 67.68,111.8 67.02,111.14 63.08,111.14 62.27,111.95 62.27,114.62 62.58,114.92 67.45,114.92
GND on IN3 (solid shape): 205.81,142.84 205.81,139.53 205.32,139.05 201.92,139.05 201.29,139.69 201.29,142.61 201.59,142.91 203.65,142.91 203.77,143.04 205.6,143.04
GND on IN3 (solid shape): 225.7,45.4 225.7,42.1 225.29,41.69 221.15,41.69 220.82,42.02 220.82,45.05 220.41,45.45 220.41,45.63 220.54,45.76 225.34,45.76
GND on IN3 (solid shape): 151.2,96.43 151.76,96.43 151.96,96.23 151.96,93.1 151.58,92.72 149.01,92.72 148.15,93.59 148.15,94.4 146.83,95.72 146.83,96.46 147.08,96.71 150.92,96.71
GND on IN3 (solid shape): 191.58,156.96 191.58,155.97 190.85,155.23 190.85,154.16 191.1,153.91 191.53,153.91 191.71,153.73 191.71,152.95 191.07,152.31 188.59,152.31 187.95,152.95 187.95,156.42 188.64,157.11 191.43,157.11
GND on IN3 (solid shape): 21.39,36.89 21.41,36.78 21.31,36.71 8.32,36.71 7.97,37.07 7.97,38.49 8.12,38.65 19.63,38.65
GND on IN3 (solid shape): 94.32,106.19 94.45,106.19 94.53,106.11 94.53,98.16 93.76,97.4 84.27,97.4 82.74,98.92 82.74,106.23 82.76,106.25 91.03,106.25 91.03,106.2 91.04,106.15 91.06,106.09 91.08,106.05 91.11,106 91.15,105.96 91.19,105.93 91.23,105.9 91.28,105.88 91.34,105.87 91.39,105.87 91.44,105.87 91.49,105.88 91.54,105.9 91.59,105.93 91.63,105.96 91.67,106 91.7,106.05 91.72,106.09 91.74,106.15 91.75,106.2 91.75,106.25 91.74,106.3 91.72,106.36 91.7,106.4 91.67,106.45 91.63,106.49 91.59,106.52 91.54,106.55 91.49,106.57 91.44,106.58 91.39,106.58 91.34,106.58 91.28,106.57 91.23,106.55 91.19,106.52 91.15,106.49 91.11,106.45 91.08,106.4 91.06,106.36 91.04,106.3 91.03,106.25 82.76,106.25 83.35,106.84 93.67,106.84
GND on IN3 (solid shape): 13.52,97.34 13.52,85.38 13.46,85.32 12.7,85.32 12.7,85.21 12.66,85.2 12.5,85.14 12.37,85.03 12.26,85.01 12.2,85.11 12.2,86.14 12.68,86.98 11.94,87.6 1.05,87.6 1.05,89.53 6.63,89.53 7.16,89.75 7.38,90.28 7.38,91.78 7.16,92.31 6.63,92.53 1.05,92.53 1.05,94.75 7.74,94.75 7.89,94.49 8.14,94.31 8.26,94.27 8.38,94.25 8.96,94.44 9.2,95 9.2,97.62 9.2,97.64 11.57,97.64 11.57,97.65 13.22,97.65
GND on IN3 (solid shape): outline of 173 points within 77.67,62.34 83.35,70.62
GND on IN3 (solid shape): outline of 473 points within 7.84,37.24 30.24,62.65
GND on IN3 (solid shape): outline of 1797 points within 103.53,91.65 127.02,102.98
GND on IN3 (solid shape): outline of 2213 points within 0.25,0.25 344.65,190.65
GND on GND1: outline of 220 points within 0.26,0.26 344.64,190.65 ; 59 cut-outs
GND on GND2: outline of 220 points within 0.26,0.26 344.64,190.65 ; 61 cut-outs
GNDA on TOP (solid shape): 299.29,147.88 299.29,146.88 298.75,146.34 295.37,146.34 294.74,146.97 294.74,149.44 294.85,149.55 297.62,149.55
GNDA on BOTTOM (solid shape): 325.4,153.43 325.78,153.43 325.78,152.84 326.27,152.84 326.27,153.43 326.74,153.43 326.86,153.3 326.86,151.88 326.66,151.68 325.39,151.68 325.14,151.93 325.14,153.35 325.21,153.43 325.4,153.43
GNDA on GND1, GND2: 291.31,144.33 291.02,144.62 291.02,145.88 295.83,150.68 303.75,150.68 303.82,150.75 303.9,150.75 304.03,150.87 305.38,150.87 305.4,150.86 305.4,150.17 305.7,149.87 311.17,149.87 311.55,150.25 311.55,152.86 312.75,152.86 312.81,152.79 315.59,152.79 316.75,153.96 316.75,156.4 317.11,156.76 321.7,156.76 322.01,156.45 322.01,155.86 322.9,154.98 324.4,154.98 324.6,154.77 324.6,153.65 325.03,153.22 326.43,153.22 333.7,160.49 333.7,161.32 333.98,161.61 337.12,161.61 337.6,161.12 340.4,161.12 340.48,161.04 340.48,159.22 340.17,158.91 337.68,158.91 336.11,157.34 336.11,156.73 323.71,144.33
GNDA on VCC: 291.31,143.67 291.02,143.96 291.02,145.88 295.83,150.68 303.75,150.68 303.82,150.75 303.9,150.75 304.03,150.87 305.38,150.87 305.4,150.86 305.4,150.17 305.7,149.87 311.17,149.87 311.55,150.25 311.55,152.86 312.75,152.86 312.81,152.79 315.59,152.79 316.75,153.96 316.75,156.4 317.11,156.76 321.7,156.76 322.01,156.45 322.01,155.86 322.9,154.98 324.4,154.98 324.6,154.77 324.6,153.65 325.03,153.22 326.43,153.22 333.7,160.49 333.7,161.32 333.98,161.61 337.12,161.61 337.6,161.12 340.4,161.12 340.48,161.04 340.48,159.22 340.17,158.91 337.68,158.91 336.11,157.34 336.11,156.73 323.05,143.67
GNDA_CHG on TOP (solid shape): 121.98,166.39 121.98,166.07 121.95,166.04 121.44,166.04 121.43,166.02 121.43,165.56 121.44,165.55 121.97,165.55 121.99,165.54 121.99,165.24 121.9,165.16 120.65,165.16 120.1,165.7 119.56,165.7 119.47,165.79 119.47,166.31 119.62,166.46 119.98,166.46 120.27,166.75 121.62,166.75
GNDA_CHG on IN3 (solid shape): 120.95,166.56 120.95,160.29 120.79,160.13 118.89,160.13 118.66,159.9 118.25,159.9 118.02,160.13 117.75,160.13 117.16,160.72 117.16,163.46 117.22,163.55 117.32,163.54 117.89,163.83 117.32,164.12 117.22,164.11 117.16,164.2 117.16,166.33 117.47,166.64 117.79,166.64 117.89,166.74 120.77,166.74
+BATT_SUM on TOP (solid shape): 140.94,171.64 140.94,163.03 140.81,162.9 135.27,162.9 135.12,163.05 135.12,171.11 135.61,171.6 135.63,171.6 135.74,171.72 138.17,171.72 138.78,171.11 139.84,171.11 140.5,171.77 140.81,171.77
+BATT_SUM on BOTTOM (solid shape): 139.11,173.09 140.35,173.09 140.94,172.5 140.94,165.87 140.43,165.37 134.26,165.37 133.62,166 133.62,169.1 132.4,170.32 132.4,174.38 132.74,174.73 137.47,174.73
+BL_PWR_SRC on TOP (solid shape): 98.52,156.55 99.61,156.55 99.76,156.4 99.76,155.46 99.61,155.31 98.14,155.31 97.96,155.13 95.49,155.13 95.24,155.38 95.24,156.81 95.47,157.03 98.03,157.03
+BL_PWR_SRC on BOTTOM (solid shape): 100.02,156.32 100.02,155.08 99.79,154.85 95.53,154.85 95.38,155 95.38,158.6 95.56,158.78 97.56,158.78
+CHGR_DC_IN on TOP (solid shape): 112.79,159.68 112.79,155.36 113.1,155.05 113.1,154.42 112.97,154.29 108.96,154.29 108.6,154.65 108.6,157.77 109.11,158.28 110.1,158.28 110.56,158.74 110.56,160.18 110.68,160.31 112.16,160.31
+DC1_PWR_SRC on TOP (solid shape): 225.61,158.5 225.61,152.66 225.49,152.53 223.2,152.53 223.07,152.66 223.07,153.17 222.95,153.3 221.3,153.3 221.17,153.42 221.17,154.19 220.79,154.57 217.55,154.57 217.49,154.63 217.49,157.81 217.55,157.87 222.95,157.87 223.07,158 223.07,158.5 223.2,158.63 225.49,158.63
+DC1_PWR_SRC on BOTTOM (solid shape): outline of 259 points within 217.34,153.56 223.16,169.9
+DC1_PWR_SRC on IN3 (solid shape): outline of 330 points within 217.61,153.55 226.19,169.25
+DC_IN on TOP (solid shape): 127.22,147.99 127.22,147.13 127.12,147.03 127.12,146.87 126.94,146.7 126.94,146.44 126.91,146.42 125.77,146.42 125.54,146.65 125.54,147.94 125.62,148.02 127.19,148.02
+DC_IN on BOTTOM (solid shape): 100.79,173.77 100.79,167.76 100.58,167.55 97.45,167.55 97.22,167.78 97.22,173.72 97.63,174.13 100.43,174.13
+DC_IN on IN2 (solid shape): 127.02,146.93 127.02,146.65 126.69,146.32 124.25,146.32 124.17,146.39 124.17,146.8 124.48,147.1 126.84,147.1
+DC_IN_SS on TOP (solid shape): 108.76,160.37 108.76,159.95 108.83,159.88 108.83,158.99 108.73,158.89 107.89,158.89 107.71,159.07 107.71,160.13 107.79,160.21 108.18,160.21 108.4,160.43 108.7,160.43
+DC_IN_SS on BOTTOM (solid shape): 99.57,182.88 99.57,179.68 100.5,178.75 100.5,178.75 100.54,178.7 100.54,176.71 100.22,176.39 97.2,176.39 96.13,175.32 94.96,175.32 93.22,173.58 93.22,170.55 92.49,169.81 91.63,169.81 91.56,169.88 91.56,180.83 93.28,182.56 94.42,182.56 94.99,183.12 99.33,183.12
+DC_IN_SS on IN2 (solid shape): 96.79,179.21 96.79,178.32 96.71,178.24 95.6,178.24 95.42,178.42 95.42,179.26 95.55,179.39 96.61,179.39
+DCIN on TOP (solid shape): 117.03,160.31 117.03,160.13 116.7,159.8 116.37,159.8 116.11,159.54 116.11,158.83 114.49,157.2 113.08,157.2 113.05,157.23 113.05,158.1 113.2,158.24 113.2,160.17 113.4,160.37 116.97,160.37
+DCIN_JACK on BOTTOM (solid shape): 88.96,152.87 95.65,152.87 95.72,152.79 95.72,150.61 95.62,150.51 94.28,150.51 93.71,149.94 87.51,149.94 87.2,150.25 87.2,152.97 87.4,153.17 88.66,153.17
+DCIN_JACK on BOTTOM (solid shape): 96.41,171.11 96.41,167.91 96.09,167.59 91.34,167.59 91.08,167.85 91.08,169.5 91.21,169.64 92.49,169.64 93.37,170.52 93.37,171.12 93.61,171.36 96.16,171.36
+DCIN_JACK on IN2 (solid shape): outline of 160 points within 85.26,149.91 93.84,170.38
+DCIN_JACK on IN3 (solid shape): outline of 687 points within 84.17,150.05 94.1,170.46
+DOCK_PWR_BAR on TOP (solid shape): 111.29,161.61 111.29,160.74 111.06,160.51 110.35,160.51 110.15,160.31 110.15,159.04 110.02,158.91 109.49,158.91 109.34,159.07 109.34,159.73 109.33,159.73 109.33,160.3 109.47,160.57 109.33,160.83 109.33,161.01 110.11,161.78 111.12,161.78
+DOCK_PWR_BAR on TOP (solid shape): outline of 100 points within 157.67,177.43 166.3,183.62
+DOCK_PWR_BAR on BOTTOM (solid shape): outline of 315 points within 147.69,165.24 166.3,184.95
+DOCK_PWR_BAR on IN1 (solid shape): outline of 100 points within 157.67,177.43 166.3,183.62
+DOCK_PWR_BAR on VCC (solid shape): outline of 5481 points within 158.31,175.03 213.92,186.63
+DOCK_PWR_BAR on IN2 (solid shape): 110.98,161.56 110.98,159.73 110.8,159.55 110.14,159.55 109.88,159.8 109.88,161.58 110.09,161.78 110.75,161.78
+DOCK_PWR_BAR on IN2 (solid shape): outline of 100 points within 157.67,177.43 166.3,183.62
+DOCK_PWR_BAR on IN3 (solid shape): outline of 95 points within 157.67,177.43 166.3,183.62
+FB_PLLAVDD on TOP (solid shape): 54.11,87.33 54.11,86.2 53.85,85.93 51.51,85.93 51.32,86.12 51.32,87.45 51.51,87.64 53.79,87.64
+FB_PLLAVDD on IN2 (solid shape): outline of 141 points within 70.4,98.23 73.78,105.08
+FB_PLLAVDD on IN2 (solid shape): outline of 199 points within 51.34,85.63 62.75,87.71
+FB_PLLAVDD on IN3 (solid shape): outline of 2038 points within 53.42,99.73 73.12,106.35
+GPU_CORE on TOP (solid shape): 62.4,63.72 62.4,62.06 62.19,61.86 47.26,61.86 47.03,62.09 47.03,63.91 47.44,64.32 61.79,64.32
+GPU_CORE on TOP (solid shape): outline of 649 points within 55.26,95.26 65.41,104.53
+GPU_CORE on BOTTOM (solid shape): 66.36,63.13 66.36,60.6 65.9,60.14 65.42,60.14 65.39,60.17 65.39,60.65 65.35,60.69 64.57,60.69 64.57,60.68 64.57,60.13 64.56,60.12 64.2,60.12 64.2,60.69 63.39,60.69 63.39,60.15 63.36,60.12 60.16,60.12 60.13,60.15 60.13,60.69 59.34,60.69 59.34,60.17 59.31,60.14 58.96,60.14 58.94,60.16 58.94,60.69 58.15,60.69 58.15,60.18 58.1,60.12 54.94,60.12 54.9,60.16 54.9,60.69 54.11,60.69 54.1,60.68 54.1,60.14 54.08,60.13 53.74,60.13 53.71,60.16 53.71,60.69 52.94,60.69 52.91,60.66 52.91,60.18 52.86,60.13 52.39,60.13 51.88,60.64 47.32,60.64 47.12,60.84 47.12,63.98 47.51,64.37 65.11,64.37
+GPU_CORE on BOTTOM (solid shape): outline of 1694 points within 55.62,95.22 65.32,104.61
+GPU_CORE on IN1 (solid shape): 62.73,63.79 62.73,61.98 62.42,61.68 47.49,61.68 47.03,62.14 47.03,63.97 47.26,64.19 62.32,64.19
+GPU_CORE on IN1 (solid shape): outline of 1053 points within 55.16,97.93 67.5,104.56
+GPU_CORE on IN2 (solid shape): 62.52,63.28 62.52,62.03 62.32,61.83 47.43,61.83 47.16,62.11 47.16,64.04 47.28,64.17 61.63,64.17
+GPU_CORE on IN3 (solid shape): outline of 2806 points within 53,83.94 72.12,99.3
+GPU_CORE on VCC: 45.41,60.44 45.41,84.72 47.97,87.29 54.6,87.29 55.77,88.45 55.77,103.34 57.09,104.66 71.44,104.66 75.33,100.77 75.33,99.08 74.57,98.31 74.57,85.87 71.9,83.2 71.9,60.44
+LCDVDD on TOP (solid shape): 101.69,141.49 101.69,138.29 101.36,137.96 99.97,137.96 99.58,138.34 99.58,138.9 98.44,140.04 98.44,141.49 98.59,141.64 101.54,141.64
+LCDVDD on BOTTOM (solid shape): 101.87,140.5 101.87,138.09 101.74,137.96 100.73,137.96 99.84,138.85 99.84,140.12 100.35,140.63 101.74,140.63
+LOM_VCT on TOP (solid shape): 198.31,184.79 198.31,184.13 198.14,183.96 198.14,183.25 197.83,182.94 197.83,182.91 197.59,182.67 197.32,182.67 197.18,182.81 197.18,183 197.42,183.24 197.42,184.92 198.18,184.92
+LOM_VCT on BOTTOM (solid shape): 198.12,185.43 198.12,183.52 198.17,183.47 198.17,182.84 198.16,182.78 198.15,182.7 198.01,182.56 197.46,182.56 197.24,182.78 197.24,182.8 197.25,182.92 197.23,183.11 197.24,183.12 197.31,183.31 197.26,183.5 197.24,183.54 197.29,183.59 197.29,185.49 197.36,185.55 197.99,185.55
+PBATT on TOP (solid shape): 136.62,186.02 136.62,176.06 135.7,175.14 132.47,175.14 131.97,175.65 131.97,177.61 132.76,177.61 132.76,177.56 132.76,177.5 132.78,177.45 132.8,177.4 132.83,177.36 132.87,177.32 132.91,177.29 132.96,177.26 133.01,177.24 133.06,177.23 133.11,177.23 133.17,177.23 133.22,177.24 133.27,177.26 133.31,177.29 133.35,177.32 133.39,177.36 133.42,177.4 133.44,177.45 133.46,177.5 133.47,177.56 133.47,177.61 133.46,177.66 133.44,177.71 133.42,177.76 133.39,177.81 133.35,177.84 133.31,177.88 133.27,177.9 133.22,177.92 133.17,177.94 133.11,177.94 133.06,177.94 133.01,177.92 132.96,177.9 132.91,177.88 132.87,177.84 132.83,177.81 132.8,177.76 132.78,177.71 132.76,177.66 132.76,177.61 131.97,177.61 131.97,177.97 132.71,178.71 132.71,178.72 132.83,178.84 132.83,186.1 133.33,186.6 136.03,186.6
+PBATT_IN_SS on TOP (solid shape): 136.12,174.63 136.12,173.12 134.89,171.89 134.89,163.36 134.59,163.05 134.13,163.05 134,163.18 133.06,163.18 132.44,163.8 131.68,163.8 131.51,163.97 131.51,164.41 131.12,164.81 130.27,164.81 129.4,165.67 129.4,171.18 130.93,172.71 130.93,174.28 131.36,174.71 136.03,174.71
+PCH_AUSB3PLL on TOP (solid shape): 157.12,103.47 157.12,100.57 156.89,100.34 153.34,100.34 153.03,100.65 153.03,101.94 153.9,102.82 154.44,102.82 154.75,102.5 155.77,102.5 155.97,102.7 155.97,103.49 156.05,103.57 157.01,103.57
+PCH_DCPSUS1 on TOP (solid shape): outline of 245 points within 163.5,70.96 172.9,72.74
+PCH_DCPSUS4 on IN2 (solid shape): outline of 579 points within 160.41,78.27 163.47,84.77
+PCH_VCC1P05 on TOP (solid shape): outline of 263 points within 156.42,78.1 160.07,86.24
+PCH_VCCDSW3_3 on TOP (solid shape): 192.52,68.13 192.52,65.67 192.45,65.59 191.28,65.59 191.16,65.71 191.16,68.09 191.36,68.29 192.37,68.29
+PCH_VCCDSW3_3 on BOTTOM (solid shape): 213.22,76.54 213.22,75.86 213,75.63 210.28,75.63 210.1,75.81 210.1,76.69 210.23,76.82 212.94,76.82
+PCH_VCCDSW3_3 on BOTTOM (solid shape): 226.46,75.45 226.46,73.42 226.3,73.27 224.83,73.27 224.6,73.49 224.6,75.55 224.76,75.7 226.2,75.7
+PCH_VCCDSW3_3 on BOTTOM (solid shape): 185.77,72.66 185.77,72.43 185.61,72.27 185.31,72.27 185.18,72.4 185.18,72.66 185,72.83 184.39,72.83 184.32,72.76 184.32,72.5 184.24,72.43 183.71,72.43 183.61,72.52 183.61,73.14 183.72,73.24 185.18,73.24
+PCH_VCCDSW3_3 on IN2 (solid shape): 211.67,69.91 211.67,68.92 210.73,67.98 209.82,67.98 209.69,68.11 209.69,69.68 210.05,70.04 211.55,70.04
+PCH_VCCDSW3_3 on IN2 (solid shape): 212.46,76.47 212.46,75.25 211.75,74.54 211.19,74.54 210.57,75.16 210.57,75.61 210.43,75.75 210.43,76.64 210.56,76.77 212.16,76.77
+PCH_VCCDSW3_3 on IN2 (solid shape): 162.55,65.46 162.57,65.4 162.57,64.96 162.56,64.95 162.55,64.85 162.56,64.75 162.57,64.75 162.57,64.38 162.51,64.2 162.57,64.02 162.57,63.69 162.56,63.65 162.57,63.59 162.29,63.32 161.94,63.32 161.78,63.48 161.78,64.07 161.76,64.09 161.76,64.12 161.69,64.37 161.45,64.49 161.38,64.52 161.36,64.59 161.36,64.78 161.36,64.83 161.37,64.86 161.4,64.93 161.47,64.95 161.73,65.07 161.8,65.34 161.8,65.45 161.94,65.59 162.42,65.59
+PNVVDD on BOTTOM (solid shape): outline of 237 points within 45.41,52.89 75.78,60.51
+PWR_SRC on TOP (solid shape): outline of 5320 points within 38.6,20.06 97.45,143.04
+PWR_SRC on BOTTOM (solid shape): 217.98,169.6 217.98,164.9 217.26,164.18 213.48,164.18 213.27,164.39 213.27,168.65 214.52,169.9 217.68,169.9
+PWR_SRC on BOTTOM (solid shape): 40.52,30 41.02,30 41.02,30.54 41.32,30.54 41.32,30 41.82,30 41.82,30.54 42.61,30.54 42.88,30.27 42.88,29.85 42.88,29.85 42.88,29.02 42.63,28.77 39.71,28.77 39.45,29.02 39.45,30.3 39.69,30.54 40.52,30.54
+PWR_SRC on BOTTOM (solid shape): 42.23,22.37 42.23,21.26 42.76,21.26 42.76,21.06 42.23,21.06 42.23,20.46 42.76,20.46 42.76,20.26 42.26,20.26 42.26,19.7 42.16,19.6 40.22,19.6 39.89,19.93 39.89,21.98 40.35,22.44 42.16,22.44
+PWR_SRC on BOTTOM (solid shape): 73.6,68.92 73.6,68.15 73.03,68.15 73.02,68.14 73.02,67.58 73.03,67.57 73.6,67.57 73.6,67.35 73.05,67.35 73.03,67.33 73.03,66.77 73.04,66.75 73.6,66.75 73.6,66.39 73.49,66.28 69.51,66.28 69.08,66.71 69.08,68.97 69.33,69.23 73.29,69.23
+PWR_SRC on BOTTOM (solid shape): 94.95,159.15 94.95,157.42 94.8,157.26 94.5,157.26 94.17,157.59 92.35,157.59 92.31,157.63 92.31,157.64 92.33,157.7 92.34,157.77 92.34,157.91 92.31,158.05 92.31,159.26 92.45,159.4 94.71,159.4
+PWR_SRC on BOTTOM (solid shape): 73.92,32.75 73.93,32.74 74.69,32.74 74.71,32.76 74.71,33.29 75.12,33.29 75.12,32.74 75.13,32.73 76.08,32.73 76.64,32.17 76.64,29.19 75.76,28.31 72.74,28.31 72.41,28.64 72.41,32.45 72.69,32.73 73.49,32.73 73.51,32.75 73.51,33.29 73.92,33.29
+PWR_SRC on BOTTOM (solid shape): 98.34,113.81 98.34,110.35 98.19,110.2 97.45,110.2 97.45,110.19 93.89,110.19 93.31,110.78 93.31,111.46 93.3,111.48 92.78,111.48 92.78,111.93 93.3,111.93 93.31,111.95 93.31,112.66 93.3,112.68 92.78,112.68 92.78,113.13 93.3,113.13 93.31,113.15 93.31,113.77 93.31,113.78 93.31,114.33 93.65,114.67 97.48,114.67
+PWR_SRC on BOTTOM (solid shape): 129.71,179.89 129.71,175.51 129.58,175.39 127.23,175.39 126.76,174.92 126.76,172.63 126.23,172.63 126.23,174 125.87,174.36 125.52,174 125.52,173.98 125.49,173.95 125.49,172.63 124.73,172.63 121.94,169.84 121.94,168.57 121.56,168.19 117.58,168.19 117.39,168.38 117.39,172.4 117.87,172.88 118.89,172.88 122.57,176.57 122.57,179.62 123.03,180.07 129.53,180.07
+PWR_SRC on IN1 (solid shape): 94.05,138.92 94.05,129.63 90.92,126.5 83.79,126.5 83.01,127.28 83.01,137.96 84.2,139.16 84.2,139.19 84.27,139.25 84.27,142.71 85.11,143.55 89.42,143.55
+PWR_SRC on VCC: outline of 539 points within 79.3,138.31 236.34,186.63
+PWR_SRC_AC on TOP (solid shape): 157.67,174.41 157.67,171.49 157.62,171.44 155.9,171.44 155.49,171.03 155.49,170.39 155.41,170.32 153.9,170.32 153.53,170.69 153.53,174.74 153.76,174.97 157.12,174.97
+PWR_SRC_AC on BOTTOM (solid shape): 158.63,174.27 158.63,171.23 158.5,171.11 155.72,171.11 155.57,170.95 155.57,170.09 155.77,169.89 157.93,169.89 158,169.81 158,165.59 157.7,165.29 153,165.29 152.62,165.67 152.62,169.97 152.82,170.29 152.62,170.62 152.62,174.59 153.05,175.02 157.88,175.02
+PWR_SRC_AC on BOTTOM (solid shape): 108.73,182.87 108.73,182.05 108.58,181.9 107.81,181.9 106.76,180.85 106.76,176.83 106.5,176.57 102.69,176.57 102.36,176.9 102.36,179.34 102.96,179.95 103.72,179.95 104.42,180.64 104.42,181.01 105.78,181.01 106.14,181.37 105.78,181.72 104.42,181.72 104.42,182.83 104.69,183.09 108.5,183.09
+PWR_SRC_AC on IN3 (solid shape): outline of 2406 points within 102.3,164.71 156.51,183.2
+RTC_CELL on TOP (solid shape): 162.2,115 162.2,114.35 162.13,114.26 162.03,114.27 161.59,114.31 161.45,113.9 161.45,113.64 160.93,113.13 160.93,113.12 160.77,112.97 160.77,112.51 160.65,112.38 159.78,112.38 159.66,112.51 159.66,113.47 159.86,113.68 160.39,113.68 160.82,114.11 160.82,114.92 161.05,115.15 162.04,115.15
+RTC_CELL on IN2 (solid shape): outline of 285 points within 156.82,78.37 158.34,83.68
+RTC_CELL on IN2 (solid shape): outline of 298 points within 162.46,63.75 164.61,70.06
+SD_IO_LDO on BOTTOM (solid shape): 19.96,32.3 19.96,31.69 19.96,31.69 19.96,30.75 20.7,30.02 20.7,29.26 20.65,29.2 20.55,29.2 19.82,29.94 19.82,30.05 19.05,30.82 19.05,31.36 18.81,31.6 18.81,32.4 18.89,32.47 19.79,32.47
+SDC_IN on BOTTOM (solid shape): 103.39,183.29 103.39,181.72 102.02,181.72 101.67,181.37 102.02,181.01 103.39,181.01 103.39,180.35 103.27,180.22 99.91,180.22 99.76,180.38 99.76,183.27 100.09,183.6 103.08,183.6
+SWR_LX on TOP (solid shape): 125.06,117.3 125.06,116.42 124.73,116.09 121.96,116.09 121.45,116.6 121.45,117.41 121.55,117.51 124.85,117.51
+SWR_LX on TOP (solid shape): 123.74,123.89 123.74,123.56 123.43,123.25 123.43,122.97 123.31,122.85 122.19,122.85 121.92,123.12 121.85,123.19 120.78,123.19 120.72,123.25 120.72,123.43 120.82,123.53 120.92,123.53 122.16,123.53 122.16,123.53 122.39,123.53 122.8,123.94 123.69,123.94
+SWR_LX on BOTTOM (solid shape): outline of 212 points within 120.02,115.71 125.44,124.11
+SWR_V12 on TOP (solid shape): 120.31,121.47 120.31,120.23 121,119.54 121.94,119.54 122.7,118.78 123.71,118.78 123.76,118.73 125.14,118.73 125.19,118.78 125.85,118.78 125.97,118.66 125.97,117.97 125.59,117.59 124.96,117.59 124.78,117.77 121.61,117.77 121.4,117.97 120.64,117.97 120.51,118.1 120.51,119.32 120.03,119.8 120.03,121.47 120.08,121.53 120.26,121.53
+SWR_V12 on TOP (solid shape): 125.16,124.34 125.16,123.46 124.98,123.28 124.78,123.28 124.68,123.18 124.68,122.59 124.43,122.34 124.02,122.34 123.66,121.98 122.29,121.98 121.83,122.44 120.87,122.44 120.79,122.52 120.79,122.64 120.84,122.69 123.36,122.69 123.56,122.9 123.56,123.1 123.88,123.42 123.88,124.43 123.92,124.47 125.03,124.47
+SWR_V12 on TOP (solid shape): 112.84,124.83 113.3,124.83 114.15,123.98 114.81,123.98 114.93,123.86 115.87,123.86 115.92,123.81 115.92,123.66 115.84,123.59 115.81,123.59 114.97,123.59 114.92,123.58 114.68,123.58 114.39,123.71 114.11,123.58 113.48,123.58 113.18,123.88 112.95,123.88 112.92,123.91 111.17,123.91 111.07,124.01 111.07,125.06 111.06,125.21 111.19,125.34 112.33,125.34
+SWR_V12 on IN3 (solid shape): outline of 195 points within 111.01,117.59 125.9,125.84
+VCHGR on BOTTOM (solid shape): 131.46,173.04 131.46,169.84 131.97,169.33 132.86,169.33 133.11,169.07 133.11,164.9 132.79,164.58 129.61,164.58 129.35,164.32 127.73,164.32 127.52,164.53 127.52,167.04 127.22,167.35 122.95,167.35 122.7,167.6 122.7,169.33 124.98,171.61 125.54,171.61 125.54,170.24 125.87,169.91 126.2,170.24 126.2,171.61 127.02,171.61 127.19,171.79 127.19,173.13 127.19,173.15 127.43,173.39 131.11,173.39
+VHDMI_VCC on TOP (solid shape): 14.85,99.76 14.85,98.46 14.52,98.13 12.41,98.13 12.18,98.36 12.18,99.3 12.12,99.37 12.12,99.64 12.36,99.88 14.72,99.88
+VHDMI_VCC on TOP (solid shape): 14.02,107.47 14.02,106.74 14.16,106.6 14.16,105.14 14.06,105.04 13.18,105.04 11.92,106.3 11.4,106.3 11.27,106.44 11.27,107.02 11.78,107.53 13.96,107.53
+VHDMI_VCC on IN1 (solid shape): outline of 149 points within 11.11,98.36 15.38,107.75
+VLDOIN_1.35V on BOTTOM (solid shape): 43.5,13.8 43.5,13.5 42.94,13.5 42.94,12.99 43.5,12.99 43.53,12.97 43.53,12.76 43.5,12.74 40.99,12.74 40.47,13.25 39.43,13.25 39.39,13.3 39.39,13.43 39.43,13.47 42.1,13.47 42.54,13.91 43.4,13.91
+VREFC_UV5 on TOP (solid shape): 32.27,115.12 32.27,112.85 32.14,112.73 31.57,112.73 31.44,112.85 31.44,115.11 31.56,115.23 32.17,115.23
+VREFD_UV5 on TOP (solid shape): 34.05,115.1 34.05,112.6 33.6,112.15 33.6,111.9 33.62,111.88 33.62,111.86 33.72,111.66 33.92,111.56 33.94,111.56 34.68,110.82 34.68,110.38 34.53,110.23 34.47,110.18 34.42,110.13 34.16,110.13 34.1,110.19 34.02,110.22 34.01,110.23 33.54,110.69 33.28,110.69 32.71,111.27 32.71,112.22 33.16,112.66 33.16,115.02 33.31,115.18 33.97,115.18
+VREFD_UV7 on TOP (solid shape): outline of 156 points within 31.11,94.44 34.49,99.14
-DCIN_JACK on BOTTOM (solid shape): outline of 118 points within 88.61,145.36 100.77,151.17
BOOT_1.35V on BOTTOM (solid shape): 42.74,16.29 42.74,14.44 41.9,13.6 40.55,13.6 40.5,13.65 39.44,13.65 39.38,13.71 39.38,13.81 39.43,13.86 40.44,13.86 40.44,13.85 41.24,13.85 42,14.62 42,16.32 42.03,16.34 42.69,16.34
BST_3V on TOP (solid shape): 213.81,155.29 213.81,154.39 213.83,154.37 213.83,154.35 213.95,154.24 213.96,154.24 214.18,154.02 214.18,153.12 214.3,153 214.71,153 214.73,152.97 214.73,152.27 214.68,152.22 213.85,152.22 213.71,152.36 213.71,153.94 213.59,154.05 213.59,155.29 213.63,155.33 213.77,155.33
BST_5V on TOP (solid shape): 214.89,160.53 214.89,159.74 214.58,159.43 214.27,159.43 214.15,159.32 214.15,158.84 213.86,158.55 213.85,158.55 213.8,158.49 213.8,157.54 213.77,157.52 213.57,157.52 213.54,157.54 213.54,159.28 213.83,159.57 213.83,160.46 213.95,160.58 214.84,160.58
BST_+VDDRP on BOTTOM (solid shape): 37.06,31.25 37.81,31.25 37.94,31.12 37.94,30.28 37.89,30.22 37.06,30.22 36.38,30.9 35.78,30.9 35.7,30.98 35.7,31.75 35.78,31.83 36.49,31.83
CD3301_DCIN on TOP (solid shape): 128.77,152.36 128.77,151.22 128.59,151.04 128.59,150.65 128.35,150.41 128.33,150.4 128,149.98 128.46,149.71 128.55,149.7 128.59,149.61 128.59,148.83 128.51,148.75 125.67,148.75 125.64,148.78 125.64,149.44 126.6,150.39 126.6,150.93 127.78,152.11 128.21,152.11 128.49,152.39 128.74,152.39
CHAGER_SRC on TOP (solid shape): 108.07,172.93 108.07,169.86 107.43,169.23 102,169.23 101.92,169.3 101.92,171.26 102.63,171.97 102.63,173.06 102.76,173.19 107.81,173.19
CHAGER_SRC on BOTTOM (solid shape): 106.67,174.89 106.67,173.04 107,172.71 111.85,172.71 112.06,172.5 112.06,167.83 111.95,167.73 107.59,167.73 107.32,167.99 107.32,168.99 107.15,169.15 101.43,169.15 101.26,169.32 101.26,170.24 101.4,170.38 102.06,170.38 102.25,170.38 102.4,170.53 102.4,172.4 102.25,172.55 102.25,174.92 102.61,175.28 106.28,175.28
CHG_LGATE on TOP (solid shape): 117.34,163.38 117.34,162.5 117.28,162.43 117.15,162.43 116.89,162.69 116.32,162.69 116.13,162.88 116.13,163.51 116.39,163.77 116.96,163.77
CHG_LGATE on BOTTOM (solid shape): 108.92,181.45 108.92,180.57 108.66,180.31 107.25,180.31 107.05,180.51 107.05,180.76 107.84,181.55 108.83,181.55
CHG_LGATE on IN1 (solid shape): 117.14,164.48 117.14,162.95 116.83,162.65 116.22,162.65 116.02,162.85 116.02,164.63 116.12,164.73 116.88,164.73
CHG_LGATE on IN1 (solid shape): 110.67,181.13 110.06,180.52 109.91,180.52 109.62,180.81 107.86,180.81 107.7,180.97 107.7,181.63 107.8,181.74 110.06,181.74
CHG_UGATE on TOP (solid shape): 115.94,161.35 116.96,161.35 117.02,161.29 117.02,161.16 116.96,161.1 116.01,161.1 115.88,160.97 115.05,160.97 114.74,161.29 114.74,161.73 114.86,161.86 115.43,161.86
CHG_UGATE on BOTTOM (solid shape): 115.2,168.72 115.2,167.83 115.04,167.68 113,167.68 112.78,167.89 112.78,168.61 112.97,168.79 115.12,168.79
CHG_UGATE on IN2 (solid shape): 115.28,168.39 115.28,166.58 115,166.31 113.94,166.31 113.45,166.79 113.45,168.49 113.76,168.79 114.87,168.79
CHG_UGATE on IN2 (solid shape): 116.12,161.45 116.12,161.25 115.84,160.97 114.98,160.97 113.99,161.96 113.99,162.98 114.11,163.11 114.47,163.11
DC_BLOCK_GC on BOTTOM (solid shape): 102.12,179.95 102.12,179.54 102.07,179.49 99.97,179.49 99.84,179.62 99.84,179.87 99.97,180 102.07,180
DH_1.35V on TOP (solid shape): 52.92,17.51 52.92,16.6 52.75,16.42 50.33,16.42 50.16,16.6 50.16,17.18 50.66,17.69 52.75,17.69
DH_1.35V on TOP (solid shape): 41.77,15.23 42.69,15.23 42.87,15.05 42.87,14.29 42.66,14.08 40.81,14.08 40.63,14.26 40.63,14.77 41.24,15.38 41.62,15.38
DH_1.35V on BOTTOM (solid shape): 54.75,17.44 54.75,16.6 54.55,16.39 52.16,16.39 51.98,16.57 51.98,17.51 52.19,17.72 54.47,17.72
DH_1.35V on BOTTOM: 39.44,14.26 39.44,14.06 39.49,14.01 41.04,14.01 41.67,14.64 41.67,15.28 41.55,15.4 41.29,15.4 40.66,14.77 40.66,14.52 40.48,14.34 39.51,14.34
DL_1.35V on BOTTOM (solid shape): 49.42,16.12 49.42,15.28 49.22,15.07 46.4,15.07 45.84,15.63 45.84,16.22 46,16.38 46.84,16.38 46.85,16.39 49.14,16.39
DL_1.35V on BOTTOM (solid shape): 40.07,16.82 40.07,16.45 39.49,15.86 39.49,15 39.4,14.91 39.13,14.91 39.08,14.96 39.08,15.91 39.01,15.99 39.01,16.34 39.69,17.03 39.87,17.03
DL_1.35V on IN2 (solid shape): 47.46,16.24 47.46,15.96 46.78,15.28 45.43,15.28 45.33,15.38 45.33,16.09 45.74,16.5 47.21,16.5
DL_1.35V on IN2 (solid shape): 40.58,17 40.58,16.06 39.74,16.06 39.51,15.84 39.21,15.84 39.03,16.01 39.03,16.57 39.56,17.11 40.48,17.11
EN_1.5VRUN on BOTTOM (solid shape): 234.08,92.55 234.08,92.01 233.54,91.48 230.85,91.48 230.65,91.68 230.65,92.45 230.83,92.63 234,92.63
GPU_B+ on BOTTOM (solid shape): 65.59,52.2 65.59,47.28 65.49,47.18 64.12,47.18 63.69,46.74 63.69,41.28 63.34,40.93 63.34,38.32 65.04,36.61 76.29,36.61 76.9,37.22 76.9,40.77 77.11,40.98 77.11,41.07 77.21,41.31 77.11,41.55 77.11,41.65 76.9,41.85 76.9,46.3 76.14,47.06 75.69,47.06 75.25,47.51 75.25,51.43 75.76,51.95 79.63,51.95 80.14,51.44 80.14,47.06 79.18,46.11 79.18,38.57 78.4,37.79 78.4,33.77 77.6,32.97 75.36,32.97 75.31,33.02 75.31,33.48 74.52,33.48 74.51,33.47 74.51,32.93 74.15,32.93 74.11,32.97 74.11,33.48 73.33,33.48 73.32,33.48 73.32,32.93 73.32,32.93 72.73,32.93 72.73,32.93 72.28,32.93 71.67,33.54 63.31,33.54 61.72,35.12 61.72,35.44 61.4,35.44 60.64,36.2 60.64,38.93 60.52,39.06 60.52,40.78 60.77,41.03 60.77,52.08 61.02,52.33 65.47,52.33
GPU_PVCC on BOTTOM (solid shape): 58.17,33.92 58.17,33.09 58.04,32.96 55.88,32.96 55.75,33.09 55.75,33.92 55.88,34.04 58.04,34.04
INT_SPK_L+ on TOP (solid shape): 289.2,146.72 291.02,146.72 291.33,146.42 291.33,145.71 291.13,145.5 289.63,145.5 289.55,145.58 288.26,145.58 288.05,145.78 288.05,146.75 288.2,146.9 289.02,146.9
INT_SPK_L+ on IN3 (solid shape): 291.02,146.95 291.02,146.7 290.52,146.19 290.52,145.66 290.29,145.43 289.07,145.43 288.79,145.71 288.79,146.52 289.02,146.75 289.58,146.75 290.19,147.36 290.62,147.36
INT_SPK_L+ on IN3 (solid shape): 303.24,152.54 303.24,151.65 302.81,151.22 300.14,151.22 299.86,151.5 299.86,152.13 299.99,152.26 301.9,152.26 302.35,152.72 303.06,152.72
INT_SPK_L- on TOP (solid shape): 291.38,149.26 291.38,148.47 291.2,148.3 290.26,148.3 290.13,148.17 287.98,148.17 287.95,148.2 287.95,149.03 288.03,149.11 290.03,149.11 290.36,149.44 291.2,149.44
INT_SPK_L- on BOTTOM (solid shape): 303.27,152.69 303.27,152.64 303.22,152.59 300.8,152.59 300.73,152.67 300.73,153 300.8,153.07 302.89,153.07
INT_SPK_L- on IN3 (solid shape): 291.66,150.25 291.66,149.31 291.13,148.78 290.29,148.78 290.16,148.91 290.16,150.38 290.34,150.56 291.35,150.56
INT_SPK_L- on IN3 (solid shape): 300.33,154.08 300.49,153.86 300.74,153.81 301,153.81 301.82,152.99 301.82,152.69 301.65,152.53 300.33,152.53 299.94,152.92 299.93,152.92 299.91,152.93 299.67,153.02 299.43,152.92 299.13,152.92 298.97,153.07 298.97,153.88 299.2,154.11 300.32,154.11
INT_SPK_R+ on BOTTOM (solid shape): 303.44,154.09 303.57,154.06 303.71,154.09 304.08,154.09 304.31,153.86 305.35,153.86 305.4,153.81 305.4,153.66 305.35,153.61 303.17,153.61 303.09,153.68 303.09,154.01 303.17,154.09
INT_SPK_R+ on IN3 (solid shape): 292.4,152.84 292.4,152.1 291.2,150.9 290.3,150.9 290.16,151.04 290.16,152.03 290.31,152.18 290.85,152.18 291.63,152.97 292.27,152.97
INT_SPK_R+ on IN3 (solid shape): outline of 96 points within 299.55,153.05 304.41,155.89
INT_SPK_R+ on TOP: 288,151.37 292.19,151.37 292.34,151.22 292.34,150.68 292.09,150.43 288.05,150.43 287.93,150.56 287.93,151.29
INT_SPK_R- on IN3 (solid shape): 292.84,154.91 292.84,154.57 290.93,152.67 290.34,152.67 290.11,152.89 290.11,153.78 291.38,155.05 292.7,155.05
INT_SPK_R- on IN3 (solid shape): 303.22,155.41 303.27,155.41 303.77,154.9 303.77,154.37 303.62,154.22 303.01,154.22 300.83,156.4 300.5,156.4 300.49,156.39 299.39,156.39 299.58,156.57 299.63,156.57 299.63,157.21 299.79,157.36 301.26,157.36
INT_SPK_R- on TOP: 288.03,153.81 289.04,153.81 289.27,153.58 291.18,153.58 291.3,153.71 291.89,153.71 292.22,153.38 292.22,153.1 291.96,152.84 287.98,152.84 287.93,152.89 287.93,153.72
INT_SPKR_L+ on TOP (solid shape): 287.54,145.9 287.44,145.81 285.28,145.81 285.08,146.01 285.08,146.75 285.23,146.9 287.54,146.9
INT_SPKR_L+ on TOP (solid shape): 234.97,125.36 235.55,125.36 235.91,125.01 235.91,123.96 235.73,123.79 233.87,123.79 233.32,124.34 232.77,124.89 232.76,124.89 231.53,126.12 229.05,126.12 228.69,125.77 227.83,125.77 227.56,125.5 226.7,125.5 226.61,125.59 226.61,125.92 228.01,127.32 233.01,127.32
INT_SPKR_L+ on BOTTOM (solid shape): 228.74,127.72 228.74,125.36 228.4,125.02 226.72,125.02 226.5,125.25 226.5,126.19 226.61,126.3 227.65,126.3 227.79,126.44 227.79,127.68 227.93,127.82 228.64,127.82
INT_SPKR_L+ on IN3 (solid shape): 236.92,125.13 236.92,124.12 236.74,123.94 234.84,123.94 234.64,124.14 234.64,124.78 235.22,125.36 236.69,125.36
INT_SPKR_L+ on IN3 (solid shape): 286.43,146.37 286.43,145.02 286.32,144.92 284.9,144.92 284.78,145.05 284.78,146.26 285,146.49 286.3,146.49
INT_SPKR_L- on TOP (solid shape): 237.84,127.44 239.03,127.44 239.16,127.32 239.16,126.5 238.98,126.33 237.23,126.33 235.3,128.26 233.34,128.26 232.83,127.75 228.18,127.75 227.75,128.18 227.75,129.17 227.93,129.35 227.96,129.35 227.98,129.37 228.69,129.37 229.17,128.89 231.44,128.89 232.05,129.5 235.78,129.5
INT_SPKR_L- on BOTTOM (solid shape): 228.87,129.12 229.76,129.12 229.91,128.97 229.91,126.38 229.76,126.22 229.23,126.22 229.07,126.38 229.07,127.98 228.92,128.13 227.73,128.13 227.5,128.36 227.5,129.25 227.63,129.37 228.62,129.37
INT_SPKR_L- on IN3 (solid shape): 287.47,149.06 287.47,148.35 287.32,148.2 283.94,148.2 283.73,148.4 283.73,149.03 283.89,149.19 287.34,149.19
INT_SPKR_L- on IN3 (solid shape): 240.71,127.29 240.71,126.61 240.5,126.4 237.94,126.4 237.84,126.5 237.84,127.35 237.87,127.39 240.6,127.39
INT_SPKR_L- on TOP: 285.18,148.32 285.18,148.98 285.39,149.19 287.34,149.19 287.38,149.14 287.38,148.21 287.37,148.2 285.31,148.2
INT_SPKR_R+ on TOP (solid shape): 233.19,130.95 234.29,130.95 234.33,130.94 234.38,130.94 234.89,130.94 234.93,130.94 234.98,130.95 235.4,130.95 235.55,131.1 237.1,131.1 237.84,130.36 237.84,130.34 239.39,128.79 239.39,127.9 239.24,127.75 238.29,127.75 236.21,129.83 231.79,129.83 231.26,129.3 229.4,129.3 229.02,129.68 229.02,130.52 229.15,130.64 231.28,130.64 231.79,131.15 232.98,131.15
INT_SPKR_R+ on BOTTOM (solid shape): 231.21,129.6 231.21,126.35 231.05,126.2 230.5,126.2 230.32,126.38 230.32,129.25 230.14,129.42 229.05,129.42 228.87,129.6 228.87,130.39 229.17,130.69 230.11,130.69
INT_SPKR_R+ on IN3 (solid shape): 240.02,128.54 240.02,127.82 239.87,127.67 238.24,127.67 237.99,127.93 237.99,128.43 238.24,128.69 239.87,128.69
INT_SPKR_R+ on IN3 (solid shape): 286.53,151.17 286.53,150.63 286.35,150.46 284.27,150.46 284.04,150.68 284.04,151.19 284.22,151.37 286.32,151.37
INT_SPKR_R+ on TOP: 287.34,151.37 284.93,151.37 284.78,151.22 284.78,150.68 285,150.46 287.37,150.46 287.49,150.58 287.49,151.22
INT_SPKR_R- on TOP (solid shape): 287.37,153.76 287.37,152.95 287.32,152.89 284.67,152.89 284.57,153 284.57,153.73 284.65,153.81 287.32,153.81
INT_SPKR_R- on TOP (solid shape): 240.43,130.69 242.81,130.69 243.25,130.26 243.25,129.58 242.89,129.22 239.56,129.22 236.57,132.22 233.78,132.22 233.7,132.3 233.39,132.3 233.31,132.22 233.04,132.22 232.68,131.86 231.56,131.86 230.67,130.97 230.14,130.97 229.96,131.15 229.96,132.07 231.59,133.69 237.43,133.69
INT_SPKR_R- on BOTTOM (solid shape): 232.68,130.29 232.68,126.45 232.5,126.28 231.69,126.28 231.49,126.48 231.49,129.75 229.99,131.25 229.99,131.46 230.44,131.91 231.05,131.91
INT_SPKR_R- on IN3 (solid shape): 286.6,153.63 286.6,153 286.5,152.89 284.67,152.89 284.57,153 284.57,153.73 284.65,153.81 286.43,153.81
INT_SPKR_R- on IN3 (solid shape): 245.25,130.09 245.25,129.78 244.77,129.3 242.1,129.3 241.85,129.55 241.85,130.19 242.18,130.52 244.82,130.52
LG_3V on TOP (solid shape): 224.15,149.23 224.15,148.66 223.96,148.47 221.93,148.47 221.8,148.6 221.8,149.23 221.93,149.36 224.03,149.36
LG_3V on TOP (solid shape): 215.5,155.54 215.5,154.19 215.45,154.14 215.1,154.14 215.01,154.23 215.01,155.31 214.86,155.46 214.44,155.46 214.39,155.51 214.39,155.65 214.46,155.71 215.32,155.71
LG_3V on BOTTOM (solid shape): 216.3,155.23 216.3,153.17 216.09,152.97 215.51,152.97 215.05,153.43 215.05,154.39 214.87,154.57 214.87,155.21 215.1,155.43 216.09,155.43
LG_3V on BOTTOM (solid shape): 221.09,149.62 221.22,149.59 221.36,149.62 221.71,149.62 221.95,149.37 222.77,149.37 222.91,149.22 222.91,148.69 222.77,148.55 220.67,148.55 220.26,148.96 220.26,149.49 220.31,149.54 220.69,149.54 220.77,149.62
LG_5V on TOP (solid shape): 224.22,160.15 224.22,159.27 224.09,159.14 222.57,159.14 222.44,159.27 222.44,160.15 222.57,160.28 224.09,160.28
LG_5V on TOP (solid shape): 216.17,157.83 216.17,157.56 215.99,157.38 215.99,157.21 215.87,157.09 214.42,157.09 214.38,157.12 214.38,157.34 214.4,157.36 214.8,157.36 214.91,157.48 214.91,157.77 215.1,157.96 216.04,157.96
LG_5V on IN1 (solid shape): 216.22,159.01 216.22,157.61 216.03,157.42 215.2,157.42 215.01,157.61 215.01,159.01 215.27,159.27 215.96,159.27
LG_5V on IN1 (solid shape): 223.33,160.09 223.33,158 223.2,157.87 222.25,157.87 222.06,158.06 222.06,160.03 222.31,160.28 223.14,160.28
LG_+VDDRP on BOTTOM (solid shape): 36.6,38.52 36.6,37.65 36.42,37.47 35.7,37.47 35.55,37.62 35.55,38.52 35.74,38.71 36.41,38.71
LG_+VDDRP on BOTTOM (solid shape): 33.93,33.08 33.93,32.22 33.98,32.17 33.98,30.97 33.88,30.87 33.57,30.87 33.32,31.12 33.32,33 33.45,33.13 33.88,33.13
LG_+VDDRP on IN2 (solid shape): 36.6,38.52 36.6,37.37 36.34,37.12 34.69,37.12 34.56,37.25 34.56,38.39 34.82,38.64 36.47,38.64
LG_+VDDRP on IN2 (solid shape): 33.93,33.1 33.93,32.19 33.78,32.04 33.19,32.04 33.06,32.17 32.79,32.17 32.43,32.52 32.43,33.59 32.53,33.69 33.34,33.69
LX_DGPU on BOTTOM (solid shape): 103.25,103.99 103.25,99.28 102.86,98.89 100.35,98.89 100.21,99.04 100.21,101.52 99.44,101.52 99.44,99.04 99.3,98.89 97.35,98.89 96.97,99.27 96.97,100.1 94.67,102.4 94.67,104.45 94.86,104.64 95.57,104.64 96.01,104.61 96.14,105.03 96.15,105.13 96.24,105.17 102.07,105.17
PBATT+_C on TOP (solid shape): 131.87,186.32 131.87,181.05 131.4,180.58 130.77,180.58 130.55,180.66 130.33,180.58 121.68,180.58 121.1,181.16 121.1,183.78 120.97,183.91 120.97,186.09 121.09,186.21 124.61,186.21 124.76,186.07 124.76,184.03 125.64,183.15 127.83,183.15 128.13,183.45 128.13,186.07 128.3,186.24 128.53,186.24 129.1,186.33 129.6,186.6 131.59,186.6
PBATT+_C on BOTTOM (solid shape): 125.94,185.88 125.94,183.92 126.61,183.25 127.47,183.25 128.11,183.88 128.11,185.81 128.34,186.04 131.61,186.04 131.91,185.75 131.91,181.23 131.77,181.09 123.22,181.09 121.06,183.25 121.06,185.8 121.33,186.07 125.75,186.07
PBATT+_C on IN1 (solid shape): 131.91,186.28 131.91,181.08 131.41,180.58 131.09,180.58 130.84,180.74 130.55,180.66 130.43,180.64 130.33,180.58 121.68,180.58 120.98,181.28 120.98,181.89 120.97,181.9 120.97,186 121.18,186.21 124.61,186.21 124.76,186.07 124.76,184.03 125.42,183.37 125.85,183.37 125.92,183.3 127.88,183.3 128.18,183.6 128.18,186.11 128.31,186.24 128.53,186.24 128.99,186.3 129.41,186.47 131.72,186.47
PBATT+_C on IN2 (solid shape): 131.91,186.28 131.91,181.05 131.44,180.58 131.09,180.58 130.84,180.74 130.55,180.66 130.43,180.64 130.33,180.58 121.68,180.58 120.98,181.28 120.98,181.89 120.97,181.9 120.97,186.04 121.13,186.2 124.62,186.2 124.76,186.07 124.76,184.03 125.42,183.37 126.77,183.37 127.02,183.34 127.27,183.37 127.75,183.37 128.13,183.76 128.13,185.38 128.11,185.41 128.11,186.04 128.3,186.24 128.53,186.24 129.09,186.33 129.59,186.59 131.6,186.59
PBATT+_C on IN3 (solid shape): 131.91,186.28 131.91,181.34 131.49,180.92 121.77,180.92 120.97,181.72 120.97,186.09 121.09,186.21 124.61,186.21 124.76,186.07 124.76,184.03 125.42,183.37 126.77,183.37 127.02,183.34 127.27,183.37 127.75,183.37 128.13,183.76 128.13,185.38 128.11,185.41 128.11,186.04 128.31,186.24 128.53,186.24 129.09,186.33 129.59,186.59 131.6,186.59
PEX_PLLVDD_GPU on IN3 (solid shape): outline of 82 points within 53.24,92.17 56.48,93.27
RING2 on TOP (solid shape): 332.5,159.44 334.74,159.44 334.88,159.3 334.88,158.58 334.77,158.48 331.01,158.48 330.76,158.73 330.76,159.32 331.04,159.61 332.34,159.61
RING2 on BOTTOM (solid shape): 336.49,159.5 336.49,158.91 336.39,158.82 333.77,158.82 333.62,158.96 333.62,159.35 333.85,159.57 336.41,159.57
RING2 on IN3 (solid shape): 334.97,159.47 334.97,158.89 334.86,158.79 333.42,158.79 333.29,158.91 333.29,159.3 333.54,159.55 334.89,159.55
RING2 on IN3 (solid shape): 310.75,148.97 310.78,148.9 310.75,148.83 310.7,148.45 311.01,148.24 311.08,148.21 311.11,148.14 311.15,147.99 311.24,147.88 311.24,147.18 311.22,147.15 310.05,147.15 309.84,147.36 309.84,148.2 309.72,148.32 309.72,148.96 309.84,149.08 310.63,149.08
SLEEVE on TOP (solid shape): 334.11,161.09 334.67,161.09 334.83,160.93 334.83,160.45 334.72,160.33 334.32,160.33 334.28,160.29 333.07,160.29 332.95,160.41 331.04,160.41 330.76,160.69 330.76,161.29 331.02,161.55 333.66,161.55
SLEEVE on BOTTOM (solid shape): 336.49,161.02 336.49,160.39 336.41,160.31 333.87,160.31 333.73,160.45 333.73,160.96 333.86,161.09 336.42,161.09
SLEEVE on IN3 (solid shape): 309.46,148.72 309.46,148.22 309.59,148.09 309.59,146.26 309.54,146.21 308.24,146.21 308.03,146.43 308.03,148.67 308.29,148.94 309.25,148.94
SLEEVE on IN3 (solid shape): 334.4,161.1 334.46,161.09 334.52,161.1 335.75,161.1 335.83,161.02 335.83,160.36 335.78,160.31 333.87,160.31 333.75,160.44 333.75,161 333.85,161.1
SNUB_1.5VRUN on BOTTOM (solid shape): 227.02,93.97 228.79,93.97 228.92,93.84 228.92,92.59 228.79,92.47 227.14,92.47 226.81,92.14 226.08,92.14 225.87,92.34 225.87,93.84 226.15,94.12 226.86,94.12
SNUB_1.35V on BOTTOM (solid shape): 52.62,10.56 52.62,9.5 52.19,9.07 50.49,9.07 50.31,9.24 50.31,10.83 50.44,10.96 52.22,10.96
SW1 on TOP (solid shape): 213.63,160.45 213.63,159.83 213.38,159.57 213.38,158.38 213.39,158.37 213.39,157.54 213.35,157.5 213.24,157.5 213.17,157.57 213.17,158.41 213.12,158.46 213.12,158.48 212.87,158.73 212.87,159.57 212.61,159.83 212.61,160.49 212.72,160.59 213.49,160.59
SW1 on TOP (solid shape): 225.36,164.03 225.36,162.95 225.74,162.57 227.3,162.57 227.67,162.19 229.5,162.19 229.76,161.93 229.76,156.32 229.27,155.84 227.26,155.84 227.14,155.96 226.12,155.96 225.99,156.09 225.99,157.74 226.12,157.87 227.14,157.87 227.39,158.12 227.39,159.39 227.14,159.65 224.85,159.65 224.72,159.77 224.72,162.44 224.73,162.44 224.47,162.69 224.47,164.09 224.54,164.16 225.23,164.16
SW1 on BOTTOM (solid shape): outline of 107 points within 223.07,155.71 228.77,162.1
SW1 on IN2 (solid shape): 213.61,160.75 213.61,158.85 213.3,158.53 212.6,158.53 212.47,158.66 212.47,160.5 213.04,161.07 213.3,161.07
SW1 on IN2 (solid shape): 228.31,161.7 228.31,161.04 228.25,160.97 226.35,160.97 226.01,161.32 226.01,161.82 226.34,162.15 227.87,162.15
SW2 on TOP (solid shape): 213.41,155.28 213.41,154.18 213.45,154.14 213.45,152.27 213.41,152.23 212.58,152.23 212.47,152.34 212.47,152.95 212.64,153.11 212.86,153.11 212.88,153.14 212.88,154.05 213.17,154.34 213.17,155.28 213.21,155.32 213.38,155.32
SW2 on TOP (solid shape): 228.95,153.9 228.95,146.9 228.67,146.62 227.73,146.62 227.63,146.72 227.63,147.46 227.65,147.48 227.65,148.07 227.17,148.55 224.96,148.55 224.63,148.88 224.63,151.14 226.03,152.53 226.03,154.15 226.19,154.31 228.53,154.31
SW2 on BOTTOM (solid shape): 228.53,154.06 228.53,148.98 228.28,148.72 223.2,148.72 223.09,148.83 223.09,149.24 222.75,149.58 222.75,153.48 223.58,154.31 228.28,154.31
SW2 on IN2 (solid shape): 213.68,154.17 213.68,151.89 213.42,151.63 213.04,151.63 212.66,152.01 212.66,154.05 212.92,154.3 213.55,154.3
SW2 on IN2 (solid shape): 227.3,152.4 227.3,151.19 226.76,150.66 226.19,150.66 225.81,151.04 225.81,152.34 225.93,152.46 227.23,152.46
SW_1.35V on TOP (solid shape): 43.53,18.78 43.53,17.94 43.3,17.72 41.9,17.72 41.72,17.89 41.72,18.76 41.95,18.99 43.32,18.99
SW_1.35V on TOP (solid shape): 52.57,18.58 52.57,18.1 52.42,17.94 50.49,17.94 50.41,18.02 50.41,18.73 50.59,18.91 52.24,18.91
SW_1.35V on BOTTOM (solid shape): 43.02,18.15 43.02,17.59 42.92,17.49 42.92,16.78 42.66,16.52 41.98,16.52 40.41,14.96 40.41,14.53 40.37,14.49 39.44,14.49 39.41,14.52 39.41,14.64 39.74,14.97 39.74,15.68 40.67,16.61 40.89,16.61 41.53,17.25 41.53,18.11 41.75,18.33 42.84,18.33
SW_1.35V on BOTTOM (solid shape): 56.11,19.79 56.11,18.9 56.58,18.43 57.47,18.43 59.4,16.5 59.4,10.15 58.86,9.6 53.06,9.6 52.9,9.77 52.9,10.53 51.68,11.75 51.68,15.1 51.25,15.53 51.25,17.57 51.86,17.57 51.86,16.52 52.11,16.27 54.6,16.27 54.88,16.55 54.88,17.49 54.53,17.84 52.13,17.84 51.86,17.57 51.25,17.57 51.25,21.12 51.86,21.73 54.17,21.73
SW_++VDDRP on BOTTOM (solid shape): 41.99,45.31 41.99,40.67 41.8,40.48 40.02,40.48 38.63,39.09 36.28,39.09 35.44,39.92 34.4,39.92 34.11,40.22 34.11,40.95 35.88,42.73 35.88,45.25 36.41,45.78 41.52,45.78
SW_++VDDRP on BOTTOM (solid shape): 36.44,33.71 36.44,32.72 36.37,32.65 35.83,32.65 35.78,32.7 35.78,33.1 35.66,33.23 35.22,33.23 35.04,33.05 35.04,32.54 35,32.5 34.67,32.5 34.51,32.65 34.51,33.79 34.56,33.84 36.32,33.84
SW_++VDDRP on IN2 (solid shape): 41.55,42.07 41.55,40.55 41.29,40.29 40.53,40.29 40.15,40.67 40.15,42.33 40.23,42.4 41.22,42.4
SW_++VDDRP on IN2 (solid shape): 34.96,34.26 34.96,32.69 34.8,32.53 34.68,32.53 34.51,32.7 34.51,32.93 34.02,33.41 34.02,34.29 34.22,34.49 34.73,34.49
SW_+V1.05SP on BOTTOM (solid shape): 84.6,71.74 84.6,70.65 85.23,70.01 86.12,70.01 86.77,69.36 86.77,64.87 84.42,62.52 82.95,62.52 82.82,62.65 82.82,63.69 81.6,64.91 81.6,66.56 81.66,66.62 83.25,66.62 83.76,67.13 83.76,69.29 83.58,69.46 83.58,71.74 83.63,71.79 84.55,71.79
U2_LGATE1 on BOTTOM (solid shape): 64.96,40.52 64.96,39.5 64.7,39.25 63.69,39.25 63.56,39.38 63.56,40.39 63.82,40.65 64.83,40.65
U2_LGATE1 on BOTTOM (solid shape): 70.47,40.39 70.47,39.43 70.29,39.25 69.28,39.25 69.15,39.38 69.15,40.39 69.4,40.65 70.22,40.65
U2_LGATE1 on BOTTOM (solid shape): 58.36,32.7 58.36,31.68 58.1,31.43 58.1,30.36 58.03,30.28 57.9,30.28 57.82,30.36 57.82,32.65 57.92,32.75 58.31,32.75
U2_LGATE1 on IN1 (solid shape): 64.39,40.39 64.39,38.37 63.89,37.88 63.31,37.88 63.08,38.11 63.08,40.28 63.39,40.58 64.2,40.58
U2_LGATE1 on IN1 (solid shape): 58.67,33.79 58.67,31.76 58.55,31.63 57.98,31.63 57.91,31.69 57.91,33.79 57.98,33.85 58.61,33.85
U2_LGATE1 on IN3 (solid shape): 69.66,40.47 69.66,39.4 69.46,39.2 63.74,39.2 63.54,39.4 63.54,40.29 63.92,40.67 69.46,40.67
U2_LGATE2 on BOTTOM (solid shape): 48.13,40.54 48.13,39.56 47.94,39.38 46.92,39.38 46.8,39.5 46.8,40.52 46.97,40.7 47.97,40.7
U2_LGATE2 on BOTTOM (solid shape): 53.91,40.65 53.91,39.63 53.66,39.38 52.64,39.38 52.51,39.5 52.51,40.52 52.77,40.77 53.78,40.77
U2_LGATE2 on IN1 (solid shape): 52.96,40.65 52.96,39.38 52.64,39.06 52.64,38.36 52.51,38.23 51.75,38.23 51.63,38.36 51.63,40.65 51.75,40.77 52.83,40.77
