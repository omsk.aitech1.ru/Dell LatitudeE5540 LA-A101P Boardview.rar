# Allegro board Alpine15_LA-A101PR10-0826C.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
I2S_LRCLK: length 145.8
  TOP w0.102: v3(277.97,154.62) 279.39,156.04 289.17,156.04 289.46,156.04 290.18,155.33 294.42,155.33 295.31,154.44 299.42,154.44 299.88,154.9 302.2,154.9 302.48,155.18 304.31,155.18 305.05,155.92 307.09,155.92 307.4,155.61 v1(309.52,155.61) 312.84,155.61 314.42,154.04 v2(314.42,153.66)
  BOTTOM w0.102: v3(277.97,154.62) 271.12,154.62 269.64,156.09 269.23,156.51 269.23,161.5 259.37,171.36 226.86,171.36 225.84,172.38 212.29,172.38 211.25,171.33 209.14,171.33 205.15,167.35 201.94,167.35 199.22,170.06 192.62,170.06 192.09,170.6 190.69,170.6 190.01,171.28 190.01,171.62 R143.2 ; v2(314.42,153.66) 314.24,153.48 312.82,153.48 312.57,153.23 U17.18
I2S_MCLK: length 140.2
  TOP w0.102: v3(314.98,155.05) v1(314.07,155.96) 313.53,156.5 307.51,156.5 307.39,156.63 303.5,156.63 303.09,156.22 300.19,156.22 299.13,155.15 295.61,155.15 294.72,156.04 290.47,156.04 289.73,156.78 v2(285.18,156.78)
  BOTTOM w0.102: v2(285.18,156.78) 284.75,157.21 283.94,157.21 282.64,155.92 271.42,155.92 270.3,157.03 270.3,161.94 259.69,172.55 227.17,172.55 226.21,173.52 211.92,173.52 210.96,172.55 201.77,172.55 201.16,171.94 195.11,171.94 194.41,172.65 R137.2 ; U17.15 312.92,154.73 313.25,155.05 v3(314.98,155.05)
IMON: length 4.3
  BOTTOM w0.203: PU300.13 84.48,93.57 84.98,94.07
  BOTTOM w0.254: 84.98,94.07 85.05,94.15 PR301.1 85.54,94.58 v2(85.77,94.8) 85.77,95.6 PC300.1
IMVP_PWRGD: length 190
  TOP w0.102: v1(202.07,126.33) 202.07,126.03 201.25,125.21 R323.2 200.27,125.68 199.52,125.68 199.22,125.98 198.97,125.98 198.64,126.32 198.64,126.5 198.75,126.61 198.75,127.93 v3(199.15,128.33)
  IN1 w0.097: v2(78.37,90.07) 78.28,90.07 77.97,90.39 77.04,90.39 76.65,90.78 76.65,98.09 77.56,99 77.56,103.72 78.27,104.43 78.27,116.06 80.38,118.17 84.29,118.17 87.59,121.47 93.51,121.47 96.54,118.43 96.54,117.78 99.82,114.51 99.82,112.3 107.74,104.38 116.55,104.38 121.01,108.84 123.1,108.84 124.99,106.95 147.86,106.95 148.67,107.76 149.86,107.76 151,106.61 151.27,106.61 153.95,103.92 161.14,103.92 161.53,104.31 165.52,104.31 166.15,103.68 171.64,103.68 173.31,103.68 173.5,103.68 175.31,105.49 177.61,105.49 184.13,112.01 186.07,112.01 186.9,111.17 188.73,111.17 190.52,112.97 191.76,112.97 192.41,113.61 194.48,113.61 195.38,114.5 195.87,114.5 198.16,116.79 198.16,117.27 199.39,118.51 199.39,121.97 199.94,122.52 199.94,127.11 199.15,127.9 v3(199.15,128.33)
  BOTTOM w0.254: v2(78.37,90.07) 78.59,90.29 PR318.2
IMVP_VR_ON: length 390.1
  TOP w0.102: v3(84.6,80.17) 84.6,79.74 83.33,78.47 83.33,73.19 78.5,68.36 78.12,68.36 77.16,67.4 77.16,62.8 83.48,56.48 83.48,43.12 78.15,37.78 78.15,28.49 77.38,27.72 75.86,26.2 75.86,24.19 73.7,22.03 v3(73.7,20.94) ; R294.2 v2(201.36,128.82)
  IN2 w0.102: v2(201.36,128.82) 200.22,127.67 200.22,118.99 201.08,118.12 201.08,115.84 203.52,113.4 203.52,107.92 203.62,107.82 203.62,105.35 204.51,104.46 204.51,102.53 205.93,101.1 205.93,99.03 206.92,98.04 206.92,89.02 209.82,86.12 209.82,85.93 209.82,84.45 214.42,79.86 214.42,71.67 214.3,71.56 214.17,71.42 214.04,71.29 213.88,71.13 213.71,70.96 213.71,69.93 213.71,67.85 214.11,67.45 214.56,66.99 217.16,66.99 217.57,66.59 217.57,65.7 224.03,59.23 226.11,59.23 230.34,55 230.34,51.24 228.62,49.51 228.62,48.26 228.62,47.92 227.5,46.8 227.5,37.98 228.24,37.25 229.38,37.25 229.99,36.64 229.99,24.95 230.98,23.96 230.98,16.2 226.44,11.67 152.4,11.67 150.39,9.66 140.32,9.66 138.22,11.76 116.62,11.76 113.71,14.67 79.01,14.67 76.75,16.93 76.75,19.52 75.33,20.94 v3(73.7,20.94)
  BOTTOM w0.102: v3(84.6,80.17) 80.41,80.17 75.05,85.53 75.05,89.97 76.55,91.46 76.55,92.34 77.08,92.87 v1(78.04,92.87) 78.86,92.87 PR313.2
INT_SPK_L+: length 13.7
  IN3 w1.016: 290.39,146.82 290.44,146.82 295.34,151.73 299.91,151.73
  BOTTOM w0.254: U17.40 304,151.73 303.77,151.95 303.09,151.95 v2(302.96,152.08)
  vias: v1(290.82,146.11) v2(302.35,152.08) v3(289.27,145.86) v3(289.91,145.86)
INT_SPK_L-: length 12.3
  IN3 w1.016: 299.34,153.63 295.04,153.63 291.46,150.05 290.77,150.05
  BOTTOM w0.254: U17.41 304.13,152.23 304.02,152.34 303.47,152.34 302.99,152.82 302.89,152.82
  vias: v1(291.05,148.6) v3(290.44,149.16) v3(291.1,149.16) v3(300.96,152.82) v3(301.59,152.82)
INT_SPK_R+: length 9.7
  IN3 w1.016: 299.74,155.08 294.45,155.08 291.35,151.98
  vias: v1(291.89,150.86) v3(290.44,151.14) v3(291.1,151.14) v3(303.32,153.83) v3(303.95,153.83)
INT_SPK_R-: length 16.3
  IN3 w1.016: 291.48,153.91 294.45,156.88 301.03,156.88 302.66,155.26
  BOTTOM w0.254: v2(302.97,154.44) 302.83,154.31 302.83,153.55 303.09,153.3 304.08,153.3 304.15,153.23 U17.43
  vias: v2(303.57,154.42) v3(290.44,153.2) v3(291.1,153.22) v6(291.68,153.48)
INT_SPKR_L+: length 57
  IN3 w1.016: 236.54,124.62 236.87,124.95 244.11,124.95 244.77,125.61 252.63,125.61 271.96,144.94 284.78,144.94 285.03,145.2
  vias: v1(234,124.12) v3(226.86,125.82) v3(227.52,125.82) v3(234.94,124.67) v3(235.58,124.67) v3(285.54,146.21) v3(286.2,146.21)
INT_SPKR_L-: length 52.6
  IN3 w1.016: 284.19,148.53 282.13,146.47 271.69,146.47 252.11,126.88 240.58,126.88
  vias: v1(236.67,127.44) v3(228.11,129.07) v3(228.11,128.41) v3(238.19,126.73) v3(238.83,126.71) v3(285.51,148.55) v3(286.2,148.55)
INT_SPKR_R+: length 54
  IN3 w1.016: 284.55,150.91 283.43,150.91 280.55,148.03 271.46,148.03 255.07,131.64 253,131.64 249.51,128.15 239.94,128.15
  vias: v1(237.61,129.53) v3(229.38,130.39) v3(229.38,129.73) v3(238.45,128.2) v3(239.08,128.22) v3(285.54,150.86) v3(286.25,150.86)
INT_SPKR_R-: length 50.5
  IN3 w1.016: 285.03,153.3 283.15,153.3 279.37,149.52 271.15,149.52 254.54,132.91 252.47,132.91 249.44,129.88 244.26,129.88
  vias: v1(237.63,131.81) v3(230.29,131.34) v3(230.85,131.63) v3(242.23,130.06) v3(242.9,130.06) v3(285.61,153.2) v3(286.25,153.2)
INTRUDER#: length 6.1
  TOP w0.076: v2(166.34,60.16) 166.54,59.96 v6(166.54,59.63) 166.21,59.3 RC7.2
  BOTTOM w0.076: UC1.AU6 165.1,63.58 165.1,63.11 165.06,63.07 165.06,61.72 165.34,61.44 165.34,61.07 166.25,60.16 v2(166.34,60.16)
IO_LDOSEL: length 4.5
  BOTTOM w0.102: v1(15.61,26.53) 15.98,26.16 R214.1 R212.2 17.87,26.5 19.22,26.5 19.31,26.4 U27.18
IO_USBP2+: length 74.4
  TOP w0.102: U4.7 150.06,109.87 150.16,109.96 150.16,110.22 149.99,110.38 v3(149.65,110.38) 148.18,110.38 v2(147.97,110.18) ; JUDB1.15 107.06,127.27 106.96,127.37 106.73,127.37 106.52,127.15 105.55,127.15 104.02,128.69 99.71,128.69 99.56,128.54 v3(99.56,128.44)
  IN1 w0.097: v3(99.56,128.44) 99.56,128.48 99.83,128.76 100.07,128.76 100.34,128.49 100.34,126.75 107.36,119.73 107.36,114.94 110.53,111.76 111.89,111.76 113.07,110.58 113.75,110.58 115.13,111.96 127.09,111.96 129.9,109.15 146.22,109.15 147.36,110.3 147.85,110.3 v2(147.97,110.18)
IO_USBP2-: length 74.6
  TOP w0.102: v3(99.56,129.08) 99.73,128.9 104.11,128.9 105.64,127.37 106.43,127.37 106.65,127.58 106.84,127.58 107.02,127.77 JUDB1.14 ; v2(147.97,110.79) 148.16,110.6 149.36,110.6 149.38,110.62 149.93,110.62 149.94,110.6 150.08,110.6 150.37,110.31 150.37,109.88 150.46,109.79 U4.6
  IN1 w0.097: v3(99.56,129.08) 99.66,128.97 100.16,128.97 100.55,128.58 100.55,126.83 107.57,119.82 107.57,115.03 110.62,111.97 111.98,111.97 113.16,110.79 113.66,110.79 115.04,112.17 127.17,112.17 129.98,109.36 146.13,109.36 147.27,110.51 147.69,110.51 v2(147.97,110.79)
IOR_DB_DET#: length 207.6
  TOP w0.102: v1(341.31,158.25) v2(341.31,158.81) 341.39,158.89 R476.1 ; v2(195.12,124.18) 195.54,124.59 196.63,124.59 U37.B62
  IN3 w0.102: v3(253.03,134.86) 253.03,135.36 256.97,139.31 258.34,139.31 270.2,151.17 272.86,151.17 280.08,158.38 287.41,158.38 287.41,158.38 288.4,158.38 288.4,158.38 291.28,158.38 292.6,159.7 294.16,159.7 295.83,161.37 303.33,161.37 303.9,161.94 310.94,161.94 312.73,163.73 314.91,163.73 317.84,166.66 328.39,166.66 330.42,164.63 334.92,164.63 335.8,165.52 337.58,165.52 340.05,163.05 340.05,160.08 v2(341.31,158.81)
  BOTTOM w0.102: v2(341.31,158.81) 340.95,158.45 JIO1.80 ; v2(195.12,124.18) 195.66,123.63 197.2,123.63 199.08,121.75 200.84,121.75 201.51,121.07 201.51,118.92 202.53,117.9 202.53,117.13 213.32,106.33 213.32,105.04 215.68,102.69 215.81,102.55 222.78,102.55 222.97,102.37 225.04,102.37 226.11,102.37 227.55,103.8 227.55,105.75 226.6,106.69 226.6,111.82 228.46,113.68 228.46,113.68 228.64,113.86 228.64,121.45 231.96,124.76 234.06,124.76 234.48,125.18 243.85,125.18 248.52,129.84 250.09,129.84 251.22,130.97 251.22,133.84 252.24,134.86 v3(253.03,134.86)
IRQ_SERIRQ: length 118.9
  TOP w0.102: RP10.6 182.73,81.31 182.61,81.43 180.7,81.43 v3(180.6,81.53) ; v2(188.14,126.05) 188.05,126.14 U37.B21 ; v2(173.11,126.34) 173.11,126.29 172.21,125.39 U38.A28 ; v3(187.98,133.79) 188.33,134.15 188.33,134.4 v1(188.2,134.53) 186.68,134.53 186.14,135.06 185.84,135.06 185.25,135.65 U25.27
  IN1 w0.097: v2(188.14,126.05) 186.16,126.05 185.92,126.3 183.2,126.3 182.8,126.7 177,126.7 176.88,126.58 176.78,126.57 174.56,126.57 174.06,126.07 173.72,126.07 173.63,126.17 173.27,126.17 v2(173.11,126.34)
  IN2 w0.076: 170.88,75.6 170.68,75.4 167.58,75.4 167.29,75.1 166.88,75.1 v2(166.52,75.47)
  IN2 w0.102: v3(199.43,86.18) 199.19,86.42 199.19,89.08 198.87,89.39 198.87,95.67 198.01,96.53 197.61,96.93 197.47,97.07 196.03,98.51 196.03,101.71 189.47,108.27 189.47,109.82 188.87,110.43 188.87,112.56 189.73,113.42 189.73,114.67 189.53,114.88 189.53,119.01 189.12,119.42 189.12,120.56 189.63,121.07 189.63,125.39 189.4,125.61 188.58,125.61 v2(188.14,126.05) ; v3(180.6,81.53) 180.21,81.14 179.94,81.14 178.36,79.56 175.94,79.56 173.4,77.03 172.31,77.03 170.88,75.6
  IN3 w0.102: v3(187.98,133.79) 187.47,133.29 187.47,128.21 187.77,127.9 187.77,126.42 v2(188.14,126.05)
  BOTTOM w0.076: UC1.T4 166.19,75.8 v2(166.52,75.47)
  BOTTOM w0.102: v3(180.6,81.53) 180.6,82.29 181.37,83.06 185.84,83.06 186.19,83.4 191.61,83.4 191.93,83.72 196.56,83.72 199.03,86.18 v3(199.43,86.18)
JTAG_CLK: length 119.2
  TOP w0.102: RP2.3 155.13,126.91 155.69,127.47 155.69,127.8 155.31,128.18 v3(154.88,128.18) ; U38.B56 162.06,125.64 162.09,125.61 162.5,125.61 v2(162.88,126) ; v2(223.03,93.05) JDEG1.4
  IN3 w0.102: v3(154.88,128.18) 154.96,128.18 155.26,127.88 156.07,127.88 156.17,127.98 158.85,127.98 159.22,127.98 159.58,127.62 160.61,127.62 161.4,126.83 161.76,126.83 161.99,126.61 162.32,126.61 162.88,126.05 v2(162.88,126)
  BOTTOM w0.102: v3(154.88,128.18) 154.63,128.43 154.63,132.08 157.45,134.9 157.45,135.16 159.02,136.74 162.15,136.74 163.9,134.99 166.89,134.99 167.61,135.7 172.41,135.7 178.96,129.15 178.96,123.09 179.16,122.89 179.16,114.57 185.59,108.14 185.6,108.14 188.8,104.94 191.11,104.94 193.75,102.3 195.41,102.3 197.3,100.41 197.3,99.46 197.3,98.75 201.47,94.58 205.11,94.58 205.26,94.42 205.28,94.42 205.68,94.02 208.15,91.55 210.9,91.55 211.38,91.07 218.44,91.07 218.95,91.58 220.41,91.58 220.57,91.58 221.82,92.83 222.81,92.83 v2(223.03,93.05)
JTAG_RST#: length 9.4
  TOP w0.102: U38.A57 159.01,123.39 158.64,123.02 C362.1 R384.1 R380.2 155.21,123.02 155.13,123.1 JTAG1.1 154.42,122.4 154.31,122.29 153.41,122.29 153.2,122.08 v1(153.2,121.27)
JTAG_TDI: length 117.4
  TOP w0.102: v2(159.69,126.34) 159.74,126.39 U38.A51 ; v3(223.49,92.04) 223.5,92.05 JDEG1.2 ; RP2.1 154.27,125.89 155.51,125.89 155.74,126.12 v3(155.74,126.3)
  IN3 w0.102: v3(155.74,126.3) 155.83,126.39 158.89,126.39 159.08,126.2 159.55,126.2 v2(159.69,126.34)
  BOTTOM w0.102: v1(223.59,95.26) 223.94,94.91 223.94,92.56 223.49,92.1 v3(223.49,92.04) 223.33,91.88 221.52,91.88 220.76,91.12 220.23,91.12 220.22,91.12 219.14,91.12 218.63,90.61 211.19,90.61 210.71,91.1 207.96,91.1 205.23,93.83 205.09,93.97 205.08,93.97 204.92,94.12 201.28,94.12 196.84,98.56 196.84,99.65 196.84,99.65 196.84,100.22 195.22,101.84 193.56,101.84 191.88,103.52 189.57,103.52 187.26,105.83 186.61,105.83 182.29,110.15 182.29,110.7 178.55,114.44 178.55,117.41 178.12,117.84 178.12,123.56 178.35,123.79 178.35,126.4 174.66,130.08 174.66,132.8 172.93,134.53 163.71,134.53 161.96,136.28 159.56,136.28 158.86,135.59 158.86,135.11 158.62,134.87 158.06,134.87 155.51,132.33 155.51,128.87 155.51,128.87 155.51,128.51 155.83,128.19 155.83,127.4 155.51,127.09 155.51,126.53 v3(155.74,126.3)
JTAG_TDO: length 116.8
  TOP w0.102: v3(154.97,127.55) 154.83,127.41 RP2.4 ; v2(162.3,126.03) 162.19,126.14 U38.B55 ; v3(223.51,93.51) 223.55,93.55 JDEG1.5
  IN3 w0.102: v2(162.3,126.03) 162.18,126.15 160.52,126.15 159.1,127.57 156.33,127.57 156.18,127.42 155.1,127.42 v3(154.97,127.55)
  BOTTOM w0.102: v3(154.97,127.55) 154.78,127.55 154.35,127.98 154.35,132.13 157.22,135 157.22,135.26 158.93,136.97 162.25,136.97 164,135.22 166.8,135.22 167.51,135.93 172.5,135.93 172.64,135.79 179.19,129.24 179.19,123.19 179.39,122.99 179.39,114.66 185.68,108.37 185.69,108.37 188.61,105.45 190.92,105.45 193.84,102.53 195.5,102.53 197.53,100.5 197.53,99.37 197.53,99.37 197.53,98.84 199.57,96.79 201.56,94.8 205.21,94.8 205.36,94.65 205.38,94.65 205.91,94.12 208.25,91.78 210.99,91.78 211.48,91.3 218.35,91.3 218.86,91.81 220.48,91.81 222.18,93.51 v1(222.61,93.51) v3(223.51,93.51)
JTAG_TMS: length 114.2
  TOP w0.102: v3(222.9,92.34) 223.11,92.55 JDEG1.3 ; v2(159.43,125.82) 159.43,125.68 v1(159.71,125.39) U38.A53 ; RP2.2 154.98,126.41 v3(155.06,126.33)
  IN3 w0.102: v2(159.43,125.82) 159.32,125.92 159.03,125.92 158.79,126.16 156.18,126.16 155.91,125.89 155.49,125.89 v3(155.06,126.33)
  BOTTOM w0.102: v3(222.9,92.34) 222.7,92.54 221.86,92.54 220.67,91.35 220.32,91.35 219.05,91.35 218.54,90.84 211.29,90.84 210.8,91.32 208.06,91.32 205.46,93.93 205.19,94.19 205.17,94.19 205.02,94.35 201.37,94.35 197.07,98.65 197.07,99.56 197.07,100.31 195.31,102.07 193.65,102.07 191.26,104.46 188.95,104.46 185.5,107.91 185.49,107.91 178.93,114.47 178.93,122.8 178.73,123 178.73,126.34 174.9,130.17 174.9,132.89 173.02,134.76 163.81,134.76 162.06,136.51 159.12,136.51 157.67,135.07 157.67,134.81 155.03,132.17 155.03,128.66 155.6,128.09 155.6,127.5 155.29,127.18 155.29,126.55 v3(155.06,126.33)
KB_DET#: length 131.6
  TOP w0.102: JKB1.10 203.64,103.65 205.6,101.69 211.04,101.69 v3(212.28,102.93) ; RP13.1 184.1,60.22 184.17,60.29 v2(184.17,61)
  IN2 w0.102: v3(223.49,67.32) 218.61,72.2 218.61,80.41 212.54,86.48 212.54,87.62 213.33,88.4 213.33,89.34 212.77,89.9 212.77,92.46 212.66,92.56 212.53,92.7 212.53,92.7 211.97,93.26 211.97,102.61 v3(212.28,102.93)
  BOTTOM w0.076: UC1.AT3 166.89,64.56 167.15,64.3 167.66,64.3 167.78,64.43 167.78,64.67 168,64.88 168.27,64.88 169.01,64.13 169.1,64.05 170.56,64.05 170.61,63.99 170.63,63.99 170.69,63.94 170.78,63.94
  BOTTOM w0.102: v3(223.49,67.32) v1(223.97,66.83) 224.47,66.34 224.47,57.12 224.47,57.12 224.47,56.74 219.84,52.11 214.4,52.11 212.65,53.86 208.83,53.86 207.84,54.85 204.8,54.85 204.18,54.23 196.3,54.23 195.6,54.93 192.31,54.93 190.84,56.4 190.48,56.4 187.9,58.98 187.9,60.21 187.39,60.72 185.36,60.72 185.11,60.46 184.5,60.46 184.17,60.79 v2(184.17,61) 183.68,61.48 178.62,61.48 178.11,60.97 174.83,60.97 174.69,61.11 174.52,61.28 174.06,61.28 171.69,63.64 171.54,63.79 171.39,63.94 170.89,63.94 170.88,63.94 170.78,63.94
LAN_ACTLED_YEL#: length 160.1
  TOP w0.102: Q32.1 v3(203.71,164.76)
  IN3 w0.102: v3(279.31,154.6) 279.31,155.74 280.81,157.24 286.12,157.24 286.86,156.5 290.13,156.5 292.88,159.24 294.35,159.24 296.02,160.91 303.52,160.91 304.09,161.48 311.19,161.48 312.77,163.05 317.11,163.05 317.69,163.64 v3(317.69,165.26)
  BOTTOM w0.102: v3(203.71,164.76) 204.85,165.9 206.82,165.9 212.58,171.66 225.55,171.66 226.15,171.07 226.59,170.62 259.1,170.62 268.52,161.21 268.52,156.21 269.35,155.38 270.87,153.86 271.17,153.86 278.58,153.86 v3(279.31,154.6) ; v3(317.69,165.26) 317.69,165.44 319.68,167.42 319.68,172.1 321.68,174.1 333.39,174.1 v1(333.78,173.71) 334.54,172.95 JIO1.21
LAN_ACTLED_YEL#_Q: length 5.1
  TOP w0.102: U23.17 200.42,168.57 200.68,168.31 201.34,168.31 v1(202.92,166.72) 203.71,165.94 Q32.6
LAN_DISABLE#_R: length 33.8
  TOP w0.102: U21.3 197.71,145.65 197.07,145.01 v1(197.07,144.87) 196.92,144.72 196.92,144.15 196.02,143.24 196.02,142.06 R180.2 195.7,141.74 193.26,141.74 v3(193.08,141.92) ; U37.B47 194.08,119.39 194.13,119.43 194.13,120.1 v2(194.54,120.5)
  IN3 w0.102: v3(193.08,141.92) 193.08,141.74 191.33,139.99 191.33,132.14 190.95,131.76 190.95,129.37 191.84,128.48 192.5,128.48 192.85,128.13 192.85,127.14 192.75,127.04 192.75,123.66 194.56,121.85 194.56,120.53 v2(194.54,120.5)
LAN_RST#: length 153.5
  TOP w0.102: U20.1 194.45,157.54 194.58,157.67 195.16,157.67 R331.1 v2(196.24,157.31) 196.98,157.31 v1(197.03,157.26)
  IN2 w0.076: 170.77,74.33 169.27,74.33 v2(168.88,73.94)
  IN2 w0.102: v3(188.43,79.62) 188.43,78.9 188.18,78.65 185.82,78.65 183.04,81.43 181.75,81.43 181.19,80.88 181.19,80.56 180.9,80.26 180.03,80.26 178.65,78.88 176.37,78.88 173.83,76.34 173.17,76.34 171.16,74.33 170.77,74.33
  IN3 w0.102: v3(188.43,79.62) 188.42,79.63 188.42,81.8 186.3,83.92 186.3,84.64 185.79,85.15 185.79,86.42 184.22,88 184.22,89.26 184.5,89.55 185,89.55 185.79,90.33 196.18,90.33 v3(203.57,97.73)
  BOTTOM w0.076: v2(168.88,73.94) 168.65,73.71 168.27,73.71 UC1.Y1
  BOTTOM w0.102: v3(203.57,97.73) 200.19,101.1 200.19,102.47 195.23,107.43 193.21,107.43 191.23,109.41 188.89,109.41 181.42,116.88 181.42,124.65 181.75,124.98 181.75,127.24 181.42,127.57 181.42,129.98 180.61,130.8 180.61,131.36 181.37,132.12 181.37,135.37 176.07,140.68 176.06,140.68 176.06,141.62 175.56,142.12 175.56,144.43 179.98,148.85 182.59,148.85 183.2,148.25 190.08,148.25 193.69,151.85 193.69,153.65 195.44,155.4 195.44,156.51 v2(196.24,157.31)
LAN_SMBCLK: length 171.4
  TOP w0.102: U21.28 200.11,153.48 200.31,153.68 200.31,154.27 200.88,154.84 200.88,156.14 v1(200.14,156.87) 198.94,158.08 198.94,158.08 198.21,158.81 192.84,158.81 v3(192.63,159.02) ; RC186.1 182.29,73.98 181.7,73.98 179.84,72.12 175.17,72.12 174.35,71.31 174.16,71.31 172.46,69.61 170.98,69.61 170.24,68.86 170.24,67.23 170.2,67.19 170.2,66.46 169.61,65.87 v2(169.61,65.47)
  IN1 w0.097: v3(198.8,98.74) 198.97,98.91 199.36,98.91 199.72,99.27 199.72,99.8 198.29,101.23 198.29,103.19 204.69,109.59 204.69,110.24 207.55,113.1 207.55,113.12 209.95,115.52 209.95,132.56 210.21,132.81 210.21,134.2 205.54,138.87 198.32,138.87 197.02,140.18 197.02,145.81 193.56,149.26 193.56,154.78 192.68,155.67 192.68,156.58 193.72,157.62 193.72,158.38 193.26,158.84 192.81,158.84 v3(192.63,159.02)
  IN3 w0.076: 171.03,67.19 170.34,66.5 170.34,66.29 169.91,65.86 169.76,65.86 169.76,65.86 169.7,65.86 169.61,65.77 v2(169.61,65.47)
  IN3 w0.102: v3(198.8,98.74) 198.59,98.94 198.08,98.94 194.98,95.85 184.38,95.85 179.85,91.32 179.46,91.32 177.63,89.5 175.38,89.5 172.67,86.79 172.67,83.6 174.46,81.81 174.78,81.81 174.88,81.71 176.44,80.15 176.44,75.87 175.91,75.34 175.17,75.34 174.84,75.01 174.84,71.72 173.98,70.85 173.59,70.85 172.37,69.63 171.69,69.63 171.06,69.01 171.06,67.22 171.03,67.19
  BOTTOM w0.076: UC1.AN1 168.31,66.09 168.49,65.91 169.27,65.91 169.61,65.57 v2(169.61,65.47)
LAN_SMBDATA: length 165.7
  TOP w0.102: v2(168.67,68.24) 168.67,68.34 169.08,68.75 169.81,68.75 170.89,69.84 172.36,69.84 174.06,71.54 174.26,71.54 175.07,72.35 179.75,72.35 181.6,74.21 182.44,74.21 RC192.1 ; v3(192.63,158.39) 192.83,158.58 198.11,158.58 198.71,157.99 v1(198.71,157.58) 199.72,156.57 199.72,156.32 199.08,155.68 199.08,154.37 198.88,154.17 198.88,152.71 198.91,152.68 U21.31
  IN1 w0.097: v3(198.8,99.38) 199.04,99.13 199.27,99.13 199.49,99.36 199.49,99.71 198.06,101.14 198.06,101.32 198.06,103.28 204.47,109.69 204.47,110.34 207.33,113.2 207.33,113.21 209.73,115.61 209.73,132.65 209.98,132.9 209.98,134.11 205.45,138.65 198.23,138.65 196.79,140.08 196.79,145.71 193.34,149.17 193.34,154.69 192.45,155.58 192.45,156.67 193.49,157.71 193.49,158.29 193.17,158.61 192.86,158.61 v3(192.63,158.39)
  IN3 w0.076: v2(168.67,68.24) 168.67,68.34 169.06,68.73 170.09,68.73 170.29,68.92 170.65,68.92 171.03,69.3
  IN3 w0.102: v3(198.8,99.38) 198.59,99.17 197.98,99.17 194.89,96.08 184.29,96.08 179.76,91.55 179.37,91.55 177.54,89.72 175.28,89.72 172.44,86.89 172.44,83.5 174.37,81.58 174.69,81.58 174.72,81.55 176.22,80.05 176.22,75.96 175.82,75.56 175.07,75.56 174.62,75.11 174.62,71.81 173.89,71.08 173.5,71.08 172.28,69.86 171.59,69.86 171.03,69.3
  BOTTOM w0.076: UC1.AK1 168.14,68.34 168.57,68.34 v2(168.67,68.24)
LAN_TEST_EN: length 2.9
  TOP w0.102: U21.30 199.31,152.66 199.13,152.84 199.13,153.45 v1(199.32,153.64) 199.77,154.1 R184.1
LAN_TX0+: length 23.8
  TOP w0.089: v2(191.71,161.4) 191.71,162.03 191.4,162.34 L27.1 ; v2(203.35,146.38) 203.29,146.44 202.84,146.44 202.41,146.87 U21.13
  IN1 w0.089: v2(191.71,161.4) 191.99,161.12 191.99,160.71 192.56,160.13 193.45,160.13 195.22,158.37 195.22,156.52 195.34,156.39 197.52,154.21 198.62,153.11 198.62,150.2 202.44,146.38 v2(203.35,146.38)
LAN_TX0+R: length 5.5
  TOP w0.089: U23.2 192.92,168.21 192.97,168.15 192.97,167.07 192.03,166.13 v1(192.03,165.29) 192.03,164.72 L27.2
LAN_TX0-: length 23.8
  TOP w0.089: v2(203.35,146.97) 203.22,146.84 203,146.84 202.57,147.27 U21.14 ; v2(192.32,161.41) 192.28,161.41 192.1,161.59 192.1,161.97 192.28,162.15 192.76,162.15 192.92,162.31 L28.1
  IN1 w0.089: v2(192.32,161.41) 192.32,160.84 192.7,160.46 193.59,160.46 195.55,158.51 195.55,156.65 197.76,154.44 198.95,153.25 198.95,150.34 202.58,146.71 203.09,146.71 v2(203.35,146.97)
LAN_TX0-R: length 5.4
  TOP w0.089: U23.3 193.42,168.21 193.36,168.15 v1(193.36,167.11) 193.36,166.91 192.42,165.97 192.42,164.59 L28.2
LAN_TX1+: length 20
  TOP w0.089: L29.1 194.94,162.2 v2(194.94,161.17) ; U21.17 203.43,148.47 v2(203.53,148.37)
  IN1 w0.089: v2(194.94,161.17) 194.94,160.33 196.61,158.65 196.61,157.99 200.5,154.1 200.5,150.62 202.5,148.62 202.75,148.37 v2(203.53,148.37)
LAN_TX1+R: length 5.1
  TOP w0.089: U23.6 194.92,168.21 194.97,168.15 v1(194.97,165.58) 194.97,164.61 L29.2
LAN_TX1-: length 20
  TOP w0.089: L30.1 195.84,162.69 195.33,162.18 195.33,161.37 195.52,161.17 v2(195.55,161.17) ; v2(203.53,148.96) 203.43,148.86 202.09,148.86 U21.18
  IN1 w0.089: v2(203.53,148.96) 203.27,148.7 202.89,148.7 202.73,148.86 200.83,150.76 200.83,154.24 196.94,158.13 196.94,158.79 195.27,160.46 195.27,160.96 195.32,161.01 195.32,161.05 195.44,161.17 v2(195.55,161.17)
LAN_TX1-R: length 5.1
  TOP w0.089: L30.2 195.37,164.69 v1(195.37,167.32) 195.37,168.16 195.42,168.21 U23.7
LAN_TX2+: length 17.1
  TOP w0.089: v2(203.48,149.76) 203.39,149.67 202.09,149.67 U21.20 ; v2(198.01,161.65) 198.01,162.18 L31.1
  IN1 w0.089: v2(198.01,161.65) 198.01,159.67 202.5,155.17 202.5,150.22 202.97,149.76 v2(203.48,149.76)
LAN_TX2+R: length 5.8
  TOP w0.089: U23.9 196.42,168.39 196.49,168.32 196.49,168.12 196.38,168.02 196.38,166.66 v1(197.45,165.6) 198.07,164.97 198.07,164.65 197.53,164.11 197.52,164.11 L31.2
LAN_TX2-: length 17.1
  TOP w0.089: U21.21 203.2,150.07 v2(203.48,150.34) ; v2(198.62,161.65) 198.59,161.65 198.4,161.84 198.4,162.07 L32.1
  IN1 w0.089: v2(203.48,150.34) 203.48,150.31 203.26,150.09 203.11,150.09 202.84,150.36 202.84,155.31 198.34,159.8 198.34,161.44 198.56,161.65 v2(198.62,161.65)
LAN_TX2-R: length 5.8
  TOP w0.089: U23.10 196.92,168.37 196.88,168.33 196.88,167.96 196.78,167.86 v1(196.78,167.11) 196.78,166.83 197.26,166.35 197.73,165.87 198.19,165.42 198.2,165.4 198.47,165.14 198.47,164.64 L32.2
LAN_TX3+: length 17
  TOP w0.089: L33.1 200.71,162.69 201.03,162.37 v2(201.03,161.58) ; v2(205.2,151.55) 205.14,151.61 204.5,151.61 204.03,151.14 v1(203.27,151.14) 203.03,151.14 202.75,150.87 U21.23
  IN1 w0.089: v2(205.2,151.55) 204.56,151.55 203.98,152.13 203.98,157.94 201.03,160.89 v2(201.03,161.58)
LAN_TX3+R: length 7.2
  TOP w0.089: L33.2 201.08,164.63 201.08,164.94 200.33,165.68 v1(199.18,165.68) 197.58,167.28 197.58,167.83 197.48,167.93 197.48,168.36 197.42,168.42 U23.11
LAN_TX3-: length 17
  TOP w0.089: U21.24 202.83,151.27 203.18,151.61 203.94,151.61 204.33,152.01 v1(204.57,152.01) 205.07,152.01 v2(205.2,152.13) ; L34.1 201.81,162.69 201.43,162.3 201.43,161.77 201.62,161.58 v2(201.64,161.58)
  IN1 w0.089: v2(205.2,152.13) 205.2,152.07 205.01,151.88 204.7,151.88 204.31,152.27 204.31,158.08 201.36,161.02 201.36,161.36 201.58,161.58 v2(201.64,161.58)
LAN_TX3-R: length 7.3
  TOP w0.089: U23.12 197.92,168.47 197.87,168.43 197.87,168.1 197.97,167.99 197.97,167.45 199.34,166.08 200.5,166.08 v1(201.24,165.33) 201.48,165.1 201.48,164.68 L34.2
LAN_WAKE#: length 54.6
  TOP w0.102: v3(176.14,117.11) 176.29,117.11 176.76,116.64 176.76,115.7 175.78,114.72 RC211.1 ; v3(175.3,140.19) 176.32,139.18 185.52,139.18 188.97,142.63 v1(190.19,142.63) R179.1 ; U38.B27 170.32,124.14 v2(170.09,124.37)
  IN3 w0.102: v2(170.09,124.37) 170.93,125.21 170.93,126.15 172.23,127.44 172.96,127.44 174.49,128.97 174.49,134.67 174.87,135.05 174.87,135.93 174.78,136.02 174.78,137.14 175.3,137.67 v3(175.3,140.19)
  BOTTOM w0.102: v3(176.14,117.11) 175.79,117.11 175.61,117.29 175.61,120.1 174.53,121.18 174.53,122.58 173.04,124.07 171.85,124.07 171.54,124.37 v2(170.09,124.37)
LAN_WAKE#_R: length 5.3
  TOP w0.102: U21.2 197.31,145.63 196.55,144.87 196.55,144.09 195.98,143.52 v1(195.67,143.52) 194.71,143.52 R176.1 R179.2
LANCLK_REQ#: length 112.4
  TOP w0.102: v2(190.64,144.69) v1(191.38,145.42) R169.1 ; v3(181.73,80.8) 181.85,80.8 182.34,80.31 183.08,80.31 RP10.8
  IN1 w0.097: v3(181.73,80.8) 182.61,80.8 183.62,79.79 185.72,79.79 190.41,84.49 190.41,84.9 194.3,88.78 194.3,93.53 194.99,94.22 194.99,94.85 192.12,97.73 192.12,104.49 195.94,108.31 196.11,108.48 196.11,109.26 197.38,110.53 198.33,110.53 202.03,114.23 202.03,114.88 205.73,118.58 205.87,118.72 205.87,118.72 205.87,120.99 206.27,121.39 206.27,125.92 205.48,126.71 205.48,132.97 202.36,136.1 197.25,136.1 195.66,137.69 194.47,137.69 194.19,137.97 190.64,141.52 v2(190.64,144.69)
  IN2 w0.076: v3(168.74,71.69) 169.04,71.69 170.88,73.53
  IN2 w0.102: 170.88,73.53 171.29,73.94 171.29,74.12 173.29,76.11 174,76.11 176.53,78.65 178.74,78.65 180.13,80.03 181.03,80.03 181.73,80.73 v3(181.73,80.8)
  BOTTOM w0.076: UC1.AD1 168.38,71.34 168.74,71.69 v3(168.74,71.69)
LANCLK_REQ#_R: length 3.2
  TOP w0.102: U21.48 195.41,146.87 v1(194.57,146.02) 193.97,145.42 R169.2
LCD_CBL_DET#: length 162.9
  TOP w0.102: v3(107.59,151.42) v1(104.21,151.42) 101.57,154.06 100.8,154.06 100.69,153.95 JLVDS1.14
  IN2 w0.102: v3(109.73,127.97) 111.05,127.97 113.73,130.66 120.94,130.66 121.28,130.32 124.79,130.32 127.17,127.94 127.17,127.23 127.17,126.14 128.07,125.23 130.03,125.23 133.38,128.59 146.83,128.59 150.49,124.93 150.49,118.27 153.39,115.37 153.39,113 154.08,112.32 154.6,112.32 155.18,112.9 157.2,112.9 158.26,111.85 158.26,109.98 158.85,109.38 167.03,109.38 168.02,108.39 170.79,108.39 174.16,105.03 174.16,102.16 175.33,100.99 175.33,98.67 177.56,96.43 179.12,96.43 179.77,95.78 179.77,93.74 176.6,90.56 175.26,90.56 172.09,87.39 172.09,80.9 v2(172.02,80.83)
  BOTTOM w0.076: 170.78,80.72 169.73,80.72 168.87,79.87 168.04,79.87 167.85,79.68 167.85,79.55 167.61,79.31 167.08,79.31 UC1.J3
  BOTTOM w0.102: RP9.8 175.07,79.16 175.07,80.2 174.79,80.48 174.74,80.53 172.33,80.53 v2(172.02,80.83) 171.09,80.83 170.97,80.72 170.78,80.72 ; v3(109.73,127.97) 109.45,127.97 107.41,130.01 107.41,151.24 v3(107.59,151.42)
LCD_ENVDD_CVT: length 68.3
  TOP w0.102: U52.20 121.9,124.56 122.37,125.03 125.82,125.03 127.35,126.55 v3(129.35,126.55)
  IN2 w0.102: v3(101.16,128.15) 102.75,129.74 109.68,129.74 111.74,131.8 119.56,131.8 119.73,131.96 120.04,131.96 120.44,131.57 121.32,131.57 121.62,131.28 122.18,131.28 122.19,131.28 125.78,131.28 129.35,127.71 v3(129.35,126.55)
  BOTTOM w0.102: U86.1 89.98,143.42 R110.1 89.22,142.66 89.22,140.19 93.28,136.13 v1(93.28,129.68) 93.28,129.02 95.65,126.66 99.66,126.66 v3(101.16,128.15)
LCD_TST: length 121.3
  TOP w0.102: R309.2 189.12,116.19 189.12,116.75 v2(188.99,116.88) 188.99,116.92 189.84,117.76 U37.A36 ; v3(108.45,139.46) v1(107.53,140.37) 107.53,140.88 106.39,142.02 100.47,142.02 100.05,142.45 JLVDS1.37
  IN1 w0.097: v3(117.44,140.4) 117.92,139.91 118.76,139.91 119.11,139.57 129.7,139.57 132.17,137.1 133.21,137.1 135.23,135.08 141.47,135.08 142.94,136.54 143.72,136.54 144.28,136.54 144.28,136.54 146.31,136.54 151.26,131.58 151.26,129.85 152.82,128.29 152.82,125.99 152.16,125.33 152.16,116.52 153,115.68 153,113.48 155.41,111.07 156.08,111.07 156.45,111.07 157.12,111.74 157.85,111.74 157.86,111.74 160.98,111.74 161.07,111.83 162.32,111.83 163.46,111.83 164.21,111.07 164.82,111.07 165.3,110.6 169.88,110.6 170.37,111.09 174.92,111.09 177.81,113.98 178.92,113.98 181.53,116.59 188.71,116.59 v2(188.99,116.88)
  IN3 w0.102: v3(117.44,140.4) 116.5,139.46 v3(108.45,139.46)
LCD_VCC_TEST_EN: length 141.2
  TOP w0.102: U37.A40 191.84,117.63 v2(191.69,117.48)
  IN1 w0.097: v2(191.69,117.48) 191.69,117.61 191.41,117.89 190.13,117.89 190.09,117.85 190.09,117.85 189.37,117.13 189.37,116.58 189.16,116.37 181.63,116.37 179.01,113.75 177.9,113.75 175.01,110.86 173.48,110.86 173.29,110.86 173.29,110.86 173.11,110.86 173.11,110.86 170.53,110.86 170.52,110.85 170.46,110.85 169.98,110.37 165.21,110.37 164.73,110.85 164.12,110.85 163.36,111.6 163.16,111.6 161.17,111.6 161.08,111.51 157.76,111.51 157.76,111.52 157.21,111.52 156.55,110.85 155.99,110.85 155.99,110.85 155.32,110.85 152.64,113.52 152.64,115.58 151.88,116.35 151.88,128.92 151.03,129.76 151.03,131.49 149.85,132.68 146.21,136.31 144.19,136.31 143.03,136.31 141.55,134.83 135.12,134.83 133.11,136.84 132.08,136.84 129.6,139.33 118.82,139.33 118.48,139.66 117.34,139.66 116.65,140.35 116.65,142.99 107.2,152.44 v3(105.43,152.44)
  BOTTOM w0.102: D76.3 95.94,143.18 96.26,142.86 v1(96.55,142.86) 97.15,142.86 97.63,143.34 103.02,143.34 104.59,144.91 104.59,151.29 105.43,152.13 v3(105.43,152.44)
LED_10_GRN#: length 108.7
  IN3 w0.102: v3(318.99,165.26) 318.99,165.26 318.99,163.98 317.25,162.24 313.9,162.24 311.38,159.73 306.55,159.73 306.15,159.32 302.37,159.32 301.33,160.36 298.49,160.36 296.92,158.79 293.07,158.79 290.3,156.02 281.47,156.02 280.61,155.15 v3(280.61,154.6)
  BOTTOM w0.102: Q22.4 250.63,167.37 250.91,167.65 v1(253.5,167.65) 261.43,167.65 268.06,161.02 268.06,156.02 269.16,154.93 270.68,153.4 271.36,153.4 279.42,153.4 v3(280.61,154.6) ; v3(318.99,165.26) 318.99,165.26 318.99,165.39 320.13,166.53 320.13,171.39 322.39,173.65 332.22,173.65 333.83,172.04 333.92,171.95 JIO1.25
LED_10_GRN#_Q: length 75.1
  TOP w0.102: v3(190.67,160.92) 190.34,161.25 190.34,164.42 191.2,165.28 191.2,166.48 191.53,166.81 191.53,169.3 191.11,169.72 191.11,170.03 191.47,170.38 U23.41
  BOTTOM w0.102: v3(190.67,160.92) 192.01,162.27 206.1,162.27 214.81,170.98 222.99,170.98 224.82,169.15 237.3,169.15 238.12,168.34 v1(246.75,168.34) 247.31,168.34 248.73,166.92 Q22.3
LED_100_ORG#: length 157.7
  TOP w0.102: Q32.4 v3(205.01,164.77)
  IN3 w0.102: v3(279.97,154.6) 279.97,155.26 280.99,156.27 290.23,156.27 292.97,159.02 294.45,159.02 296.11,160.68 303.61,160.68 304.18,161.25 311.39,161.25 312.97,162.83 317.44,162.83 318.35,163.74 v3(318.35,165.26)
  BOTTOM w0.102: JIO1.23 334.15,172.45 332.72,173.87 322.02,173.87 v1(321.56,173.42) 319.9,171.76 319.9,166.97 318.35,165.42 v3(318.35,165.26) ; v3(279.97,154.6) 279.01,153.63 271.26,153.63 270.78,153.63 269.25,155.15 268.29,156.12 268.29,161.11 259.01,170.39 226.49,170.39 226.47,170.42 225.45,171.44 212.92,171.44 206.25,164.77 v3(205.01,164.77)
LED_100_ORG#_Q: length 9.5
  TOP w0.102: U23.18 201.54,169.88 202.3,169.12 v1(203.6,169.12) 205.5,167.22 205.5,164.63 205.01,164.14 Q32.3
LED_DET#: length 119.9
  TOP w0.102: v2(188.36,117.46) 188.36,117.46 188.84,117.94 U37.A34 ; v3(226.41,40.04) 226.41,39.71 R478.1 ; v3(218.06,35.9) 216.86,34.7 JLED1.4
  IN1 w0.097: v3(226.41,40.04) 222.27,35.9 v3(218.06,35.9)
  IN2 w0.102: v2(188.36,117.46) 188.36,115 188.64,114.72 188.64,110.22 189.24,109.61 189.24,108.17 195.57,101.85 v3(195.57,99.3)
  BOTTOM w0.102: v3(195.57,99.3) 195.57,98.53 199.7,94.41 200.83,93.28 200.83,91.83 204.02,88.63 209.7,88.63 210,88.94 218.91,88.94 220.56,87.29 220.56,82.9 225.71,77.76 225.97,77.76 227.52,76.21 227.52,71.65 226,70.12 v1(226,61.82) 226,61.56 225.5,61.06 225.5,59.79 226.04,59.25 226.04,46.76 227.42,45.38 227.42,41.06 v3(226.41,40.04)
LED_SATA_DIAG_OUT#: length 130.2
  TOP w0.102: D24.1 221.16,40.9 224.1,40.9 224.45,40.55 225.77,40.55 v1(226.77,41.55) 228.36,43.14 228.36,44.03 228.92,44.59 v3(228.92,45.17) ; U37.A10 v2(191.33,129.87)
  IN2 w0.102: v2(191.33,129.87) 191.33,131.71 191.48,131.85 191.48,132.68 192.94,134.15 194.98,134.15 196.3,132.83 198.48,132.83 199.35,131.96 203.67,131.96 204.11,131.53 204.11,130.13 207.84,126.4 207.84,105.44 209.77,103.51 209.77,103 210.71,102.06 210.71,92.19 211.62,91.27 211.62,85.15 216.02,80.76 216.02,71 215.31,70.29 215.31,69.27 215.58,69 218.42,69 231.28,56.14 231.28,50.89 229.53,49.14 229.53,45.96 228.92,45.35 v3(228.92,45.17)
LED_WWAN_OUT#: length 18.9
  BOTTOM w0.102: Q30.4 248.61,162.68 R226.1 246.73,163.67 246.73,166.41 245.86,167.27 v1(245.25,167.27) 241.72,167.27 240.63,166.18 240.63,161.23 240.96,160.9 JMINI2.42
LG_3V: length 9.4
  BOTTOM w1.016: 215.66,153.66 215.66,152.44 215.1,151.88 215.1,150.71 215.66,150.15 219.77,150.15 220.74,149.19
  vias: v1(215.87,154.86) v2(215.31,155.13) v2(215.26,154.5) v2(222.06,149.11) v2(222.69,149.11)
LG_5V: length 7.7
  TOP w0.102: v2(222.69,159.39) 222.21,159.39 v1(222.06,159.54)
  IN1 w1.016: 215.72,158.71 218.25,158.71 218.68,158.28 222.47,158.28 222.5,158.31
  vias: v2(215.26,157.68) v2(215.89,157.67) v2(222.69,160.03)
LG_+VDDRP: length 5.1
  IN2 w1.016: 32.93,33.34 32.93,35.62 34.94,37.63
  vias: v2(33.7,32.93) v2(33.67,32.32) v2(35.81,38.39) v2(35.81,37.75)
LID_CL#: length 237.8
  TOP w0.102: v3(207.31,152.82) 207.03,153.1 U47.2 ; JUDB1.19 109.11,125.27 109.2,125.36 109.2,125.84 108.89,126.15 108.89,128.65 111.06,130.82 121.67,130.82 121.9,130.59 124.3,130.59 127.52,127.37 132.69,127.37 133.54,128.22 146.98,128.22 159.3,140.54 160.51,140.54 161.53,141.57 162.44,141.57 163.53,142.66 172.74,142.66 v3(173.22,143.14) ; v3(212.84,134.38) 211.82,134.38 204.94,127.5 204.94,122.78 203.98,121.82 203.11,121.82 202.94,122 R325.1
  IN1 w0.097: v3(207.31,152.82) 207.31,151.55 212.84,146.01 v3(212.84,134.38) 212.84,133.21 211.49,131.86 211.49,128.55 212.28,127.76 212.28,116.46 206.31,110.49 206.31,109.82 200.2,103.7 200.2,98.24 199.45,97.49 199.45,92.01 v3(199.73,91.72)
  BOTTOM w0.102: v3(199.73,91.72) 199.74,91.73 200.6,91.73 203.93,88.4 209.54,88.4 210.66,87.29 218.91,87.29 219.95,86.24 v1(219.95,84) ; v3(207.31,152.82) 207.31,154.67 204.08,157.9 200.04,157.9 199.51,158.43 196.76,158.43 195.09,156.76 195.09,155.38 193.46,153.75 193.46,152 190.95,149.49 179.95,149.49 173.6,143.14 v3(173.22,143.14)
LID_CL_SIO#: length 15
  TOP w0.102: U37.B54 196.02,120.64 v3(195.96,120.59) ; v1(203.47,122.19) 203.14,122.52 202.07,122.52 C337.1 R325.2 R322.2 200.88,121.11 v3(200.77,121.22)
  IN3 w0.102: v3(195.96,120.59) 197.18,119.38 197.18,118.88 197.77,118.29 200.26,118.29 201.01,119.03 201.01,119.43 200.84,119.59 200.65,119.59 200.4,119.85 200.4,120.84 v3(200.77,121.22)
LOM_ACTLED_YEL#: length 19.4
  TOP w0.102: U21.26 200.91,152.54 201.46,153.09 201.46,153.42 v3(202.02,153.99) ; U23.15 199.42,168.4 199.94,167.88 199.94,167.69 200.18,167.45 200.27,167.45 200.42,167.3 v3(200.42,167.22) 200.97,167.22 v1(201.12,167.37)
  IN3 w0.102: v3(202.02,153.99) 202.02,155.79 200.4,157.42 200.4,167.27 200.42,167.3 v3(200.42,167.22)
LOM_SPD10LED_GRN#: length 31.2
  TOP w0.102: U21.25 201.31,152.46 202.44,153.59 U24.2 202.44,155.29 203.04,155.89 203.17,155.89 203.5,156.22 203.5,159.19 v1(203.01,159.68) 202.25,160.44 191.25,160.44 191.08,160.61 191.08,161.81 190.57,162.32 190.57,164.32 191.42,165.18 191.42,166.38 191.94,166.9 U23.42
LOM_SPD100LED_ORG#: length 18.6
  TOP w0.102: U23.16 199.92,168.36 200.35,167.93 v3(200.35,167.85) ; v3(201.44,155.59) 201.79,155.24 U24.1 201.79,154.41 200.97,153.59 v1(200.97,153.4) 200.97,153.1 200.51,152.64 U21.27
  IN3 w0.102: v3(201.44,155.59) 200.02,157.01 200.02,167.6 200.35,167.93 v3(200.35,167.85)
LP_CTL: length 6.6
  TOP w0.102: v1(172.66,151.5) R55.1 173.75,153.22 175.12,154.6 175.71,154.6 175.96,154.85 175.96,155.27 U6.B2
LPC_LAD0: length 329.5
  TOP w0.102: v2(185.21,122.87) 185.21,122.86 185.68,122.39 U37.A27 ; U38.A30 171.8,126.39 172.71,127.3 172.71,128.26 173.19,128.74 173.19,130.46 173.96,131.23 174.97,131.23 175.4,131.66 176.47,131.66 176.83,131.31 177.26,130.87 177.99,130.14 177.99,126.89 177.44,126.33 177.44,126.33 177.26,126.15 177.26,125.87 177.71,125.41 v3(177.71,124.25) ; v2(185.94,134.58) 185.64,134.58 184.6,135.62 U25.26 184.6,136.79 185.56,137.76 210.93,137.76 212.25,139.08 214.04,139.08 214.05,139.08 235.58,139.08 236.07,138.58 245.49,138.58 248.1,141.19 248.1,143.56 v1(249.97,145.43) 258.06,153.53 266.51,153.53 272.02,159.04 273.04,159.04 273.05,159.04 273.23,159.04 273.42,159.04 274.2,159.04 285.17,170.01 289.88,170.01 292.96,173.09 304.66,173.09 305.97,174.41 306.47,174.41 307.36,175.3 v2(307.36,175.4)
  IN1 w0.097: v2(203.73,51.03) 203.83,51.03 209.46,56.67 209.46,99.66 209.27,99.85 v3(208.44,99.85) ; v2(185.21,122.87) 184.62,122.87 183.58,123.91 181.36,123.91 181.18,123.74 180.61,123.74 180.1,124.25 v3(177.71,124.25)
  IN3 w0.102: v2(185.21,122.87) 185.74,123.4 186.1,123.4 186.53,123.84 186.53,127.36 186.26,127.63 185.79,128.1 185.79,134.43 v2(185.94,134.58)
  BOTTOM w0.076: 163.11,54.65 162.45,55.31 162.45,58.83 160.81,60.46 160.81,61.49 160.58,61.72 160.58,63.08 160.58,63.09 160.58,63.42 160.31,63.7 UC1.AU14
  BOTTOM w0.102: v2(203.73,51.03) 203.5,50.81 173.8,50.81 171.46,53.16 164.6,53.16 163.11,54.65 ; R234.2 308.16,176.21 v2(307.36,175.4) ; v2(185.21,122.87) 186.81,121.27 186.81,119.85 187.42,119.24 187.42,118.48 187.04,118.1 187.04,115.86 189.22,113.68 200.98,113.68 206.73,107.93 206.73,100.99 207.83,99.88 208.4,99.88 v3(208.44,99.85)
LPC_LAD1: length 320.1
  TOP w0.102: v2(306.77,175.42) 305.98,174.64 305.88,174.64 304.63,173.4 292.78,173.4 289.63,170.24 285.07,170.24 274.1,159.27 273.33,159.27 273.33,159.27 273.14,159.27 271.93,159.27 266.42,153.76 255.91,153.76 247.87,145.72 247.87,141.28 245.39,138.81 236.17,138.81 235.67,139.31 217.61,139.31 212.16,139.31 210.83,137.98 183.06,137.98 182.65,137.58 U25.23 182.65,133.02 182.3,132.68 181.96,132.68 180.05,130.77 180.05,128.99 180.13,128.92 180.13,124.93 180.91,124.14 v3(181.02,124.14) ; v2(185.8,122.89) U37.A26 ; U38.B32 170.51,126.64 170.34,126.47 169.85,126.47 169.35,125.98 v2(169.24,125.98)
  IN1 w0.097: v2(207.99,100.27) 206.9,99.17 206.9,85.35 206.68,85.14 206.68,75.91 208.57,74.02 208.57,58.63 v2(202,52.06) ; v2(185.8,122.89) 185.72,122.89 185.36,123.25 184.56,123.25 183.14,124.67 181.55,124.67 v3(181.02,124.14) 179.57,125.59 175.81,125.59 175.35,125.12 172.08,125.12 171.97,125.01 169.25,125.01 169.03,125.23 169.03,125.77 v2(169.24,125.98)
  BOTTOM w0.076: UC1.AW12 161.31,62.28 161.31,60.76 163.41,58.66 163.41,57.24 163.41,56.64 v1(164.23,55.82) 165.37,54.69 165.37,54.65 ; 165.88,54.19 170.78,54.19
  BOTTOM w0.102: 165.37,54.65 165.83,54.19 165.88,54.19 ; 170.78,54.19 171.4,54.19 174.09,51.5 201.44,51.5 v2(202,52.06) ; v2(207.99,100.27) 207.99,101.05 208.5,101.56 208.5,102.94 206.96,104.48 206.96,109.18 202.23,113.91 196,113.91 193.73,116.17 189.11,116.17 187.98,117.3 187.98,117.62 188.22,117.86 188.22,119.2 187.29,120.14 187.29,121.4 v2(185.8,122.89) ; R236.2 306.77,175.7 v2(306.77,175.42)
LPC_LAD2: length 332.8
  TOP w0.102: v2(188.92,124.34) 188.92,124.16 188.9,124.14 188.88,124.14 188.66,123.92 188.66,123.9 188.4,123.64 U37.B26 ; v2(178.72,132.54) 179,132.82 179.71,132.82 180.05,133.16 180.05,133.89 180.15,133.99 180.15,134.3 180.7,134.85 U25.20 180.7,137.67 181.47,138.44 210.64,138.44 211.97,139.76 217.8,139.76 235.86,139.76 236.36,139.27 245.2,139.27 247.41,141.47 247.41,145.9 257.6,156.09 267.91,156.09 273.42,161.61 274.1,161.61 283.22,170.73 289.04,170.73 292.42,174.1 304.59,174.1 v2(305.73,175.25) ; U38.A31 171.83,126.89 172.2,127.27 172.2,128.18 172.81,128.79 172.81,129.55 v2(172.56,129.81)
  IN1 w0.097: v2(172.56,129.81) 173.93,131.18 175.15,131.18 176.06,132.09 178.02,132.09 178.46,132.54 v2(178.72,132.54) 178.58,132.4 178.58,131.46 177.79,130.67 176.47,130.67 175.83,130.03 175.83,129.32 176.5,128.66 180.44,128.66 181.52,127.58 187.61,127.58 188,127.2 188.73,127.2 189.29,126.64 189.29,124.72 v2(188.92,124.34) ; v3(208.85,99.35) 207.34,97.84 207.34,85.17 207.14,84.97 207.14,76.68 209.02,74.8 209.02,58.41 203.11,52.5 203.11,51.93 v2(202.63,51.45)
  BOTTOM w0.076: UC1.AY12 161.15,61.8 161.15,60.69 163.06,58.78 v1(163.06,58.32) 163.06,56.58 164.99,54.65
  BOTTOM w0.102: v3(208.85,99.35) 208.34,99.35 208.03,99.66 207.74,99.66 206.5,100.9 206.5,107.75 200.8,113.45 189.13,113.45 185.36,117.22 185.36,118.5 186.36,119.5 186.36,121.39 185.26,122.49 185.05,122.49 184.83,122.71 184.83,123.03 185.07,123.27 187.87,123.27 188.92,124.32 v2(188.92,124.34) ; 164.99,54.65 165.67,53.96 171.3,53.96 173.99,51.27 202.45,51.27 v2(202.63,51.45) ; R240.2 306.39,175.9 v2(305.73,175.25)
LPC_LAD3: length 321.1
  TOP w0.102: v2(188.26,124.2) 188.2,124.14 U37.B25 ; U38.B33 170.44,127.14 v2(170.17,126.88) ; v3(176.81,133.11) 177.1,133.4 177.1,134.12 178.2,135.22 178.5,135.22 178.75,135.46 U25.17 178.75,137.04 180.41,138.7 187.95,138.7 v3(188.1,138.85) 210.73,138.85 211.87,139.99 217.89,139.99 235.95,139.99 236.45,139.5 245.11,139.5 247.18,141.57 247.18,146 255.09,153.91 257.51,156.32 267.82,156.32 273.33,161.84 274,161.84 283.15,170.98 288.79,170.98 292.37,174.56 304.41,174.56 v2(305.12,175.27)
  IN1 w0.097: v2(170.17,126.88) 170.62,126.88 171.24,127.49 171.24,130.36 173.98,133.11 v3(176.81,133.11) ; v2(206.77,100.04) 206.67,99.95 206.67,85.45 206.45,85.23 206.45,75.82 208.35,73.93 208.35,59.22 v2(201.34,52.21)
  IN3 w0.102: v3(188.1,138.85) 188.1,135.24 186.48,133.62 186.48,128.38 187.29,127.57 187.29,125.18 188.26,124.21 v2(188.26,124.2)
  BOTTOM w0.076: 170.78,54.42 168.33,54.42 167.83,54.91 166.18,54.91 v1(165.5,55.6) 164.77,56.32 164.14,56.32 163.58,56.89 163.58,57.17 163.58,58.8 162.05,60.33 162.05,62.3 UC1.AW11
  BOTTOM w0.102: 170.78,54.42 171.49,54.42 174.18,51.73 200.85,51.73 v2(201.34,52.21) ; v2(305.12,175.27) 305.5,175.65 R239.2 ; v2(206.77,100.04) 206.27,100.55 206.27,107.6 200.65,113.22 189.03,113.22 184.78,117.48 184.78,121.88 184.6,122.06 184.6,123.12 184.98,123.5 187.56,123.5 v2(188.26,124.2)
LPC_LFRAME#: length 327.7
  TOP w0.102: v2(170.05,126.07) 170.38,126.07 170.46,126.14 U38.B31 ; v2(304.61,175.55) 304.71,175.65 305.87,175.65 306.11,175.4 306.11,175.09 305.89,174.87 305.68,174.87 304.57,173.76 292.74,173.76 289.45,170.47 284.98,170.47 274.01,159.5 271.84,159.5 266.32,153.99 255.82,153.99 247.64,145.81 247.64,141.38 245.3,139.04 236.26,139.04 235.77,139.53 217.7,139.53 212.06,139.53 210.74,138.21 182.25,138.21 182,137.96 U25.22 182,135.43 182.41,135.02 182.41,133.11 182.23,132.93 181.69,132.93 179.82,131.06 179.82,128.9 179.9,128.82 179.9,124.34 180.97,123.28 181.83,123.28 v2(182.08,123.53) 182.08,123.86 182.21,123.99 184.39,123.99 185.8,125.39 U37.A21
  IN1 w0.097: v2(208.04,96.91) 207.57,96.44 207.57,85.08 207.37,84.88 207.37,76.77 209.24,74.9 209.24,57.34 208.6,56.7 208.07,56.7 203.52,52.16 203.52,51.62 v2(203.22,51.32) ; v2(170.05,126.07) 169.95,126.07 169.67,126.35 169.32,126.35 169.31,126.36 169.08,126.36 168.81,126.08 168.81,125.14 169.16,124.78 172.06,124.78 172.17,124.9 174.77,124.9 175.04,124.62 176.7,124.62 177.49,123.84 180.2,123.84 180.52,123.51 182.07,123.51 v2(182.08,123.53)
  BOTTOM w0.076: UC1.AV12 160.74,62.99 160.74,61.79 160.98,61.55 160.98,60.62 162.55,59.06 162.55,58.96 162.61,58.9 162.61,56.75 v1(162.74,56.62) 163.85,55.52 163.85,55.03 164.23,54.65
  BOTTOM w0.102: v2(182.08,123.53) 182.08,121.4 182.27,121.22 182.27,116.72 188.43,110.55 190.77,110.55 191.84,109.49 192.8,109.49 194.12,108.16 195.18,108.16 200.68,102.67 200.68,101.3 204.05,97.93 205.43,97.93 206.44,96.91 v2(208.04,96.91) ; R238.2 v2(304.61,175.55) ; v2(203.22,51.32) 202.94,51.04 173.9,51.04 171.21,53.73 165.14,53.73 164.23,54.65
LX_DGPU: length 1.1
  TOP w0.508: PR324.2 v3(100.02,103.8)
  vias: v1(100.14,104.76)
M_CLK_DDR0: length 62.4
  IN1 w0.076: 144.57,54.06 144.57,54.08 144.54,54.1 144.54,55.07 145.87,56.39 146.26,56.39 146.61,56.73 146.61,58.87 146.83,59.09 146.83,59.81 146.67,59.97 146.4,59.97 146.29,60.07 v2(146.29,60.22)
  IN1 w0.097: 144.57,54.06 144.57,47.94 144.31,47.69 143.97,47.69 143.81,47.52 143.81,47.32 143.95,47.18 144.21,47.18 144.44,46.95 144.44,46.7 133.82,36.08 130.07,36.08 122.04,28.05 122.04,27.63 122.04,26.68 121.56,26.2 121.08,26.2 120.88,26.01 120.88,25.5 120.62,25.23 120.43,25.23 120.34,25.14 120.34,24.19 119.94,23.79 119.94,23.62 120.13,23.43 120.54,23.43 120.76,23.65 v2(120.76,24.01)
  BOTTOM w0.076: v2(146.29,60.22) 146.29,60.09 145.98,59.78 145.8,59.78 145.71,59.86 145.71,60.43 145.43,60.72 145.43,63.4 145.56,63.54 145.71,63.54 145.76,63.49 145.76,63.27 UC1.AV37
  BOTTOM w0.102: JDIMM1.101 120.38,25.32 120.5,25.2 120.83,25.2 121.19,24.84 121.19,23.76 121.06,23.63 120.89,23.63 120.76,23.76 v2(120.76,24.01)
M_CLK_DDR1: length 60.8
  IN1 w0.076: v2(146.15,61.6) 146.42,61.87 146.84,61.87 147,61.72 147,58.75 146.82,58.57 146.82,56.47 146.42,56.07 146.11,56.07 145.12,55.07 145.12,54.1 145.09,54.08 145.09,54.06
  IN1 w0.097: v2(121.51,21.7) 121.4,21.6 121.4,21.14 121.53,21.02 122.1,21.02 122.28,21.21 122.28,21.69 121.78,22.19 121.78,25.68 122.54,26.44 122.54,27.84 130.18,35.48 133.93,35.48 145.09,46.65 145.09,54.06
  BOTTOM w0.076: UC1.AY36 146.47,61.93 v2(146.15,61.6)
  BOTTOM w0.102: v2(121.51,21.7) 121.51,21.27 121.4,21.17 121.17,21.17 120.7,20.7 120.7,19.73 120.88,19.56 120.88,19.33 120.68,19.12 JDIMM1.102
M_CLK_DDR2: length 94.1
  IN3 w0.086: v2(195.17,22.92) 195.17,23.23 195.27,23.33 195.57,23.33 195.88,23.64 195.88,24.96 194.99,25.84 194.74,25.84 194.54,25.64 194.32,25.64 193.94,26.02 193.94,26.37 193.45,26.85 193.07,26.85 192.82,27.09 192.82,27.48 189.53,30.77 189.51,30.77 189.41,30.88 168.24,30.88 168.1,31.01 168.1,32.11 167.91,32.3 167.51,32.3 167.32,32.11 167.32,31.01 167.24,30.92 166.98,30.92 166.89,31.01 166.89,32.11 166.7,32.3 166.3,32.3 166.11,32.11 166.11,31.01 166.02,30.92 165.76,30.92 165.68,31.01 165.68,32.11 165.49,32.3 158.91,32.3 144.6,46.62 144.6,57.01 144.8,57.2 144.8,58.1 145.16,58.46 145.16,63.94 145.16,63.94 145.16,64.09 145.12,64.12 145.13,64.12 145.11,64.14
  IN3 w0.091: v2(145.12,66.01) 144.91,66.22 144.81,66.22 144.71,66.12 144.71,65.73 144.74,65.7 144.74,64.51 145.11,64.14
  BOTTOM w0.076: UC1.AN38 145.51,66.15 145.37,66.01 v2(145.12,66.01)
  BOTTOM w0.102: JDIMM2.101 194.88,25.38 194.44,24.95 194.44,23.64 194.72,23.37 195,23.37 195.17,23.2 v2(195.17,22.92)
M_CLK_DDR3: length 92.4
  IN3 w0.086: v2(194.61,20.19) 194.61,20.4 194.72,20.51 195,20.51 195.39,20.9 195.39,21.71 194.36,22.74 194.36,24.59 194.36,24.6 194.36,24.61 191.45,27.52 191.45,27.88 189.13,30.21 165.09,30.21 163.66,31.63 158.41,31.63 143.93,46.12 143.93,57.27 144.12,57.46 144.12,63.86
  IN3 w0.091: 144.12,63.86 144.33,64.08 144.33,65.53 144.25,65.61 144.25,66.91 144.03,67.12 144.03,67.43 144.28,67.69 144.81,67.69 145.07,67.43 v2(145.07,67.27)
  BOTTOM w0.076: UC1.AL38 145.65,67.49 145.65,67.33 145.6,67.28 145.07,67.28 v2(145.07,67.27)
  BOTTOM w0.102: v2(194.61,20.19) 194.61,20.51 194.76,20.66 195.2,20.66 195.35,20.51 195.35,19.6 195.18,19.42 JDIMM2.102
M_CLK_DDR#0: length 62.6
  IN1 w0.076: 144.36,54.06 144.36,54.15 144.38,54.17 144.38,55.13 145.8,56.55 146.19,56.55 146.44,56.8 146.44,58.93 146.67,59.16 146.67,59.74 146.6,59.8 146.4,59.8 146.29,59.7 v2(146.29,59.59)
  IN1 w0.097: v2(120.76,22.74) 120.76,23.06 120.6,23.22 120.04,23.22 119.73,23.53 119.73,23.88 120.12,24.28 120.12,25.23 120.34,25.44 120.53,25.44 120.67,25.58 120.67,26.09 120.99,26.41 121.47,26.41 121.83,26.77 121.83,27.54 121.83,28.13 129.98,36.29 133.73,36.29 144.23,46.79 144.23,46.86 144.12,46.97 143.86,46.97 143.59,47.23 143.59,47.61 143.89,47.9 144.23,47.9 144.36,48.03 144.36,54.06
  BOTTOM w0.076: v2(146.29,59.59) 145.72,59.59 145.52,59.78 145.52,60.37 145.26,60.64 145.26,63.47 UC1.AU37
  BOTTOM w0.102: v2(120.76,22.74) 120.76,23.24 120.93,23.42 121.15,23.42 121.41,23.67 121.41,24.93 120.98,25.36 JDIMM1.103
M_CLK_DDR#1: length 61.1
  IN1 w0.076: v2(146.15,62.25) 146.36,62.04 146.91,62.04 147.16,61.78 147.16,58.69 146.98,58.5 146.98,56.4 146.49,55.9 146.18,55.9 145.28,55 145.28,54.1 145.3,54.08 145.3,54.06
  IN1 w0.097: 145.3,54.06 145.3,46.56 134.01,35.27 130.27,35.27 122.75,27.75 122.75,26.35 121.99,25.59 121.99,22.28 122.49,21.77 122.49,21.12 122.18,20.81 121.86,20.81 121.51,20.46 v2(121.51,20.43)
  BOTTOM w0.076: v2(146.15,62.25) 146.47,62.58 UC1.AW36
  BOTTOM w0.102: JDIMM1.104 121.28,19.16 121.1,19.34 121.1,19.65 120.92,19.82 120.92,20.61 121.26,20.95 121.76,20.95 121.89,20.83 121.89,20.56 121.76,20.43 v2(121.51,20.43)
M_CLK_DDR#2: length 94.4
  IN3 w0.086: v2(195.17,24.19) 195.17,23.65 195.3,23.51 195.5,23.51 195.7,23.71 195.7,24.88 194.92,25.67 194.81,25.67 194.61,25.47 194.24,25.47 193.76,25.95 193.76,26.29 193.38,26.67 192.99,26.67 192.65,27.02 192.65,27.41 189.46,30.59 189.44,30.59 189.33,30.7 168.17,30.7 167.93,30.94 167.93,32.04 167.84,32.13 167.58,32.13 167.5,32.04 167.5,30.94 167.31,30.75 166.9,30.75 166.71,30.94 166.71,32.04 166.63,32.13 166.37,32.13 166.28,32.04 166.28,30.94 166.09,30.75 165.69,30.75 165.5,30.94 165.5,32.04 165.41,32.13 158.84,32.13 144.43,46.54 144.43,57.08 144.62,57.28 144.62,58.17 144.98,58.53 144.98,64.01
  IN3 w0.091: 144.98,64.01 144.56,64.43 144.56,65.62 144.53,65.66 144.53,66.19 144.73,66.4 144.92,66.4 145.12,66.59 v2(145.12,66.66)
  BOTTOM w0.076: v2(145.12,66.66) 145.18,66.66 UC1.AM38
  BOTTOM w0.102: v2(195.17,24.19) 195.17,23.73 195.02,23.58 194.81,23.58 194.66,23.73 194.66,24.86 195.03,25.23 195.22,25.23 195.48,25.49 JDIMM2.103
M_CLK_DDR#3: length 92.8
  IN3 w0.086: v2(194.61,21.46) 194.61,20.82 194.74,20.69 194.93,20.69 195.22,20.97 195.22,21.64 194.19,22.67 194.19,24.52 194.18,24.52 194.18,24.54 191.28,27.44 191.28,27.81 189.06,30.03 165.02,30.03 163.59,31.46 158.34,31.46 143.75,46.04 143.75,57.34 143.94,57.53 143.94,63.79 143.94,63.79 143.94,63.94 143.97,63.97 143.97,63.98 143.99,63.99
  IN3 w0.091: v2(145.12,67.96) 145.02,67.86 144.89,67.86 144.89,67.87 144.21,67.87 143.85,67.51 143.85,67.05 144.07,66.83 144.07,65.54 144.15,65.46 144.15,64.15 143.99,63.99
  BOTTOM w0.076: v2(145.12,67.96) 145.44,68.29 UC1.AK38
  BOTTOM w0.102: v2(194.61,21.46) 194.61,21.02 194.75,20.88 195.29,20.88 195.57,20.6 195.57,19.52 195.78,19.31 JDIMM2.104
