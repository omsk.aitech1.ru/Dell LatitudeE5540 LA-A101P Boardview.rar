# Allegro board Alpine15_LA-A101PR10-0826C.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+3.3V_TP: length 23.8
  TOP w0.102: PJP8.2 v6(134.85,109.1)
  TOP w0.305: 131.89,107.58 131.9,107.58 JTP1.4
  IN2 w0.508: v3(149.98,104.66) 149.98,104.15 149.24,103.42 141.01,103.42 137.4,107.02 133.72,107.02 v3(132.2,108.55)
+3.3V_USBHUB: length 21.9
  TOP w0.254: U90.23 220.44,51.82 220.11,52.16 C3024.1 ; 223.1,55.82 223.48,55.44 U90.15 ; C3028.1 227.9,52.11 227.62,51.82 U90.5 ; U90.10 225.98,55.79 ; U90.29 222.48,47.47 C3025.1
  TOP w0.381: QC4.5 216.93,55 216.56,54.62 R2693.2
  TOP w0.432: QC4.2 219.8,55 v2(220.08,55.28)
  TOP w0.508: v3(218.76,52.59) 218.94,52.59 219.07,52.46 219.34,52.19 219.37,52.16 C3024.1 ; R2691.2 R2692.2 215.89,52.16 v2(215.89,53.25) ; C3025.1 v3(222.47,46.82) ; v3(229.56,52.77) 229.07,52.77 228.67,52.36 C3028.1 ; v2(222.34,56.9) 222.35,56.89 C3029.1 223.07,55.85 223.1,55.82 ; v3(219.68,47.63) 219.32,47.28 C3023.1 ; R2701.2 R2700.2 217.52,49.06 v3(217.31,48.86) ; 225.98,55.79 226.33,56.14 C3026.1 v2(226.97,56.98) ; R2693.2 v3(215.66,54.62)
  vias: v1(231.02,49.95) v2(220.35,57.6) v3(220.74,58.18) v3(221.1,57.57) v3(230.56,49.59) v3(230.6,48.91)
+3.3V_VTR:
  vias: v1(173.68,122.3)
+3.3V_VTR_ADC: length 12.1
  TOP w0.127: v1(153.79,116.67) 154,116.89 R461.2
  TOP w0.279: 159.86,122.8 159.95,122.89 U38.A58
  TOP w0.508: v2(155.16,118.63) 154.55,118.63 154,118.08 R461.2 ; 159.86,122.8 159.35,122.8 158.51,121.96 C347.1 C353.1 v3(158.51,121.07)
  IN3 w0.508: v2(155.16,118.63) 156.07,118.63 v3(158.51,121.07)
+3.3V_WLAN: length 29.9
  TOP w0.102: v3(266.15,159.79) v6(266.15,160.67)
  IN1 w0.508: v3(247.71,166.64) 247.72,166.64 248.32,166.64 249.32,165.65 v3(253.51,165.65) 254.06,165.09 262.47,165.09 266.15,161.41 v3(266.15,159.79)
  BOTTOM w0.457: R229.2 251.64,163.46 Q30.2 ; Q22.2 247.79,165.93 R227.2
  BOTTOM w0.508: v3(253.51,165.65) 252.49,164.63 252.49,163.74 252.07,163.32 R229.2 ; v3(315.43,176.46) R233.2 ; R227.2 v3(247.71,166.64)
  vias: v2(301.31,180.53) v2(301.29,179.82) v2(320.33,186.67) v2(320.94,186.67) v3(264.75,158.42) v3(265.23,158.9) v3(265.69,159.36) v3(265.82,158.67) v3(266.28,159.13) v3(324.25,177.84) v3(324.25,177.2)
+3.3V_WLANP:
  vias: v1(266.03,154.67)
+5V_ALW: length 502.1
  TOP w0.203: v2(166.87,107.11) 166.54,106.78 U43.4 ; v3(194.63,109.94) 194.55,110.02 U45.4
  TOP w0.305: C1188.1 315.36,167.68 314.75,168.28 JPWR1.1
  TOP w0.381: v3(132.03,134.95) 132.27,135.19 PU1.5
  TOP w0.508: U22.5 218.13,184.19 220.74,184.19 221.01,184.46 231.95,184.46 237.53,178.88 ; v3(215.74,38.77) 215.43,38.77 214.47,37.81 214.47,36.03 214.98,35.52 C1187.1 ; R411.1 169.74,141.06 v3(170.45,141.77) ; PR435.1 v2(120.59,134.2) ; PR536.2 128.39,162.04 v3(128.49,162.14) ; U29.5 229.82,44.17 230.39,44.74 230.42,44.74 230.65,44.97 230.65,45.71 v3(230.24,46.11) ; PU404.8 113.54,136.6 113.35,136.41 113.35,135.97 PC429.1 PC428.1 115.06,135.6 v2(115.31,135.85) ; C1185.1 341.16,176.69 v3(341.24,176.77) ; v3(227.75,31.23) 227.42,31.56 225.06,31.56 Q16.3 ; C1188.1 316.25,166.53 v3(316.37,166.41) ; v3(222.11,88.53) 217.77,88.53 211.09,95.21 v3(208.85,95.21) 208.74,95.1 204.04,95.1 v3(203.9,95.24) ; v3(222.27,118.16) 221.83,118.59 U34.5 ; R28.1 v3(232.35,32.68) ; PR11.1 127.76,138.11 v2(128.45,138.79) 128.97,138.27 PD5.3 ; v3(84.7,84.24) 85.87,84.24 89.55,80.56 v3(89.55,79.92) 87.93,78.29 87.93,77.33 88.43,76.82 88.43,75.22 86.53,73.32 85.36,73.32 v3(82.13,70.09) 81.25,70.09 PR150.1
  IN1 w0.508: v3(261.34,150.96) 258.82,153.48 255.34,153.48 254.3,154.52
  IN2 w0.508: v3(82.13,70.09) 81.32,70.9 77.94,70.9 76.79,69.75 v3(76.79,68.74) ; v2(77.6,66.56) 77.49,66.56 76.79,67.26 v3(76.79,68.74) ; v3(76.79,68.74) 74.54,68.74 73.8,69.48 63.16,69.48 61.56,71.08 56.35,71.08 53.7,68.44 37.58,68.44 v3(32.05,62.9) ; v3(159.21,110.18) 159.95,110.92 164.95,110.92 165.01,110.86 166.51,110.86 168.32,109.05 171.11,109.05 175.36,104.8 177.52,104.8 178.06,104.27 178.06,101.46 181.85,97.66 181.85,89.52 184.92,86.46 187.79,86.46 v3(188.03,86.7) ; v3(31.23,27.3) 30.93,27.61 30.93,29.88 v3(30.12,30.69) 29.48,31.33 29.48,32.55 29.99,33.06 29.99,37.25 22.07,45.16 22.07,62.43 22.09,62.44
  IN3 w0.508: v3(37.64,16.35) 37.64,16.71 38.22,17.28 v3(38.98,17.28) ; v3(203.9,95.24) 203.17,95.24 201.34,93.41 201.34,88.64 199.95,87.26 191.62,87.26 190.82,86.46 188.27,86.46 v3(188.03,86.7) ; v3(32.05,62.9) 24.04,62.9 v3(23.45,63.5) ; v3(128.49,162.14) 127.63,161.28 127.63,150.51 124.02,146.9 v3(124.02,145.63)
  IN3 w3.048: 20.18,123.48 62.63,123.48 66.7,127.56 69.78,127.56 73.21,130.99 82.83,130.99 85.36,133.51 105.48,133.51 106.77,134.81
  BOTTOM w0.203: v3(37.64,16.35) 37.64,16.16 38.01,15.79 PU100.12 ; U19.4 89.44,79.81 v3(89.55,79.92) ; U51.4 v3(261.34,150.96) ; PU150.18 77.68,66.47 v2(77.6,66.56) ; U46.4 v3(254.88,161.26) ; U18.4 v3(270.89,182.74)
  BOTTOM w0.508: PC151.2 76.29,69.24 v3(76.79,68.74) ; PR617.2 56.32,35.83 55.9,36.26 50.92,36.26 44.96,30.3 44.96,27.58 42.36,24.98 v6(41.09,24.98) 39.51,24.98 38.12,23.58 ; v2(166.87,107.11) 166.87,108.16 165.73,109.31 160.09,109.31 v3(159.21,110.18) ; PR711.2 30.48,30.33 v3(30.12,30.69) ; 38.12,23.58 31.6,23.58 31.12,24.07 31.12,27.19 v3(31.23,27.3) ; 38.12,23.58 v6(38.12,21.88) 38.12,20.32 38.41,20.03 PR102.1 PC107.2 39.43,17.73 v3(38.98,17.28) ; v2(128.45,138.79) 128.45,141.2 v3(124.02,145.63) ; v3(224.73,41.23) 220.91,41.23 218.46,38.77 v3(215.74,38.77) ; v3(84.7,84.24) 84.99,84.24 PR327.1 ; v3(208.85,95.21) 208.85,97.57 208.34,98.08 206.41,98.08 205.88,98.61 204.56,98.61 203.62,99.55 203.62,104.76 198.44,109.94 v3(194.63,109.94) ; v3(97.98,141.26) U33.5
  vias: v2(237.38,148.37) v2(237.43,147.69) v2(237.38,147.1) v2(237.38,146.47) v2(237.96,148.42) v2(238.01,147.74) v2(238.01,147.1) v2(238.01,146.47) v2(238.6,148.42) v2(238.65,147.74) v2(238.65,147.1) v2(238.65,146.47) v2(239.23,148.42) v2(239.28,147.74) v2(239.28,147.1) v2(239.28,146.47) v2(239.82,148.45) v2(239.87,147.76) v2(239.87,147.1) v2(239.87,146.44) v2(240.33,148.14) v2(240.38,147.46) v2(243.93,185.15) v2(244.54,185.15) v2(245.16,185.14) v2(245.77,185.14) v2(271.82,183.22) v2(272.43,183.22) v2(273.05,183.21) v2(273.66,183.21) v3(15.61,121.93) v3(15.61,121.27) v3(16.27,121.96) v3(16.27,121.3) v3(16.93,121.96) v3(16.93,121.3) v3(17.71,122.03) v3(17.71,121.37) v3(23.26,69.76) v3(23.26,69) v3(24.02,69.63) v3(24.13,68.99) v3(24.15,68.24) v3(108.04,136.62) v3(108.08,135.97) v3(108.76,136.63) v3(108.8,135.98) v3(108.86,135.27) v3(109.34,136.36) v3(109.36,135.65) v3(109.39,134.81) v3(229.02,38.95) v3(229.66,38.95) v3(229.95,40.22) v3(229.95,39.58) v3(253.89,159.3) v3(254.27,159.93) v3(254.52,159.3) v3(254.91,159.93) v3(255.16,159.3) v3(255.79,159.3) v3(333.82,176.31) v3(333.85,175.65) v3(334.38,176.72) v3(334.41,176.06) v3(340.88,177.43) v3(341.16,178.01) v3(341.52,177.46) v6(274.27,182.61)
+5V_ALW2: length 3.5
  TOP w0.102: v6(216.7,157.42) 216.86,157.26 216.86,156.15 216.79,156.09 PC69.1
  TOP w0.203: PC69.1 216.1,156.09 215.78,156.41 PU51.13
+5V_ALWP: length 76.2
  TOP w0.127: v6(234.18,165.4) 233.44,164.67 PC67.1
  TOP w0.203: v2(216.43,156.91) 216.33,156.81 PU51.14
  TOP w0.508: PR52.2 208.7,157.74 v3(208.19,157.24)
  IN2 w0.508: v3(208.19,157.24) 208.19,165.09 214.34,171.23 226.81,171.23 228.54,169.51 v2(228.54,163.33)
  IN3 w0.508: v2(227.78,165.14) 227.78,169.07 226.43,170.42 215.36,170.42 212.18,167.25 212.18,163.35 216.75,158.77 216.75,157.24 v2(216.43,156.91)
  vias: v2(227.9,164.53) v2(227.88,163.89) v2(227.9,163.28) v2(227.9,162.69) v2(228.54,162.69) v2(229.17,163.33) v2(229.17,162.69) v2(229.84,163.33) v2(229.81,162.69) v2(230.44,162.69) v2(230.52,163.33) v2(231.08,162.69) v2(231.18,163.33) v2(231.71,162.69)
+5V_HDD: length 7.4
  TOP w0.102: v3(224.7,113.7) v6(225.39,113.7)
  IN1 w0.508: v3(224.7,113.7) 225.01,113.4 225.01,109.33 v3(223.92,108.24)
  BOTTOM w0.508: R125.1 v3(223.92,108.24)
+5V_HDMI_DDC: length 20.2
  TOP w0.508: v3(21.49,109.19) 20.23,107.94 R470.2 ; v2(12.56,104.48) 12.56,104.47 v1(13.3,103.73) 14.05,102.98 D65.1 ; R472.2 R471.2 v3(13.86,108.5)
  IN2 w0.508: v2(12.56,104.48) 13.07,104.99 13.07,108.04 13.53,108.5 v3(13.86,108.5)
  IN3 w0.508: v3(13.86,108.5) 18.76,108.5 19.46,109.19 v3(21.49,109.19)
+5V_MOD: length 1.7
  TOP w0.102: C3005.1 231.97,41.5 v6(232.43,41.96)
+5V_RUN: length 501
  TOP w0.254: RP4.1 RP4.2 RP4.3 RP4.4 166.5,135.99 v3(166.13,135.62)
  TOP w0.508: v3(207.89,102.25) 207.89,102.86 C376.1 207.64,103.11 JKB1.6 ; C1001.1 340.6,175.95 v3(341.52,175.95) ; v3(85.59,17.08) 85.59,15.33 C645.1 ; v3(287.52,175.22) 275.48,175.22 274.77,175.93 269.8,175.93 266.31,179.42 v3(266.31,179.77) ; v3(190.92,158.2) 190.26,158.2 R74.1
  TOP w1.016: 58.41,71.39 53.2,71.39 44.64,79.95 26.64,79.95 21.83,84.75 21.83,85.42 21.83,86.16 21.82,86.16 21.82,93.55 22.44,94.17 22.44,95.16 ; 81.35,60.67 84.64,57.38 84.64,47.6 85.41,46.82 v3(85.41,46.39) ; 21.05,96.25 20.34,96.25 17.52,99.07 17.49,99.07 ; 22.44,97.67 22.44,108.46 25.31,111.33 25.31,117.63 24.13,118.81 20.91,118.81
  IN1 w0.508: v3(182.57,171.11) 182.57,170.88 183.89,169.56 190.66,169.56 191.63,168.58 191.63,167.47 192.22,166.89 196.84,166.89 197.22,166.51 201.95,166.51 202.16,166.71 v3(206.8,166.71) ; v3(207.89,102.25) 211.62,102.25 v3(212.87,101) ; v2(77.09,90.95) 77.09,97.73 78.01,98.65 78.01,103.43 78.71,104.13 78.71,115.89 80.56,117.74 v3(80.79,117.74) v3(81.52,117.74) 91.41,117.74 94,115.15 97.69,115.15 98.9,113.94 98.9,108.52 v3(97.55,107.17)
  IN2 w0.508: v3(287.52,175.22) 288.23,174.51 299.33,174.51 299.84,174 308.8,174 310.12,175.32 330.77,175.32 332.88,177.43 336.26,177.43 337.74,175.95 v3(341.52,175.95)
  IN2 w1.016: 47.88,31.61 47.86,31.63 39.58,31.63 35.93,27.99 32.76,27.99 ; 60.6,69.23 62.55,67.27 65.42,67.27 68.06,64.63 77.31,64.63 78.38,63.56 ; 80.92,118.66 78.87,118.66 78.35,119.17 76.85,119.17 76.22,119.8 73.07,119.8 72.53,120.33 70.22,120.33 69.67,119.78 64.91,119.78
  IN2 w2.032: 132.86,144.13 132.78,144.21 119.93,144.21 118.99,145.15 114.75,145.15 112.07,147.83 ; 177.03,151.22 177.84,152.03 183.71,152.03 184.47,152.79 185.99,152.79 186.27,152.51 186.28,152.51 187.09,151.71 187.09,151.7 187.82,150.96 193.08,150.96 193.16,151.04
  IN3 w0.508: v3(176.72,149.52) 172.02,144.82 172.02,142.12 166.13,136.23 v3(166.13,135.62)
  IN3 w1.016: 85.51,45.27 85.51,25.98 88.65,22.85 93.07,22.85 94.14,21.78 94.14,21.76 94.43,21.47 ; 60.35,69.13 50.97,69.13 40.2,58.36 40.2,53.22 39.59,52.62 39.59,36.97 43.75,32.8 48.11,32.8
  BOTTOM w0.102: v3(62.5,120.74) v6(61.64,120.74)
  BOTTOM w0.203: PU301.2 95.56,105.3 96.2,105.95
  BOTTOM w0.254: v3(341.52,175.95) JIO1.10
  BOTTOM w0.508: v3(85.59,17.08) 84.17,18.5 84.17,23.23 85.49,24.55 86.66,24.55 88.28,22.92 92.93,22.92 94.02,21.83 v3(94.02,21.37) 94.07,21.32 v3(94.07,20.61) ; PR314.1 v2(77.09,90.95) ; 96.2,105.95 96.54,106.28 PC303.1 97.41,107.03 v3(97.55,107.17)
  vias: v2(190.54,158.96) v2(223.03,111.04) v2(223.03,110.27) v2(223.54,110.65) v2(223.66,110.02) v3(19.14,119.14) v3(19.14,118.5) v3(19.78,119.14) v3(19.78,118.5) v3(31.82,28.66) v3(31.88,27.9) v3(49.03,32.19) v3(48.97,31.47) v3(60.34,70.34) v3(60.98,70.32) v3(63.19,120.74) v3(63.19,120.1) v3(63.82,120.07) v3(80.25,61.86) v3(80.81,61.43) v3(85.41,45.38) v3(93.13,163.41) v3(93.21,162.67) v3(93.82,163.44) v3(93.87,162.66) v3(104.23,153.99) v3(104.32,153.36) v3(104.87,153.99) v3(104.96,153.35) v3(107.84,149.82) v3(107.87,150.46) v3(108.41,150.12) v3(108.36,149.46) v3(191.2,158.99) v3(191.86,158.99) v3(191.89,158.23) v3(209.31,163.74) v3(209.31,162.98) v3(209.95,164.12) v3(209.95,163.36) v3(209.95,162.6) v3(210.58,163.74) v3(210.58,163.11) v3(211.29,163.79) v3(217.82,108.57) v3(217.8,107.94) v3(217.79,107.3) v3(217.8,106.67) v3(222.82,40.47) v3(222.82,39.84) v3(223.53,40.5) v3(223.56,39.86) v3(228.46,36.59) v3(228.49,35.9) v3(229.15,35.88) v3(229.17,36.61) v3(250.82,169.38) v3(251.32,168.87) v3(251.7,169.38) v3(252.21,168.87) v3(252.72,169.38) v3(253.1,168.87) v3(253.61,169.38) v3(253.99,168.87) v3(257.17,158.53) v3(257.42,159.17) v3(257.8,158.53) v3(258.05,159.17) v3(258.44,158.53) v3(258.69,159.17) v3(259.07,158.53) v3(259.71,158.53) v3(266.34,180.4)
+5V_RUN_AUDIO: length 0.7
  TOP w0.102: v3(322.26,157.46) v6(322.26,158.12)
  vias: v3(278.25,164.55) v3(278.48,165.21) v3(279.14,165.44) v3(322.67,156.86)
+5V_RUN_AUDIOP:
  vias: v1(273.38,178.18)
+5V_TSP: length 6.3
  TOP w0.508: JTS1.1 95.11,167.09 94.4,166.38 v3(92.37,166.38)
  vias: v6(93.03,166.06)
+5V_TSP_Q: length 36.2
  IN1 w0.508: v2(81.11,135.66) 81.11,138.15 82.72,139.76 82.72,146.88 86.26,150.42 86.26,155.17 83.02,158.41 83.02,159.93 88.74,165.65 v2(88.74,166.05)
  vias: v6(88.81,166.61)
+5V_USB_CHG_PWR: length 0.8
  BOTTOM w0.102: v6(18.72,83.21) 18.33,83.6 v3(18.05,83.6)
  vias: v2(15.98,91.46) v2(15.96,90.83) v2(16.59,91.46) v2(16.58,90.84) v2(23.25,74.18) v2(23.25,73.57) v2(23.8,73.97) v2(23.8,73.36) v3(17.29,83.6)
+DVDD_CORE: length 3.7
  BOTTOM w0.254: 305.31,157.3 305.37,157.3 305.73,156.94 U17.1
  BOTTOM w0.508: 305.31,157.3 303.62,157.3 C121.1
+P1.05V_PEX_VDD:
  vias: v1(91.88,80.26)
+V1.05S_APLLOPI: length 32.7
  TOP w0.381: v2(156.07,73.47) 156.21,73.6 CC56.1
  TOP w0.508: v3(157.42,94.63) 157.42,95.67 157.37,95.72 CC55.1 158.26,97.57 158.26,97.75 v1(158.96,98.46) 159.58,99.07 160.01,99.07 LC5.2
  IN1 w0.508: v3(154.42,85.36) 155.24,86.17 155.24,89.09 157.42,91.27 v3(157.42,94.63)
  IN3 w0.508: v3(154.42,85.36) 154.42,84.29 152.87,82.74 152.87,81.75 152.24,81.11 152.24,79.74 153.97,78.02 153.97,77.02 155.34,75.65 155.34,74.89 156.07,74.15 v2(156.07,73.47)
  BOTTOM w0.254: UC1.W21 156.2,73.88 156.07,73.75 v2(156.07,73.47) 156.07,73.45 UC1.AA21
+V1.05SP_B+:
  vias: v6(76.44,67.65)
+VCC_CORE: length 55.3
  TOP w0.508: v2(152.9,80.2) 152.21,79.51 PC366.1
  BOTTOM w0.102: UC1.G33 148.23,81.29 148.23,81.46 ; UC1.G33 148.33,81.02 148.33,80.72 ; UC1.G33 148.58,81.27 148.58,81.43 ; UC1.G33 148.67,80.85 ; 139.52,81.48 139.52,81.34 UC1.G47 ; 153.22,81.45 153.22,81.31 UC1.G25 ; 146.84,81.67 146.71,81.55 UC1.F36 ; UC1.F28 151.36,81.17 151.36,81.07 ; UC1.F28 151.86,81.67 151.92,81.67 ; UC1.F28 151.82,81.22 151.82,81.11 ; UC1.F28 151.38,81.66 151.28,81.66 ; UC1.G43 142.42,80.95 142.42,80.64 v2(142.27,80.49) ; UC1.G43 142.06,81.32 142.06,81.44 ; UC1.G43 141.97,80.8 141.97,80.79 ; UC1.G43 142.46,81.29 142.46,81.45 ; UC1.F40 144.1,81.43 144.3,81.23 144.3,81.06 ; UC1.F40 143.83,81.69 ; UC1.F40 144.09,81.42 143.86,81.19 143.86,81.08 ; UC1.F40 144.34,81.68 ; UC1.G57 133.27,81 133.27,80.82 133.41,80.68 ; UC1.G57 133.48,81.22 133.48,81.48 ; UC1.G57 133.58,80.89 133.66,80.89 ; UC1.G57 133.15,81.32 133.15,81.47 ; UC1.G45 141.09,81.3 141.09,81.43 ; UC1.G45 141.14,80.85 ; UC1.G45 140.73,80.94 140.73,80.73 ; UC1.G45 140.73,81.26 140.73,81.45 ; UC1.G35 147.46,81.28 147.46,81.46 ; UC1.G35 146.99,80.8 ; UC1.G35 147.42,80.97 147.42,80.75 ; UC1.G35 147.12,81.27 147.12,81.44 ; UC1.F36 146.47,81.3 146.47,81.01 ; UC1.F36 146.82,81.21 146.82,81.05 ; UC1.F36 146.47,81.56 146.46,81.56 146.35,81.67 ; UC1.G49 138.23,80.95 138.23,80.77 ; UC1.G49 138.56,81.28 138.56,81.43 ; UC1.G49 138.66,80.82 ; UC1.G49 138.19,81.29 138.19,81.45 ; UC1.G25 153.71,80.82 ; UC1.G25 153.72,81.4 ; UC1.G25 153.27,80.94 153.27,80.65 v2(153.43,80.49) ; 139.5,80.79 139.5,80.84 UC1.G47 ; 134.97,81.45 134.97,81.32 UC1.G55 ; 143.69,80.81 143.4,81.1 UC1.G41 ; UC1.G31 149.96,81.27 149.96,81.45 ; UC1.G31 149.59,81.31 149.59,81.43 ; UC1.G31 149.6,80.91 149.44,80.91 ; UC1.G31 149.87,81.02 149.87,80.75 ; 136.09,81.45 136.09,81.31 UC1.G53 ; 155.14,80.07 155.14,80.27 UC1.H23 ; UC1.F44 141.31,81.16 141.31,81.05 ; UC1.F44 141.83,81.68 ; UC1.F44 141.58,81.43 141.3,81.71 ; UC1.F44 141.77,81.24 141.77,81.1 ; 143.59,81.51 143.59,81.29 UC1.G41 ; UC1.F32 148.84,81.17 148.84,81.05 148.85,81.05 ; UC1.F32 149.32,81.64 149.41,81.64 ; UC1.F32 149.29,81.24 149.29,81.09 ; UC1.F32 148.9,81.63 148.8,81.63 ; 144.58,81.42 144.58,81.3 UC1.G39 ; UC1.F48 139.29,81.22 139.29,81.1 ; UC1.F48 138.79,81.71 ; UC1.F48 139.38,81.74 ; UC1.F48 138.83,81.18 138.83,81.08 ; 155.32,78.02 155.54,78.23 UC1.L22 ; UC1.F56 134.28,81.65 134.36,81.65 ; UC1.F56 133.79,81.7 ; UC1.F56 134.33,81.15 ; UC1.F56 133.79,81.16 ; 134.47,80.83 UC1.G55 ; UC1.G55 134.56,81.29 134.56,81.46 ; UC1.G55 134.86,80.99 134.86,80.78 ; 153.89,81.09 153.89,81.2 UC1.F24 ; 139.96,81.47 139.96,81.3 UC1.G47 ; 150.78,80.76 150.78,80.96 UC1.G29 ; UC1.L22 155.03,78.35 ; UC1.L22 155.54,78.58 155.38,78.74 ; 144.46,80.84 144.52,80.84 UC1.G39 ; UC1.G41 143.18,81.32 143.18,81.52 ; UC1.G41 143.22,80.93 143.22,80.67 v2(143.4,80.49) ; UC1.G39 144.92,80.96 144.92,80.76 ; UC1.G39 144.96,81.28 144.96,81.45 ; UC1.G47 139.91,80.96 139.91,80.8 ; 145.69,81.49 145.69,81.32 UC1.G37 ; UC1.G27 152.06,81.35 152.06,81.49 ; UC1.G27 152.47,81.27 152.47,81.47 ; UC1.G27 152.45,80.95 152.45,80.76 152.38,80.68 ; UC1.G27 152.03,80.84 ; 137.04,81.42 137.04,81.32 UC1.G51 ; 146.11,80.8 146.11,80.9 UC1.G37 ; 153.85,81.7 UC1.F24 ; UC1.F24 154.31,81.24 154.31,80.95 ; UC1.F24 154.38,81.69 ; 137.46,81.46 137.46,81.3 UC1.G51 ; UC1.H23 155.16,80.51 155.16,80.72 ; UC1.H23 154.73,80.08 ; UC1.H23 154.8,80.61 ; 137.43,80.78 137.43,80.93 UC1.G51 ; 154.52,80.82 UC1.G23 ; UC1.G23 154.59,81.32 154.59,81.42 ; UC1.G23 154.99,80.92 154.99,80.82 ; UC1.G23 155,81.29 155,81.45 ; UC1.G53 135.76,80.98 135.76,80.75 ; UC1.G53 136.1,80.88 136.1,80.77 ; UC1.G53 135.66,81.32 135.66,81.5 ; UC1.G51 136.95,80.8 ; UC1.G29 151.16,80.86 ; UC1.G29 150.72,81.3 150.72,81.46 ; UC1.G29 151.13,81.31 151.13,81.38 ; 136.83,81.69 UC1.F52 ; UC1.F52 136.29,81.15 ; UC1.F52 136.76,81.24 136.76,81.1 ; UC1.F52 136.33,81.66 136.28,81.66 ; 146.09,81.44 146.09,81.28 UC1.G37 ; UC1.G37 145.77,80.97 145.77,80.73
  BOTTOM w0.254: UC1.W57 v2(133.63,73.87) ; v2(133.67,76.64) 133.5,76.48 UC1.P57 ; UC1.K57 v2(133.85,79.08) ; UC1.AB57 v2(133.63,72.57) ; UC1.F59 132.11,81.15 v2(131.77,81.49) ; UC1.M57 v2(133.63,77.78) ; UC1.U57 v2(133.63,75.18)
  BOTTOM w0.508: RC250.1 v2(123.97,82.97)
  vias: v2(97.12,90.08) v2(97.17,88.73) v2(97.27,90.69) v2(97.37,89.42) v2(97.81,90.05) v2(97.91,90.69) v2(97.91,88.76) v2(97.88,88.02) v2(98.01,89.42) v2(98.44,90.05) v2(98.54,88.76) v2(98.64,88.02) v2(98.67,90.69) v2(98.77,89.42) v2(99.08,91.38) v2(99.2,90.05) v2(99.3,88.76) v2(99.3,88) v2(99.38,90.72) v2(99.43,89.39) v2(99.79,91.4) v2(99.91,90.08) v2(99.94,88) v2(99.97,88.73) v2(100.09,90.72) v2(100.12,89.45) v2(100.42,91.35) v2(100.57,90.08) v2(100.63,88.76) v2(100.63,87.97) v2(100.83,90.74) v2(100.88,89.45) v2(101.16,91.38) v2(101.29,90.11) v2(101.26,87.97) v2(101.39,88.76) v2(101.46,90.74) v2(101.51,89.45) v2(101.79,91.38) v2(101.92,90.13) v2(102.02,88.76) v2(102.23,90.74) v2(102.25,92.01) v2(102.28,89.45) v2(102.56,91.38) v2(102.56,90.11) v2(102.78,88.76) v2(102.89,92.01) v2(102.94,90.72) v2(102.94,89.45) v2(103.24,90.11) v2(103.27,91.35) v2(103.44,88.84) v2(103.62,90.72) v2(103.6,89.45) v2(103.85,90.18) v2(104.21,89.57) v2(109.41,100.44) v2(109.39,97.34) v2(109.39,96.76) v2(109.36,93.51) v2(109.36,92.92) v2(109.46,101.08) v2(111.65,93.53) v2(111.65,92.95) v2(111.67,101.08) v2(111.67,100.44) v2(111.67,97.32) v2(111.67,96.73) v2(113.96,101.08) v2(113.96,100.44) v2(113.96,97.34) v2(113.96,96.76) v2(113.96,93.51) v2(113.96,92.92) v2(116.25,101.13) v2(116.24,100.44) v2(116.25,97.29) v2(116.24,96.71) v2(116.25,93.51) v2(116.24,92.92) v2(118.53,100.44) v2(118.53,97.32) v2(118.53,96.73) v2(118.56,101.15) v2(118.56,93.51) v2(118.56,92.92) v2(120.82,101.18) v2(120.79,100.44) v2(120.79,97.32) v2(120.79,96.73) v2(120.82,93.48) v2(120.82,92.9) v2(121.94,85.64) v2(123.1,101.13) v2(123.1,100.44) v2(123.1,97.34) v2(123.1,96.73) v2(123.1,93.48) v2(123.1,92.9) v2(125.39,101.13) v2(125.39,100.44) v2(125.37,97.37) v2(125.37,96.79) v2(125.37,93.46) v2(125.39,92.82) v2(126.64,94.25) v2(126.66,94.86) v2(133.9,80.45) v2(134.19,82.03) v2(134.61,80.4) v2(135.91,80.38) v2(136.44,82.03) v2(137.26,80.49) v2(138.38,80.49) v2(139.21,82.03) v2(139.77,80.45) v2(140.96,80.48) v2(141.72,82.03) v2(144.22,82.03) v2(144.64,80.45) v2(145.96,80.45) v2(146.73,82.03) v2(147.23,80.48) v2(148.53,80.45) v2(149.24,82.03) v2(151.75,82.03) v3(150.87,80.19) v6(104.35,95.49)
+VCC_PWR_SRC: length 13.6
  BOTTOM w0.127: v6(92.01,116.01) 91.85,115.85 91.85,114.41
  BOTTOM w0.254: PC314.1 83.81,100.97 83.2,100.37 83.2,97.95 84.04,97.12 88.67,97.12 89.23,96.56 PR311.1
+VCCIO_OUT: length 19.4
  BOTTOM w0.254: UC1.A59 132.24,84.85 130.57,86.52 129.91,86.52 128.94,87.49
  BOTTOM w0.508: RC242.1 115.33,86.27 116.55,87.49 v1(118.55,87.49) 128.94,87.49
+VCCIOA_OUT: length 5.7
  TOP w0.508: RC134.1 v1(154.32,82.26) 155.16,83.1 156.68,83.1 v2(157.52,82.25)
  BOTTOM w0.254: v2(157.52,82.25) 157.21,81.94 UC1.E20
+VDDA_AVDD1: length 19
  TOP w0.508: v3(322.58,152.65) 321.91,151.98 v1(321.91,149.11) 319.52,146.72 312.9,146.72 v2(311.47,148.15)
  BOTTOM w0.254: U17.27 310.23,148.95 310.52,148.66 310.52,148.1 C115.1
  BOTTOM w0.508: C115.1 311.15,147.77 311.47,148.09 v2(311.47,148.15)
+VDDA_AVDD2: length 63.8
  TOP w0.508: v3(319.52,161.33) 319.75,161.33 324.91,166.48 v1(329.9,166.48) 339.72,166.48 340.17,166.03 340.17,162.52 339.82,162.17 v3(338.55,162.17)
  IN1 w0.508: v3(317.95,154.01) 317.95,152.16 315.42,149.63 v2(302.65,149.63)
  IN3 w0.508: v3(319.52,161.33) 319.85,161 319.85,154.44 319.42,154.01 v3(318.61,154.01)
  BOTTOM w0.254: JIO1.66 338.76,161.95 v3(338.55,162.17) ; C150.1 303.72,150.31 304.14,150.73 U17.38
  BOTTOM w0.508: v3(319.52,161.33) 320.69,160.16 R158.1 R159.1 ; C150.1 v2(302.65,149.63)
+VDDA_PVDD: length 19.2
  TOP w1.016: v2(303.46,150.82) 300.11,150.82 298.78,152.15 v2(298.78,152.69)
  BOTTOM w0.254: U17.45 304.57,154.23 303.75,155.05 302.91,155.05 C123.1 ; C129.1 302.66,151.37 302.83,151.55 303.64,151.55 303.84,151.35 303.85,151.35 303.97,151.23 U17.39
  BOTTOM w0.508: v2(298.78,152.69) 298.78,153.77 C122.1 299.86,154.04 300.4,153.5 301.64,153.5 301.92,153.78 301.92,154.06 C123.1 ; C129.1 302.99,150.96 303.32,150.96 v2(303.46,150.82)
  vias: v1(274.96,168.05) v3(274.23,165.09) v3(274.92,165.09) v3(275.56,165.06) v3(287.47,157.19) v3(288.1,157.19) v3(288.74,157.21)
+VDDRP: length 34.7
  TOP w0.254: v2(39.15,55.18) 39.16,55.17 39.16,54.59 v6(36.9,52.33) 32.25,47.68 32.25,31.83 32.02,31.6 32.02,29.89 32.71,29.21 32.71,25.69 32.1,25.09 v2(32.1,24.73)
  BOTTOM w0.254: PR707.2 v2(32.1,24.73)
+VDDRP_B+:
  vias: v1(42.43,36.73)
GND: length 3814.3
  TOP w0.102: v2(270.68,179.12) v6(270.68,179.8) ; v2(46.13,118.82) v6(46.13,119.5) ; v2(52.8,118.78) v6(52.8,119.46) ; v2(271.21,172.22) v6(271.21,172.8) ; v6(252.71,130.26) 252.22,129.78 v2(252.22,129.49) ; v2(266.18,177.76) v6(266.18,178.43) ; v2(324.7,181.39) v6(324.7,182.07) ; v2(334.86,178.55) v6(334.86,179.22)
  TOP w0.152: U6.D7 177.26,159.17 176.62,159.17 v5(176.61,159.17)
  TOP w0.203: U6.F10 v5(178.56,161.12) ; U6.D11 177.59,161.44 v5(177.26,161.12) U6.D10 ; U6.F7 v5(178.56,158.52) ; U6.G6 v5(179.86,157.87) 179.54,157.55 U6.G5 ; U6.F11 v5(178.56,161.77) 178.24,161.44 U6.E11 ; v3(118.36,122.69) 118.16,122.49 U52.6 ; UV7.G8 UV7.G9 ; U6.J11 v5(181.16,161.77) ; U6.J8 v5(181.16,159.82) ; U6.E4 v5(177.91,156.57) ; U6.J9 v5(181.16,160.47) ; U6.G4 v5(179.86,156.57) ; U52.16 119.9,122.96 v3(119.63,122.69) ; U6.D5 v5(177.26,157.22) ; v2(166.54,102.55) U43.11 ; U6.L6 v5(182.46,157.87) ; U6.F6 v5(178.56,157.87) 178.89,157.55 U6.F5 ; U6.D4 v5(177.26,156.57) ; U6.H10 v5(180.51,161.12) ; UV5.G8 UV5.G9 ; U6.J6 v5(181.16,157.87) ; U6.J12 v5(181.16,162.42) ; v3(190.19,109.84) 190.36,110.02 U45.11 ; U6.G11 v5(179.86,161.77) ; U6.D6 v5(177.26,157.87) ; U6.J7 v5(181.16,158.52) ; U6.G7 v5(179.86,158.52) ; U6.D9 v5(177.26,160.47) ; U6.G10 v5(179.86,161.12) ; U4.3 151.08,108.36 v2(151.32,108.11) ; U6.H4 v5(180.51,156.57) ; U6.G9 v5(179.86,160.47) ; U6.J5 v5(181.16,157.22) ; U6.F8 v5(178.56,159.82) ; U6.D8 v5(177.26,159.82) ; U6.G8 v5(179.86,159.82) ; U6.C5 v5(176.61,157.22) ; U6.K5 v5(181.81,157.22) ; U6.F4 v5(178.56,156.57) ; U6.F9 v5(178.56,160.47)
  TOP w0.254: JAPS1.14 v2(225.73,79.09) ; UV7.T9 27.93,88.12 v2(27.56,87.74) ; v2(34.73,103.56) 34.78,103.56 UV5.G9 ; U91.25 187.1,97.82 v2(187.85,97.07) ; UV5.D1 37.16,110.66 37.16,110.74 ; UV5.T1 28.34,110.72 29.06,110.72 v2(29.13,110.64) 29.47,110.3 UV5.P1 ; v2(106.23,130.16) 106.62,129.77 JUDB1.10 ; RP18.4 176.46,120.17 v2(176.67,120.38) ; UV7.D8 v2(37.13,88.55) UV7.E8 ; 188.84,97.01 188.99,96.86 189.07,96.86 190.1,95.83 U91.10 ; UV5.D8 v2(37.12,104.3) UV5.E8 ; v2(87.65,16.55) 88.05,16.95 88.05,17.26 88.06,17.26 JEXP1.38 ; U90.11 225.48,55.42 v2(225.18,55.71) ; U6.B14 176.29,163.39 v5(176.61,163.72) U6.C14 ; UV7.G9 35.09,88.15 v2(34.74,87.81) ; v2(88.04,24.63) 88.06,24.62 JEXP1.37 ; v2(33.88,88.54) 33.53,88.89 UV7.J8 ; UV7.M1 30.73,94.96 30.01,94.96 v2(29.96,94.91) ; v2(91.53,23.77) 91.06,23.3 JEXP1.25 ; v2(133.54,108.39) 133.9,108.04 JTP1.8 ; v2(39.43,92.35) 39.13,92.65 UV7.B3 ; UV7.P9 29.53,88.17 v2(29.16,88.54) ; 37.16,110.74 v2(37.16,110.76) ; 37.16,110.74 UV5.E1 ; JEXP1.32 89.56,16.71 89.65,16.62 89.65,16.6 v2(89.68,16.57) ; v2(30.74,104.29) 31.12,103.92 UV5.M9 ; U6.B13 176.29,162.74 v5(176.61,163.07) U6.C13 ; JLVDS1.5 98.19,158.45 97.93,158.71 v2(97.93,159.02) ; JEXP1.17 93.06,23.56 v2(93.25,23.75) ; JLVDS1.15 101.06,153.45 v3(101.26,153.65) ; v2(36.29,87.73) 35.93,88.09 UV7.F9 ; U91.12 191.46,96.82 v2(191.66,97.01) ; PU701.23 v2(130.65,158.56) ; v2(148.54,110) 148.54,109.82 148.96,109.4 U4.8 ; UV5.G1 v2(35.52,110.7) ; v2(95.66,24.48) 95.06,23.88 JEXP1.9 ; U91.20 187.6,99.53 187.8,99.73 v2(187.8,99.81) ; v2(39.53,87.75) UV7.B9 ; v2(117.53,163.83) 117.73,163.63 PU402.14 ; UV7.D1 v2(37.13,94.95) UV7.E1 ; v3(100.37,152.01) 100.32,151.95 JLVDS1.18 ; UV7.P1 29.49,94.55 v2(29.14,94.89) 29.07,94.97 28.35,94.97 UV7.T1 ; UV7.B1 39.13,94.61 v2(39.53,95.01) ; v2(27.7,103.43) 27.92,103.65 UV5.T9 ; UV7.M9 31.13,88.17 v2(30.76,88.54) ; v2(101.74,148.17) 101.54,147.97 100.98,147.97 100.5,148.45 JLVDS1.25 ; U83.10 v2(302.3,165.27) ; U6.L6 182.14,158.22 182.26,158.34 182.26,158.7 182.14,158.82 U6.L7 U6.L8 ; U91.27 186.58,96.82 v2(186.81,97.04) ; UV7.J2 33.53,93.76 v2(33.93,94.16) ; JEXP1.20 92.56,19.39 93.17,20 93.27,20 v2(93.4,20.14) ; v2(39.52,103.5) UV5.B9 ; JLVDS1.28 v3(97.93,146.95) ; RP18.3 176.45,119.67 v2(176.65,119.47) 176.35,119.17 RP18.2 ; UV5.F9 35.79,103.9 v2(35.32,103.43) ; U83.21 v2(296.51,165.27) ; UV5.A9 v2(40.32,103.5) ; v2(100.73,159.04) 100.32,159.45 JLVDS1.3 ; v2(171.87,70.9) 172.44,71.47 CC54.2 ; PU701.32 126.91,154.7 v2(126.76,154.85) ; UV7.E2 v2(37.13,93.35) ; PU701.5 v2(130.65,150.46) ; UV5.P9 29.52,103.92 v2(29.14,104.29) ; v2(191.48,98) 191.18,98 190.99,97.82 U91.14 ; PQ523.4 v2(139.33,157.82) ; UV5.E2 v2(37.12,109.1) ; v2(33.92,109.91) 33.52,109.51 UV5.J2 ; v2(163.26,133.51) 163.26,133.54 162.73,133.01 RP16.1 ; PU701.14 v2(134.61,154.7) ; v2(29.94,110.66) 30,110.71 30.71,110.71 UV5.M1 ; v2(185.28,94.55) 185.41,94.55 185.6,94.74 U91.1 ; v2(53.92,111.14) 54.05,111.01 RV2721.2 RV2722.2 ; UV5.B3 39.12,108.21 v2(39.23,108.1) ; v2(39.52,110.7) UV5.B1 ; UV7.A9 v2(40.33,87.75) ; U6.D14 v5(177.26,163.72) ; JEXP1.26 91.06,17.08 v2(91.58,16.56) ; JEXP1.8 95.56,18.95 ; U6.D13 v5(177.26,163.07) ; v2(93.87,16.67) 94.06,16.87 JEXP1.14 ; v2(121.33,119.98) 121.4,119.9 123.02,119.9 123.91,119.01 124.65,119.01 R2583.1 124.65,120.08 123.92,120.08 123.23,120.76 v2(121.33,120.76) ; UV7.G1 v2(35.53,94.95)
  TOP w0.279: JXDP1.14 v2(87.7,40.36) ; JXDP1.26 v2(87.84,43.36) ; JXDP1.32 v2(87.77,44.86) ; JXDP1.2 v2(90.97,37.36) ; JXDP1.19 v2(93.67,41.86) ; JXDP1.38 v2(91.48,46.36) ; JXDP1.7 v2(93.62,38.86) ; v2(92.84,38.01) 93.49,37.36 JXDP1.1 ; v2(93.72,51.42) 93.81,51.51 93.81,51.71 93.96,51.86 JXDP1.59 ; JXDP1.13 v2(93.7,40.36) ; v2(87.14,37.88) 87.14,38.09 87.91,38.86 JXDP1.8 ; v2(93.61,46.36) JXDP1.37 ; v2(88,41.86) JXDP1.20 ; JXDP1.25 v2(93.57,43.36) ; v2(91.2,49.36) JXDP1.50 ; JXDP1.31 v2(93.52,44.86) ; v2(93.49,49.36) JXDP1.49
  TOP w0.305: v2(33.16,104.26) 33.52,104.62 UV5.J8 ; JLED1.12 v2(221.49,33.56) ; U25.11 179.4,143.79 C200.2 ; U15.5 218.21,125.01 218.47,125.27 v2(218.47,125.77) ; v2(216.78,121.65) 216.78,121.98 216.6,122.16 U15.16 ; JAPS1.10 v2(224.02,77.09) ; U25.9 180.7,142.98 v2(180.99,143.27) 181.35,142.91 U25.8 ; U37.B27 188.26,123.14 188.34,123.07 v2(188.34,123.05) ; JDEG1.10 v2(223.6,96.05) ; v2(170.79,119.04) U38.B18 ; v2(162.53,120.53) 162.47,120.48 162.16,120.48 162.02,120.63 161.94,120.63 161.92,120.64 U38.B66 ; v2(223.84,77.99) 223.94,78.09 JAPS1.12 ; JUDB1.13 106.76,128.27 v2(106.26,128.77) JUDB1.12 ; v2(167.13,119.7) 167.19,119.64 U38.B11 ; JLED1.10 219.86,34.52 v2(219.78,34.61) ; v2(213.66,122.85) 213.82,123.01 U15.13 ; v3(108.73,125.68) 108.64,125.77 JUDB1.18 ; U38.B54 161.96,126.64 162.08,126.52 163.1,126.52 163.19,126.42 163.85,126.42 v2(163.92,126.49) ; v2(100.9,178.42) 100.73,178.25 JMED1.6 ; 95.56,18.95 v2(96.21,19.6) ; U15.12 v2(213.68,123.51) ; JPWR1.6 312.25,167.72 310.94,166.41 v2(310.94,166.38) ; JPWR1.9 310.75,168.3 309.39,166.94 v2(309.39,166.43) ; U38.B60 161.92,123.64 161.99,123.71 162.46,123.71 162.88,123.3 v2(162.88,123.23) ; JAPS1.8 v2(226.06,76.09) ; U15.10 213.62,124.51 v2(213.5,124.4) ; JUDB1.11 v2(108.97,129.27) ; v2(216.1,121.7) U15.15
  TOP w0.381: PQ515.4 v2(139.71,141.73) ; QZ21.4 60.8,85.98 v2(60.08,86.69) ; v2(147.21,141.52) 147.67,141.98 PU502.3 ; v2(138.57,139.74) 138.41,139.9 PQ515.1 ; v2(142.92,150.63) PQ503.1 ; v2(165.75,140.37) 165.53,140.15 U42.3 ; v2(148.35,161.68) 148.78,161.68 PQ506.4 ; PU504.3 v2(158.5,157.3) ; CC66.2 160.42,71.82 v2(160.37,71.87) ; U25.18 179.4,135.59 178.65,134.85 178.52,134.85 178.18,134.51 178.18,133.97 178.58,133.58 v2(178.71,133.58) ; v2(145.54,146.44) 145.54,146.25 145.08,145.79 PU500.3 ; v2(34.73,103.56) 34.73,101.94 34.48,101.69 CV2926.2 ; PQ409.1 123.97,135.02 124.2,135.25 124.2,136.15 PR12.2 ; PQ519.1 v2(141.33,141.74) ; v2(184.14,54.93) 184.14,55.38 184.34,55.59 UC4.3 ; U11.7 163.37,157.59 v2(164.02,156.93) ; v2(188.36,59.93) 188.49,60.06 UC7.3 ; v2(159.09,77.87) 159.36,78.14 CC33.2 ; v2(154.85,157.01) 154.56,157.3 PU505.3 ; v2(144.22,153.92) PQ503.4 ; v2(132.24,139.25) 132.24,138.06 PU1.2 ; v2(58.5,87.33) 58.54,87.28 QZ21.1 ; v2(131.16,72.48) 131.11,72.53 RC238.2 ; v2(227.07,120.7) 227.03,120.66 SW5.5 ; QZ5.4 v2(30.95,115.88) ; U13.7 v2(168.95,156.63) ; v2(205.83,154.42) 206.09,154.42 206.38,154.13 U47.3 ; PQ516.4 v2(147.24,156.04) ; PQ502.1 148,148.14 v2(147.57,147.71) 147.56,147.69 147.56,147.52 PQ507.4 ; PQ507.1 150.31,145.38 v2(150.31,145.1) ; JUDB1.16 106.72,126.77 v3(106.58,126.63) ; CC36.2 162.21,70.57 v2(161.9,70.88) ; RC133.2 130.85,70.04 129.56,70.04 128.95,70.65 128.06,70.65 127.88,70.83 v2(127.88,70.95) ; PQ502.4 v2(149.3,151.31) ; v2(128.72,73.46) 128.91,73.46 129.9,72.47 RC235.2 ; v5(57.98,110.7) 57.98,110.68 57.3,110 CV102.2 ; UC3.3 192.69,58.6 v2(192.93,58.84) ; PQ519.4 v2(142.63,143.47) ; v2(152.15,166.03) 152.42,166.3 PU506.3 ; U25.25 v2(183.95,137.6) ; PQ516.1 v2(148.54,157.87) ; PQ523.1 v2(138.03,155.91)
  TOP w0.4: CV88.2 62.07,93.35 v5(62.3,93.58)
  TOP w0.406: U24.3 203.09,155.23 v2(203.37,155.51) ; v2(193.15,155.98) U20.3 ; U87.3 144.67,112.35 144.29,111.97 v2(144.29,111.92) ; U93.2 v2(109.59,114.59) ; PU401.2 123,147.26 v2(122.62,146.88) 122.89,146.61 PU401.1
  TOP w0.432: PQ702.4 v2(130.23,129.15) ; v2(198.31,132.09) 197.91,131.69 Q5.4
  TOP w0.457: CC5.2 162.27,56.91 161.64,56.91 v2(161.48,56.76) ; RC168.2 159.16,58.03 v2(158.64,58.03) ; CC30.2 159.24,56.06 v2(158.89,56.06) 158.7,56.06 CC65.2 ; CC56.2 157.05,72.69 157.47,73.11 v2(157.47,73.27) ; CC46.2 161.38,70.25 CC36.2 ; CC39.2 162.09,69.15 v2(162.09,68.7) ; U94.5 153.41,110.63 153.15,110.88 153.15,111.11 153.34,111.3 156.86,111.3 157.25,111.7 157.25,113.11 C365.2 ; Q143.4 163.5,108.1 v2(162.96,107.56) ; v2(160.61,110.02) 161.23,109.4 Q143.1 ; v2(216.1,121.7) 216.1,121.31 C102.2 ; Q5.1 v2(199.88,133.23)
  TOP w0.508: C397.2 C398.2 187.66,110.25 v3(186.48,110.25) ; v2(60.65,97.3) 61.1,97.74 PC666.2 ; CD15.2 119.65,20.7 v2(119.04,21.31) ; v2(88.04,24.63) 86.11,24.63 84.57,23.1 84.57,21.35 85.36,20.56 JEXP1.42 ; v2(149.08,145.12) PC502.1 ; v2(143.7,166.31) 144.14,166.31 144.49,165.95 PQ525.3 ; RC153.1 168.49,97.32 168.49,97.67 168.14,98.03 v3(168.14,98.16) ; CD24.2 CD25.2 148.62,27.38 v2(148.18,27.82) 150.54,27.82 CD30.2 ; v2(289.12,149.8) 289.13,149.8 C125.2 ; C2990.2 v2(188.99,165.9) ; v3(158.39,123.82) 157.74,123.82 C362.2 R384.2 ; R2586.2 111.6,120.69 111.01,120.1 R2593.1 110.51,119.77 v3(110.84,119.44) ; CV3054.2 66.31,95.52 v2(66.5,95.33) ; v2(35.25,112.22) 35.25,112.4 34.5,113.15 CV2941.2 RV2712.2 ; D22.1 v2(141.77,104.14) ; v2(32.73,114.76) RV2710.2 CV2902.2 ; PC512.2 130.71,148.04 v2(130.71,147.36) ; v2(102.38,135.8) 103,136.42 JUDB1.21 ; v2(176.42,121.32) 176.39,121.3 175.63,121.3 C357.2 ; v5(68.13,106.84) 68.1,106.87 RV2723.2 ; JKB1.1 212.64,103.69 v2(212.49,103.54) ; C1188.2 314.98,165.62 v2(314.65,165.29) ; CC60.2 158.88,71.39 v2(158.88,70.86) 159.19,70.54 CC44.2 ; v2(228.36,40.68) 227.85,40.17 C460.2 ; JDEG1.12 229.12,88.18 v2(229.4,88.18) ; C396.2 187.13,108.27 v3(186.76,108.27) ; C390.2 166.54,102.04 v2(166.54,102.55) ; v2(101.51,174.89) 101.87,174.54 PC11.2 ; Q9.3 118.6,78.8 v2(120.58,78.8) ; C88.2 16.13,105.84 v2(16.22,105.93) ; v2(132.46,140.5) 132.46,140.77 132.07,141.16 131.25,141.16 PQ5.6 ; v2(150.69,158.1) 150.79,158.2 PC510.2 ; CV2932.2 30.95,112.76 30.62,112.43 v2(30.37,112.43) ; DE2.1 235.12,127.62 v2(235.68,127.06) ; C634.2 v2(96.66,12.36) ; v2(255.16,186.22) 255.16,185.83 254.79,185.46 U28.2 ; C376.2 v2(209.31,103.03) ; CC50.2 150.65,70.9 150.65,69.95 v2(150.95,69.65) ; CC34.2 158.26,74.66 v2(158.44,74.84) ; CD18.2 120.92,24.8 v2(120.77,24.65) ; v2(208.61,93.41) 208.13,92.93 JBIO1.8 207.1,93.71 v2(207.97,93.71) ; v5(60.65,106.94) 60.84,106.94 CV3061.2 ; C452.2 v2(213.3,185.58) ; v2(329.45,157.89) C141.2 ; CC40.2 CC53.2 161.68,72.11 v2(161.64,72.07) 161.64,72.05 CC37.2 ; CC64.2 156.05,75.07 v2(156.08,75.1) ; v2(56.72,103.27) 56.46,103.52 PC667.2 ; v2(201.51,172.86) 201.9,173.25 C193.2 ; PC507.2 154.83,154.11 v2(154.45,154.49) ; CC61.2 166.82,97.85 v3(166.82,98.13) ; RD11.2 226.63,29.91 v2(227.63,29.91) 227.63,29.88 227.22,29.48 CD61.2 CD60.2 ; v2(216.17,115.48) 216.17,117.13 C462.2 ; C30.2 153.69,106.84 153.46,106.62 C75.2 152.7,105.8 154,104.49 154,103.93 v2(154.4,103.53) 154.4,103.52 154.87,103.05 CC42.2 ; CV2937.2 CV2939.2 v2(36.26,99.2) ; CD9.2 117.1,18.9 117.1,20.29 116.84,20.55 v2(116.48,20.55) ; PR12.2 124.63,136.2 v2(124.96,135.88) ; v2(35.76,96.53) 35.76,96.8 CV2962.2 CV2960.2 ; CC14.1 167.29,60.17 v2(166.96,60.17) ; C18.2 181.8,171.61 v3(182.06,171.87) ; PC406.2 125.22,146.12 v2(125.22,145.68) ; UC5.4 211.22,60.68 211.81,61.28 211.82,61.28 212.72,62.18 H36.1 ; R32.1 233.24,32.63 v2(233.19,32.68) ; v2(217.34,53.12) 217.39,53.07 R2696.1 ; C3029.2 222.27,57.81 v2(222.26,57.79) ; v2(125.95,122.85) C435.2 ; v2(168.55,136.56) 167.83,137.28 C386.2 ; D78.1 200.52,87.97 v2(199.89,88.59) ; HDMIU1.2 13.64,100.56 v2(13.38,100.29) ; v2(288.56,147.74) 288.86,147.43 C124.2 ; CV239.2 65.1,99.14 PC668.2 64.53,99.58 v5(63.77,100.34) ; JTAG1.2 153.46,123.81 v2(153.67,124.02) ; CC51.2 156.57,77.47 156.1,77.94 v2(155.87,77.94) ; CC9.2 v2(195.12,58.17) ; JTP1.9 134.55,103.05 v2(134.28,102.78) ; v2(111.8,133.84) 111.49,134.15 PR453.2 ; R438.2 228.57,38.39 v2(228.39,38.57) ; CD3.2 v2(104.79,12.43) ; CC2.1 v2(180.1,55.79) ; v2(204.36,89.79) 204.07,89.79 203.75,90.1 JBIO1.6 ; v2(176.29,127.55) 176.17,127.67 C350.2 R371.1 ; v2(160.06,74.13) 159.75,74.44 CC43.2 ; v2(36.03,112.54) 35.56,113.01 CV2935.2 ; 62.89,104.27 v5(62.89,104.4) ; 62.89,104.27 62.89,104.17 62.65,103.92 62.4,103.92 CV235.2 ; 62.89,104.27 63.4,103.76 CV233.2 ; CV226.2 65.09,95.36 65.42,95.04 v2(65.42,94.76) ; C200.2 179.14,144.54 v2(178.83,144.84) ; C148.2 271.38,176.61 v2(271.4,176.59) ; C97.2 163.74,166.61 v2(163.54,166.81) ; v3(168.32,100.7) 168.32,101.41 CC75.2 169.03,101.67 169.03,100.75 v2(169.05,100.75) ; v2(222.44,31.96) 223.01,31.4 JLED1.14 ; v2(178.4,55.38) 178.4,54.7 179.17,53.94 RC52.2 ; R2634.1 297.37,170.88 ; 297.37,170.88 295.44,170.88 v2(291.76,167.19) ; 297.37,170.88 301.01,170.88 C2972.2 ; v2(29.36,83.64) CV2968.2 29.41,84.33 CV2967.2 ; PC70.2 209.68,159.48 v2(209.65,159.46) 209.03,158.83 PR57.1 ; D18.1 16.5,80.83 v2(15.74,81.59) ; C387.2 167.1,141.06 v2(166.89,141.26) ; CC23.2 201.49,53.89 v6(200.85,53.25) v2(200.85,52.56) ; v2(163.47,113.4) 163.09,113.02 C343.2 R399.1 ; C366.2 169.31,113.68 v2(169.05,113.42) ; v2(158.61,99.83) 158.61,100.21 158.08,100.75 CC76.2 ; v2(112.28,20.55) 112.68,20.55 112.9,20.33 112.9,19.03 CD8.2 ; CE8.2 188.61,175.81 v2(189.2,175.22) ; CD21.2 125.8,25.87 125.8,24.48 125.43,24.1 v2(125.18,24.1) ; Y3.4 205.47,142.27 v2(205.71,142.51) ; v2(228.51,26.35) 228.36,26.2 CD59.2 ; C406.1 v2(195.51,153.23) ; v2(314.93,171.41) 315.83,172.32 JPWR1.11 ; v2(111.26,116.14) 111.75,115.65 C414.2 ; CD16.2 113.58,26.03 113.58,24.46 113.94,24.1 v2(114.2,24.1) ; v2(161.12,135.88) 161.02,135.78 160.92,135.68 160.92,135.25 R342.1 ; RC132.2 156.55,24.04 RC128.2 156.51,22.36 v2(155.1,20.95) ; C311.2 R271.2 177.58,183.3 177.51,183.23 v2(177.51,183.25) ; C354.2 156.3,130.47 v2(156.18,130.59) ; v2(95.01,161.28) 95.01,159.82 JLVDS1.44 ; JUDB1.22 105.36,122.62 v2(106.04,121.94) ; v2(147.85,80.85) 147.85,79.72 PC382.2 146.57,79.97 v3(146.57,80.25) ; v2(152.47,170.29) 152.16,170.6 PC515.2 ; PC51.1 209.74,151.17 v2(210.02,150.89) ; Q135.3 165.69,165.94 166.49,166.74 166.74,166.74 v2(166.79,166.79) ; CV3056.2 53.87,84.87 v2(53.25,85.48) ; CE10.2 107.53,156.3 v2(107.89,156.65) ; v2(289.04,152.18) 289.53,152.18 C126.2 ; R2592.1 107.84,119.85 v3(108.22,119.47) ; C203.2 179.25,133.58 v2(178.71,133.58) ; v2(215.28,56.93) 214.25,55.9 CC57.1 CC25.1 ; PC660.2 59.06,97.68 v5(58.71,97.33) ; v2(217.88,58.33) 217.57,58.01 R2698.1 ; C1185.2 C1001.2 338.98,175.81 v2(338.47,175.3) ; v2(225.31,16.57) 225.31,16.72 225.21,16.83 225.21,17.23 224.93,17.51 CD57.2 ; C180.2 199.29,139.48 v2(198.64,139.48) ; CC48.2 102.77,48.43 v2(103.34,49.01) ; CC43.2 CC28.2 ; CC43.2 159.35,75.37 CC45.2 ; v2(158.59,149.59) 158.87,149.31 C34.2 ; v2(191,152.54) 190.64,152.18 C42.2 ; v2(297.04,159.63) 297.2,159.78 C2965.2 ; CV2938.2 37.53,114.25 37.54,114.26 37.54,114.69 v2(37.6,114.76) ; v2(205.01,86.46) 204.65,86.1 JBIO1.2 ; v2(64.78,97.42) 64.22,96.86 PC672.2 ; CC1.1 180.1,59.55 179.85,59.8 178.73,59.8 v2(177.89,58.97) ; PC411.1 v2(113.78,155.13) ; PC514.2 136.84,152.99 PC513.2 v2(136.84,151.2) ; v2(252.87,180.81) 253.5,180.18 C263.2 ; C352.2 C346.2 175.94,122.21 176.04,122.11 v2(176.32,122.11) ; C337.2 202.82,123.01 v2(203.14,123.33) ; v5(54.87,93.58) 54.74,93.72 CV94.2 ; v2(125.89,132.69) 125.95,132.75 PC433.2 ; v3(144.01,80.17) 144.01,79.82 PC383.2 145.34,79.83 v2(145.34,80.85) ; CV2933.2 37.53,112.71 37.35,112.54 v2(37.35,112.47) ; v2(158.18,117.44) 157.92,117.18 157.92,117.16 157.47,116.71 C364.2 ; v2(100.65,12.33) 100.65,12.57 100.47,12.75 RC69.2 ; C635.2 98.69,13.04 C636.2 v2(98.7,12.23) ; CC10.2 v2(85.66,49.57) ; C10.2 C12.2 186.9,163.28 186.46,163.72 186.45,163.74 186.38,163.66 v2(186.35,163.66) ; C375.2 205.2,103.03 v2(205.17,103.06) ; v2(183.25,171.13) 183.37,171.01 R47.2 ; C3026.2 226.75,57.9 v2(226.99,57.65) ; JDEG1.11 v2(229.35,98.2) ; v2(67.29,112.42) 67.14,112.58 YV2401.2 ; RC191.2 190.49,136.54 v2(190.8,136.84) ; v2(104.76,157.06) 104.76,157.8 D77.1 ; v2(156.43,149.72) 156.21,149.5 PQ512.3 ; v3(130.86,110.53) 131.33,110.05 C374.2 ; PC67.2 v2(235.65,163.61) ; C24.2 169.94,154.98 v2(169.59,155.33) 170.37,156.12 C17.2 ; v2(155.97,122.26) 156.29,122.26 156.59,121.96 C347.2 ; v2(110.73,141.21) 111.09,140.85 PC434.2 ; v2(171.78,19.63) 172.36,19.04 CD34.2 ; C3028.2 229.58,51.49 v2(229.59,51.47) ; CD14.2 115.59,20.2 115.24,20.55 v2(114.68,20.55) ; v3(149.44,70.24) 149.44,71.67 CC47.2 ; C331.2 v2(200.6,122.85) ; v2(129.4,104.39) 129.4,104.39 128.25,103.24 JTP1.10 ; v2(200.4,155.56) 200.35,155.56 200.35,155.53 R184.2 ; v2(202.44,157.04) 202.64,157.24 C198.2 ; C3025.2 v2(220.95,47.46) ; v5(58.74,99.32) 58.79,99.26 PC663.2 ; C23.2 v2(170.05,157.04) ; C1186.2 110.33,134.33 v2(110.76,134.76) ; v2(253.2,181.58) 252.63,182.15 C267.2 ; CD31.2 149.22,18.92 148.67,18.92 147.87,19.72 v2(147.36,19.72) ; R309.1 v2(189.25,114.19) ; PR59.2 v2(211.98,161.84) ; v3(139.06,80.33) 139.06,79.95 PC365.2 140.35,79.67 140.35,80.82 v2(140.32,80.85) ; v2(133.87,138.01) 133.87,137.93 134.1,137.71 134.1,137.7 134.33,137.48 134.33,137.48 134.61,137.2 PC4.2 ; v2(300.35,159.32) 300.35,159.7 300.75,160.11 R2626.2 ; SW5.6 228.56,125.09 229.21,125.74 v2(229.3,125.74) ; C379.2 145.15,103.04 v2(143.36,101.26) ; v2(148.61,140.88) 148.85,140.64 PQ508.3 ; v3(193.13,114.51) 193.13,115.07 C330.2 ; v2(163.3,55.23) 163.3,55.13 163.82,54.61 RC136.1 ; v2(148.86,107.35) 148.3,107.35 C3003.2 C3002.2 ; C264.2 v2(251.86,185.21) ; CD58.2 226.97,17.18 v2(226.81,17.03) ; v2(144.57,95.01) 145.69,93.89 RC47.2 RC46.2 ; CD56.2 225.82,17.94 226.05,17.72 v2(226.05,16.65) ; PU503.3 158.1,153.53 v2(158.49,153.53) ; RC154.2 171.61,74.15 171.21,74.55 170.4,74.55 170.05,74.2 v2(170.05,73.96) ; CC12.2 148.63,58.3 148.37,58.05 v2(147.86,58.05) ; v2(197.86,142.31) R175.1 ; PC69.2 v2(216.79,155.37) ; v2(166.08,184.76) R120.1 ; v2(158.79,76.36) 158.86,76.44 CC59.2 ; v2(169.23,111.01) 169.21,110.99 C369.2 ; C185.2 v2(205.12,148.84) ; R312.2 v2(186.99,159.4) ; CC24.2 v2(188.98,55.4) ; v2(201.73,141.4) 201.73,141.91 C190.2 ; U7.4 165.98,153.45 165.67,153.76 v2(165.67,154.49) ; v2(148.9,22.07) 148.88,22.1 RD5.1 RD6.1 ; CD27.2 150.54,25.44 150.54,25.18 CD26.2 151.21,23.92 v2(150.85,23.55) ; v2(32.22,85.91) 32.22,85.36 CV2942.2 RV2714.2 ; v2(189.83,161.99) 189.5,162.32 C8.2 ; CC58.2 157.88,92.28 158.09,92.49 v2(158.09,92.84) ; v2(187.65,158.89) 187.42,158.66 R311.2 ; v2(191.46,153.68) 191.52,153.74 R25.2 C183.2 ; v3(169.82,94.86) RC152.1 RC156.1 ; v2(123.68,20.55) 123.47,20.55 123.06,20.13 123.06,19.23 CD11.2 ; CV3063.2 71.06,98.75 v5(71.51,99.2) ; v2(27.76,112.54) 28.25,113.03 CV2930.2 ; R92.2 170.15,161.71 v2(168.37,159.93) ; v2(178.5,172.63) 178.55,172.58 C27.2 C29.2 ; CC81.2 137.81,59.12 v2(138.41,59.12) ; 166.26,91.35 166.26,90.08 v2(166.64,89.7) ; v2(176.29,131.23) 175.66,130.59 R383.2 ; C395.2 155.42,131.69 v2(155.97,132.24) 156.01,132.28 C360.2 ; C355.2 165.78,133.31 v2(165.78,134.02) ; CC38.2 CC35.2 167.25,56.55 v2(167.25,56.56) ; CV234.2 64.72,103.41 v5(65.11,103.02) ; v2(32.9,83.58) 33.47,84.15 RV2907.1 ; CV2950.2 30.95,114.71 v2(31,114.76) ; v2(112.83,163.51) 113.06,163.74 PC410.2 ; v2(70.78,89.14) 70.12,89.8 CV3053.2 69.48,90.44 RV2435.2 ; CD55.2 v2(228.11,25.06) ; v2(130.51,78.5) 130.84,78.83 PC372.2 132.62,78.43 v2(133.31,78.43) ; C365.2 157.66,112.79 v2(158.21,112.79) 158.21,111.95 159.03,111.12 160.22,111.12 160.4,110.95 C340.2 ; PR452.2 PC435.2 111.29,140.16 v2(110.8,140.16) ; v2(153.69,120.18) 154.12,120.18 C356.2 ; CC82.2 v2(192.5,61.33) ; v2(128.26,135.9) 128.26,135.52 128.69,135.09 PU405.3 ; CC17.2 145.04,59.48 v2(144.5,59.48) ; v2(313.25,165.34) 313.53,165.62 C1189.2 ; v2(215.07,128.03) 215.08,128.04 C101.2 ; v2(167.8,113.48) 167.8,113.75 168.16,114.11 C349.2 C368.2 ; v2(125.96,126.94) 125.84,126.82 C441.2 ; RC156.1 170.7,94.65 v2(171.09,95.03) ; RC156.1 RC155.1 RC158.2 RC288.2 ; JKB1.11 v3(215.64,106.08) ; v5(53.12,96.94) 53.9,96.15 PC662.2 ; CC15.1 v2(169.05,57.77) ; v2(161.53,94.19) 160.94,94.19 CC79.2 ; v2(117.36,133.31) 116.92,133.75 PQ410.3 ; v2(220.84,45.45) 221.06,45.66 CC86.2 ; v2(162.86,141.34) 163.56,142.04 U41.2 ; C127.2 288.91,154.25 v2(288.76,154.39) ; v2(102.76,46.8) 102.6,46.64 CC11.2 ; v2(153.69,120.85) C345.2 ; CC27.2 161.27,76.45 v2(161.77,76.45) 162.73,76.45 CC31.2 ; R310.1 R313.1 193.95,115.02 v3(193.95,114.51) ; C378.2 150.66,105.23 v2(150.66,104.63) 150.66,104.06 C377.2 ; U5.3 230.47,26.63 230.64,26.45 R34.1 v2(230.64,24.9) ; C380.2 144.48,105.73 v2(144.37,105.63) ; PC508.2 155.89,158.33 v2(155.9,158.34) ; CD6.2 127.67,19.31 128.04,19.68 v2(128.3,19.68) ; v2(158.93,61.22) 159.45,60.7 RC159.2 ; v5(53.15,102.74) 53.29,102.88 CV101.2 ; v2(148.9,20.55) 149.02,20.55 149.36,20.89 CD28.2 CD29.2 ; v2(184.26,121.62) C339.2 ; v2(310.05,171.41) 310.05,171.56 309.29,172.32 JPWR1.12 ; 59.19,92.22 59.19,91.77 v5(59.82,91.14) ; CV2927.2 35.56,114.45 v2(36.08,114.97) ; v2(196.95,183.33) 196.9,183.38 C316.2 ; PR537.2 PR547.2 131.95,162.83 132.2,163.08 v2(132.2,163.41) ; v2(96.74,164.78) 97.18,164.34 JLVDS1.45 ; v2(14.65,105.98) 14.57,106.06 C87.2 ; v2(102.94,56.48) 102.61,56.81 CC68.2 ; C3030.1 v2(230.43,47.47) ; YV2401.4 v2(62.61,114.28) ; U22.1 v2(215.66,186.04) ; JMED1.8 v2(96.55,174.5) ; v2(304.36,159.75) 303.51,159.75 302.9,160.36 R2644.2 ; v2(222.25,59.44) C3022.2 ; Y1.2 190.24,155.79 v2(191.1,156.65) ; CV3052.2 v2(55.44,80.24) ; PR509.2 130.94,163.98 v2(131.44,163.49) ; C333.2 13.55,110.27 12.87,110.96 v2(12.87,111.59) ; C336.2 196.6,115.02 v3(195.72,115.02) ; CV2944.2 v2(36.47,85.05) ; v2(161.46,167.27) 160.78,167.95 Q133.3 160.57,167.78 158.92,167.78 158.51,167.37 C93.2 ; C186.2 205.36,150.69 v2(205.76,151.09) ; v2(66.97,111.39) 66.85,111.27 CV105.2 ; RC50.2 v2(170.07,57.77) ; v2(30.93,102.55) 30.82,102.44 CV2936.2 RV2909.1 ; PC669.2 64.62,101.02 v5(65.03,101.02) ; v2(224.95,58.66) 224.88,58.58 C3031.2 ; C363.2 v2(174.01,129.7) ; JFAN1.5 14.87,117.2 v2(14.22,117.85) ; C2980.2 335.46,161.49 334.63,162.33 v2(332.34,162.33) ; CV240.2 67.11,99.14 v2(67.34,99.38) 67.57,99.15 CV3062.2 ; v2(204.96,146.89) 204.89,146.82 204.85,146.82 C182.2 ; v2(125.8,119.54) R2583.1 ; C1187.2 215.41,37.65 v2(215.81,38.06) ; QZ5.1 v2(29.05,118.81) ; v2(94.89,143.75) 95.24,143.4 JLVDS1.42 ; CC77.2 155.16,105.98 155.13,106.01 155.13,106.23 v2(155.08,106.29) ; CC32.2 v2(194.28,65.95) ; v2(181.78,135.04) 181.78,134.88 181.93,134.74 CC84.2 ; RC287.2 173.12,99.43 v2(173.63,99.94) ; Y3.2 201.82,140.07 v2(201.6,140.28) C189.2 ; v2(205.02,144.41) 204.94,144.33 204.94,144.32 204.72,144.1 204.56,144.1 R185.2 ; PR56.1 v2(208.33,154.06) ; C328.2 183.79,131.36 v2(184.29,130.85) ; v2(117.98,24.1) 117.62,24.1 117.36,24.36 117.36,25.62 CD17.2 ; CV88.2 61.67,93.28 CV3048.2 ; CE11.2 107.2,163.6 H37.1 ; PQ527.3 150.4,164.94 v2(150.9,165.44) ; v2(207.58,155.96) PR53.1 PR55.2 ; v2(167.28,133.39) 167.15,133.26 R366.1 R373.1 ; C443.2 115.08,114.24 115.66,113.65 v2(116.27,113.65) ; v2(61.73,102.32) 61.3,102.74 PC671.2 ; C645.2 84.98,13.8 v2(84.98,13.63) ; v2(164.27,28) 163.56,28.71 161.55,28.71 160.87,28.02 CD33.2 CD32.2 ; JAPS1.20 228.84,83.19 v2(229.38,83.73) ; v2(149.48,154) 149.31,153.82 PQ521.3 ; v2(167.21,79.96) 167.2,79.96 CC74.2 ; PC673.2 56.77,98.3 v2(56.78,98.31) ; JKB1.12 199.04,107.68 v2(198.99,107.63) ; CE9.2 185.99,177.3 v2(186.54,177.85) ; JTS1.7 v2(96.14,173.66) ; RC189.2 v2(201.64,129.73) ; JTS1.5 97.19,170.29 v2(96.79,169.89) ; CC26.2 153.05,69.84 153.39,69.5 v2(153.57,69.5) ; v2(296.23,159.63) 296.31,159.7 C2962.2 ; PQ411.3 134.74,134.52 v3(133.92,135.33) ; v2(161.34,77.99) 161.34,78.62 CC29.2 ; R354.1 v2(201.36,123.99) ; R2585.2 127.75,122.39 v2(128.01,122.13) ; PC670.2 56.79,99.32 v2(56.78,99.33) ; CC6.2 150.32,92.56 149.88,93 v2(149.75,93) 149.45,92.7 CC7.2 ; v3(210.11,81.88) 207.57,81.88 207.17,82.28 JBIO1.7 206.31,81.93 207.08,81.16 v3(210.23,81.16) ; v2(131.98,69.22) 132.27,69.51 RC125.2 ; v2(150.35,80.85) 150.18,80.67 150.18,79.36 PC366.2 ; JLVDS1.43 95.24,151.24 v3(96.16,152.16) ; v2(225.49,44.33) CC85.2 ; JTS1.4 97.31,169.49 96.89,169.07 v2(96.82,169.07) ; C3024.2 v2(219.6,53.66) ; C444.2 v2(116.22,114.34) ; v2(181.88,120.73) C329.2 R307.1 ; JKB1.3 v2(210.64,105.65) ; v2(123.08,137.18) 122.55,137.18 PR444.2 PC431.2 ; v2(187.09,53.5) 186.89,53.3 RC2.2 ; v2(144.34,108.19) 144.59,108.44 C459.1 ; RC237.2 161.04,56.31 v2(161.48,56.76) ; CV2961.2 26.67,83.83 26.99,83.5 v2(28.21,83.5) ; C633.2 86.38,14.01 v2(85.87,13.5) ; v2(216.81,115.48) 217.31,115.99 217.57,115.99 ; v2(217.22,47.63) 217.57,47.28 C3023.2 ; C3032.2 v2(225.59,56.97) ; C332.2 C334.2 182.68,128.49 R321.2 182.52,129.57 v2(182.05,129.57) ; CD10.2 116.72,26 116.72,24.42 116.41,24.1 v2(116.1,24.1) ; v2(145,134.12) 145.49,134.12 146.1,133.52 146.1,132.85 145.74,132.49 PQ528.3 ; C147.2 270.1,176.69 v2(270.19,176.6) ; v2(27.57,114.69) 27.57,114.63 28.14,114.06 CV2949.2 ; U29.1 v2(228.87,42.2) ; v2(98.04,21.31) 98.63,21.31 99.26,20.68 JEXP1.41 ; CD23.2 v2(228.11,27.67) ; C3034.2 226.28,44.86 v2(226.28,44.03) ; C257.2 321.93,184.84 C262.2 321.93,186.68 v2(321.91,186.7) ; v2(158.18,76.39) 158.18,76.91 CC63.2 ; v2(115.32,141.74) PR451.2 ; C3033.2 227.33,44.6 v2(226.97,44.23) ; JTS1.8 v2(94.93,165.79) ; R305.1 185.06,133.01 185.4,133.35 186.36,133.35 186.76,133.74 v2(187.19,133.74) ; C73.2 158.44,108.03 158.44,106.69 v2(158.61,106.52) 159.01,106.52 159.4,106.13 C3.2 ; v2(155.97,120.97) 156.81,120.97 C353.2 R370.2 ; C252.2 C250.2 240.97,142.77 v2(240.88,142.86) ; C442.2 v2(125.57,125.74) ; RV2715.2 30.48,97.49 v2(30.48,96.79) ; v2(59.83,104.82) 59.22,105.42 PC665.2 ; C2963.2 295.42,159.78 v2(295.58,159.61) ; PC661.2 55.03,100.95 v5(55.64,100.34) ; C202.2 183.4,132.85 v2(183.15,132.6) ; PC439.2 122.32,133.72 122.47,133.57 122.47,133.56 v2(122.52,133.51) ; CV236.2 66.7,103.02 v2(67.26,103.58) ; v3(136.59,80.35) 136.59,79.34 PC374.2 135.31,80.01 v2(135.31,80.85) ; v2(200.03,85.08) 200.1,85.15 C268.2 ; v2(158.29,113.77) 158.96,113.77 159.26,114.06 C342.2 159.33,114.45 C344.2 ; RC236.1 163.72,91.86 163.97,91.86 v2(164.1,91.73) ; C399.2 186.51,111.07 v3(186.43,111) ; v2(224.6,126.76) 224.83,126.53 SW5.4 ; RC32.2 v2(114.57,118.07) ; JMED1.7 94.83,182.9 v2(94.5,183.22) ; C265.2 v2(258.08,185.15) ; CC55.2 156.96,98.94 v2(156.96,98.28) ; PC429.2 114.17,133.87 v2(114.49,133.55) 114.81,133.55 115.06,133.8 PC428.2 ; PD5.2 v2(130.45,137.42) ; C43.2 v2(186.43,155.78) ; R308.1 R320.1 v2(201.36,127.04) ; v2(202.25,59.08) 202.5,59.33 CC22.2 ; CV2921.2 24.9,96.4 v2(24.9,96.76) ; v2(23.67,117.59) 23.02,116.94 JFAN1.6 ; CV104.2 63.26,111.27 62.93,110.93 62.93,110.46 v2(62.85,110.38) 62.8,110.33 RV2444.1 ; CD54.2 v2(228.11,24.17) ; DE1.1 233.88,131.58 v2(233.54,131.91) ; v2(16.88,87.11) 17.2,87.11 17.7,86.61 C291.2 ; CV3057.2 v2(55.76,86.69) ; v2(139.2,59.5) 139.2,58.95 CC52.2 ; CV228.2 55.33,99.19 v5(55.57,98.95) 55.33,98.71 CV100.2 ; v2(193.44,133.13) 193.44,132.88 193.61,132.71 R326.2 R303.1 ; JAPS1.19 229.15,70.49 v2(229.53,70.88) ; CV89.2 v5(57.34,93.58) ; RC78.1 187.26,59.12 187.7,59.55 187.98,59.55 v2(188.36,59.93) ; C404.2 v2(206.82,150.05) ; CV2943.2 35.09,96.83 v2(35.09,96.53) ; R394.2 C367.2 176.01,115.61 176.27,115.86 v2(176.27,116.27) ; D27.1 306.75,165.65 v2(306.16,165.65) ; v2(216.81,119.86) 217.13,119.54 U34.1 ; v2(137.22,155.58) 136.78,155.14 PR556.2 ; RC83.2 v2(103.9,12.36) ; v2(228.01,46.19) 228.23,46.41 R2689.2 ; v2(174.77,103.19) 174.67,103.29 CC62.2 ; v3(291.38,162.69) 291.38,161 291.56,160.82 C2964.2 ; v2(21.94,110.73) 21.94,111.17 21.53,111.58 21.15,111.58 20.82,111.25 JFAN1.4 ; v2(164.79,101.15) 164.58,101.36 C391.2 ; C351.2 v2(171.64,132.7) ; PQ3.3 v2(125.67,137.74) ; v5(61.16,104.45) 60.93,104.45 60.45,104.93 CV103.2 ; C184.2 203.4,144.25 v2(203.17,144.49) ; C177.2 v2(197.65,140.27) ; v2(121.99,140.25) 122.25,139.98 PC432.2 ; v2(121.51,19.79) 120.94,19.22 CD20.2 ; v2(160.61,110.02) 160.28,109.69 C207.2 ; v2(186.86,160.79) 186.99,160.92 R351.2 ; PR19.2 v2(100.35,175) ; R2695.1 v2(217.44,50.96) ; C371.2 v2(172.48,133.39) ; v5(60.79,99.35) 61.09,99.65 PC664.2 ; RC115.2 119.17,73.06 118.9,72.8 118.9,71.58 v2(119.12,71.36) ; v2(201.37,56.25) 201.37,55.85 201.67,55.56 202.78,55.56 CC80.1 ; v2(256.88,181.64) 257.14,181.9 C266.2 ; PC68.2 v2(216.79,151.1) ; CD7.2 122.44,24.36 122.7,24.1 v2(123.12,24.1) ; CV2929.2 27.72,101.83 v2(27.04,102.52) ; v2(104.31,141.52) 103.8,141.01 C430.2 ; R2705.2 187.37,157.9 187.42,157.9 v2(187.6,158.08) ; C3027.2 227.86,47.71 v2(227.85,47.71) ; R2577.1 v2(168.93,94.83) ; v2(184.29,132.75) C384.2 ; v2(111.62,24.1) 112.05,24.1 112.28,24.34 CD4.2 ; v2(145.78,149.06) PC500.1 ; PQ514.3 v2(153.72,154.09) ; RC85.2 RC305.1 176.54,97.66 176.54,97.82 v2(177.05,98.34) ; CD19.2 126.51,19.93 125.88,20.55 v2(125.21,20.55) ; C15.2 181.16,166.78 181.14,166.78 181.06,166.71 v2(180.71,166.71) 180.66,166.76 C9.2 C11.2 180.67,169.44 C13.2 ; C426.2 v2(217.1,182.77) ; D87.1 208.96,169.2 v2(207.64,167.88) ; C319.2 v2(198.87,174.94) ; v2(29.36,85.87) CV2966.2 ; C437.2 126.1,123.51 v2(126.41,123.51) ; v2(139.08,133.29) 139.96,134.16 PQ529.3 ; v2(95.37,139.58) 96.4,138.55 JLVDS1.41 ; Y1.4 188.54,153.94 v2(189.3,154.7) ; v2(116.01,147.01) PU403.4 ; v2(26.67,86.12) CV2964.2 ; 188.84,97.01 v2(188.61,97.01) ; C188.2 v2(207.41,147.32) ; R2581.2 v2(138.75,112.2) ; C348.2 v2(171.09,139.86) ; v2(118.13,140.41) PU404.4 ; v2(57.5,105.23) CV231.2 ; CV2918.2 40.78,112.54 v2(41.16,112.15) ; CC78.2 v2(156.51,95.77) ; C482.2 v2(336.95,174.79) ; C436.2 v2(110.68,125.06) ; C434.2 v2(120.92,116.83) ; PR405.2 v2(120.15,146.04)
  GND1 w0.203: H18.1 343.42,185.08 ; H18.1 341.9,188.68 ; H18.1 340.38,185.08 ; H18.1 340.38,188.12 ; H18.1 343.42,188.12 ; H18.1 341.9,184.52 ; H18.1 339.82,186.6 ; H18.1 343.98,186.6 ; 3.46,88.45 JUSB1.11 ; JUSB1.11 4.84,89.33 ; JUSB1.11 6.21,88.45 ; JUSB1.11 3.46,89.33 ; JUSB1.11 6.21,89.33 ; 109.02,185.3 PBATT2.2 ; PBATT2.2 109.22,185.97 ; PBATT2.2 110.57,184.63 ; PBATT2.2 109.89,186.18 ; PBATT2.2 110.77,185.3 ; PBATT2.2 110.57,185.97 ; PBATT2.2 109.89,184.42 ; PBATT2.2 109.22,184.63 ; JDOCK1.164 210.26,185.51 ; JDOCK1.164 206.14,184.53 ; JDOCK1.164 208.2,183.55 ; JDOCK1.164 210.26,183.55 ; JDOCK1.164 206.14,183.55 ; JDOCK1.164 206.14,185.51 ; JDOCK1.164 210.26,184.53 ; JDOCK1.164 208.2,185.51 ; 101.98,115.95 H11.1 ; H11.1 100.05,117.88 ; H11.1 101.98,119.81 ; H11.1 103.91,117.88 ; H11.1 100.56,119.3 ; H11.1 100.56,116.46 ; H11.1 103.4,119.3 ; H11.1 103.4,116.46 ; 40.7,76.06 H5.1 ; H5.1 42.4,76.7 ; H5.1 42.4,72.02 ; H5.1 44.1,76.06 ; H5.1 40.7,72.66 ; H5.1 40.06,74.36 ; H5.1 44.74,74.36 ; H5.1 44.1,72.66 ; H15.1 233.62,66.92 ; H15.1 234.13,65.5 ; H15.1 232.2,63.57 ; H15.1 230.78,64.08 ; H15.1 230.78,66.92 ; H15.1 230.27,65.5 ; H15.1 233.62,64.08 ; H15.1 232.2,67.43 ; 285.57,164.42 H26.1 ; H26.1 286.35,166.23 ; H26.1 285.57,165.98 ; H26.1 285.32,165.2 ; H26.1 287.38,165.2 ; H26.1 287.13,165.98 ; H26.1 286.35,164.17 ; H26.1 287.13,164.42 ; 9.49,106.71 JHDMI1.17 ; JHDMI1.17 9.37,106.25 ; JHDMI1.17 10.41,106.71 ; JHDMI1.17 9.49,105.79 ; JHDMI1.17 10.41,105.79 ; JHDMI1.17 10.53,106.25 ; 161.14,184.53 JDOCK1.161 ; JDOCK1.161 165.26,183.55 ; JDOCK1.161 161.14,183.55 ; JDOCK1.161 165.26,185.51 ; JDOCK1.161 163.2,183.55 ; JDOCK1.161 163.2,185.51 ; JDOCK1.161 165.26,184.53 ; JDOCK1.161 161.14,185.51 ; 89.98,60.49 H24.1 ; H24.1 90.76,62.3 ; H24.1 89.98,62.55 ; H24.1 90.76,60.74 ; H24.1 89.2,60.74 ; H24.1 91.01,61.52 ; H24.1 88.95,61.52 ; H24.1 89.2,62.3 ; 174.76,87.13 H3.1 ; H3.1 176.67,87.85 ; H3.1 178.58,87.13 ; H3.1 179.3,85.22 ; H3.1 174.76,83.31 ; H3.1 174.04,85.22 ; H3.1 176.67,82.59 ; H3.1 178.58,83.31 ; JUSB1.13 13.71,73.63 ; JUSB1.13 10.16,72.75 ; JUSB1.13 13.71,72.75 ; JUSB1.13 13.71,71.87 ; JUSB1.13 11.94,71.87 ; JUSB1.13 10.16,71.87 ; JDOCK1.158 180.76,180.6 ; JDOCK1.158 179.7,181.66 ; JDOCK1.158 180.5,181.4 ; JDOCK1.158 178.9,181.4 ; JDOCK1.158 178.9,179.81 ; JDOCK1.158 178.65,180.6 ; JHDMI1.20 12.93,96.43 ; JHDMI1.20 10.37,96.43 ; JHDMI1.20 12.93,94.57 ; JHDMI1.20 10.37,95.5 ; JHDMI1.20 12.93,95.5 ; JHDMI1.20 10.37,94.57 ; JHDMI1.20 11.65,96.43 ; JHDMI1.20 11.65,94.57 ; JDOCK1.145 162.58,180.6 ; JDOCK1.145 161.53,182.58 ; JDOCK1.145 162.58,178.62 ; JDOCK1.145 160.47,180.6 ; JDOCK1.145 161.53,178.62 ; JDOCK1.145 162.58,182.58 ; JDOCK1.145 160.47,178.62 ; JDOCK1.145 160.47,182.58 ; 236,42.87 JSATA2.15 ; JSATA2.15 238.8,42.09 ; JSATA2.15 238.8,43.64 ; JSATA2.15 238.8,42.87 ; JSATA2.15 236,43.64 ; JSATA2.15 237.4,43.64 ; JSATA2.15 237.4,42.09 ; JSATA2.15 236,42.09 ; H10.1 6.12,119.75 ; H10.1 4.7,119.24 ; H10.1 7.54,116.4 ; H10.1 8.05,117.82 ; H10.1 4.7,116.4 ; H10.1 7.54,119.24 ; H10.1 6.12,115.89 ; H10.1 4.19,117.82 ; H16.1 11.8,4.93 ; H16.1 13.22,4.42 ; H16.1 9.87,3 ; H16.1 11.8,1.07 ; H16.1 10.38,4.42 ; H16.1 10.38,1.58 ; H16.1 13.73,3 ; H16.1 13.22,1.58 ; H36.1 212.72,64.26 ; H36.1 214.24,60.66 ; H36.1 214.8,62.18 ; H36.1 211.2,60.66 ; H36.1 211.2,63.7 ; H36.1 212.72,60.1 ; H36.1 214.24,63.7 ; H36.1 210.64,62.18 ; 190.9,179.81 JDOCK1.159 ; JDOCK1.159 192.5,179.81 ; JDOCK1.159 192.5,181.4 ; JDOCK1.159 190.9,181.4 ; JDOCK1.159 191.7,181.66 ; JDOCK1.159 191.7,179.55 ; JDOCK1.159 190.65,180.6 ; JDOCK1.159 192.76,180.6 ; 209.88,178.62 JDOCK1.152 ; JDOCK1.152 208.82,178.62 ; JDOCK1.152 210.93,182.58 ; JDOCK1.152 210.93,178.62 ; JDOCK1.152 210.93,180.6 ; JDOCK1.152 209.88,182.58 ; JDOCK1.152 208.82,182.58 ; JDOCK1.152 208.82,180.6 ; PBATT2.11 105.82,185.3 ; PBATT2.11 105.82,183.29 ; PBATT2.11 104.77,183.29 ; PBATT2.11 103.72,183.29 ; PBATT2.11 103.72,185.3 ; JDOCK1.157 168.5,179.81 ; JDOCK1.157 166.65,180.6 ; JDOCK1.157 167.7,179.55 ; JDOCK1.157 168.76,180.6 ; JDOCK1.157 166.9,179.81 ; JDOCK1.157 167.7,181.66 ; JDOCK1.157 166.9,181.4 ; JDOCK1.157 168.5,181.4 ; 10.37,110 JHDMI1.21 ; JHDMI1.21 11.65,110.93 ; JHDMI1.21 10.37,110.93 ; JHDMI1.21 11.65,109.07 ; JHDMI1.21 12.93,110 ; JHDMI1.21 10.37,109.07 ; JHDMI1.21 12.93,109.07 ; JHDMI1.21 12.93,110.93 ; JUSB1.10 13.71,88.45 ; JUSB1.10 13.71,87.57 ; JUSB1.10 10.16,89.33 ; JUSB1.10 10.16,88.45 ; JUSB1.10 13.71,89.33 ; JUSB1.10 11.94,89.33 ; JDOCK1.154 179.7,177.66 ; JDOCK1.154 178.65,177.66 ; JDOCK1.154 178.65,175.7 ; JDOCK1.154 178.65,176.68 ; JDOCK1.154 180.76,176.68 ; JDOCK1.154 179.7,175.7 ; JDOCK1.154 180.76,175.7 ; 106.7,162.02 H37.1 ; H37.1 108.22,162.58 ; H37.1 108.78,164.1 ; H37.1 106.7,166.18 ; H37.1 105.18,165.62 ; H37.1 105.18,162.58 ; H37.1 108.22,165.62 ; H37.1 104.62,164.1 ; JHDMI1.5 10.41,100.71 ; JHDMI1.5 9.49,99.79 ; JHDMI1.5 10.53,100.25 ; JHDMI1.5 9.49,100.71 ; JHDMI1.5 10.41,99.79 ; JHDMI1.5 9.37,100.25 ; H19.1 335.98,149.1 ; H19.1 335.42,150.62 ; H19.1 335.42,147.58 ; H19.1 333.9,151.18 ; H19.1 332.38,150.62 ; H19.1 332.38,147.58 ; H19.1 333.9,147.02 ; H19.1 331.82,149.1 ; H28.1 6.3,4.68 ; H28.1 6.3,1.32 ; H28.1 8.48,4.68 ; H28.1 8.48,1.32 ; H28.1 8.48,3 ; H40.1 80.99,142.31 ; H40.1 80.99,139.47 ; H40.1 78.15,139.47 ; H40.1 77.64,140.89 ; H40.1 79.57,138.96 ; H40.1 81.5,140.89 ; H40.1 78.15,142.31 ; H40.1 79.57,142.82 ; 12.82,79.93 JUSB1.7 ; JUSB1.7 13.49,80.6 ; JUSB1.7 13.34,81.13 ; JUSB1.7 12.82,81.27 ; JUSB1.7 13.34,80.07 ; 174.76,63.31 H4.1 ; H4.1 178.58,63.31 ; H4.1 174.76,67.13 ; H4.1 179.3,65.22 ; H4.1 176.67,62.59 ; H4.1 178.58,67.13 ; H4.1 176.67,67.85 ; H4.1 174.04,65.22 ; 230.48,107.18 H12.1 ; H12.1 231.9,110.53 ; H12.1 230.48,110.02 ; H12.1 233.31,107.18 ; H12.1 233.31,110.02 ; H12.1 231.9,106.67 ; H12.1 233.83,108.6 ; H12.1 229.97,108.6 ; H20.1 188.2,4.93 ; H20.1 186.78,4.42 ; H20.1 189.62,4.42 ; H20.1 186.27,3 ; H20.1 189.62,1.58 ; H20.1 190.13,3 ; H20.1 186.78,1.58 ; H20.1 188.2,1.07 ; JDOCK1.155 192.76,176.68 ; JDOCK1.155 192.76,177.66 ; JDOCK1.155 190.65,176.68 ; JDOCK1.155 190.65,175.7 ; JDOCK1.155 191.7,175.7 ; JDOCK1.155 192.76,175.7 ; JDOCK1.155 191.7,177.66 ; JDOCK1.155 190.65,177.66 ; 82.23,179.78 H22.1 ; H22.1 83.91,182.21 ; H22.1 82.23,184.64 ; H22.1 83.91,179.78 ; H22.1 83.91,184.64 ; 83.23,163.17 H7.1 ; H7.1 81.81,166.52 ; H7.1 84.65,163.68 ; H7.1 81.3,165.1 ; H7.1 83.23,167.03 ; H7.1 84.65,166.52 ; H7.1 85.16,165.1 ; H7.1 81.81,163.68 ; 230.78,9.09 H17.1 ; H17.1 233.62,11.93 ; H17.1 232.2,8.58 ; H17.1 233.62,9.09 ; H17.1 232.2,12.44 ; H17.1 230.78,11.93 ; H17.1 234.13,10.51 ; H17.1 230.27,10.51 ; 2.17,94.53 JHDMI1.22 ; JHDMI1.22 3.45,94.53 ; JHDMI1.22 3.45,92.67 ; JHDMI1.22 4.73,93.6 ; JHDMI1.22 4.73,94.53 ; JHDMI1.22 2.17,93.6 ; JHDMI1.22 2.17,92.67 ; JHDMI1.22 4.73,92.67 ; H9.1 187.55,65.85 ; H9.1 184.71,65.85 ; H9.1 186.13,69.2 ; H9.1 187.55,68.69 ; H9.1 184.71,68.69 ; H9.1 184.2,67.27 ; H9.1 188.06,67.27 ; H9.1 186.13,65.34 ; JUSB1.4 14.99,77.1 ; JUSB1.4 13.79,76.57 ; JUSB1.4 14.84,77.63 ; JUSB1.4 13.79,77.63 ; JUSB1.4 14.32,77.77 ; JUSB1.4 14.32,76.43 ; JUSB1.4 14.84,76.57 ; JUSB1.4 13.64,77.1 ; 79.04,17.51 H25.1 ; H25.1 80.6,19.07 ; H25.1 79.82,17.26 ; H25.1 80.85,18.29 ; H25.1 80.6,17.51 ; H25.1 78.79,18.29 ; H25.1 79.04,19.07 ; H25.1 79.82,19.32 ; 127.02,183.29 PBATT2.10 ; PBATT2.10 125.96,185.3 ; PBATT2.10 125.96,183.29 ; H27.1 325.81,161.13 ; H27.1 326.58,160.88 ; H27.1 326.83,160.11 ; H27.1 325.03,159.33 ; H27.1 325.81,159.08 ; H27.1 324.78,160.11 ; H27.1 326.58,159.33 ; H27.1 325.03,160.88 ; 110.67,82.59 H1.1 ; H1.1 112.58,83.31 ; H1.1 108.76,83.31 ; H1.1 113.3,85.22 ; H1.1 110.67,87.85 ; H1.1 108.76,87.13 ; H1.1 108.04,85.22 ; H1.1 112.58,87.13 ; 228.28,179.37 H14.1 ; H14.1 231.63,177.95 ; H14.1 231.12,176.53 ; H14.1 227.77,177.95 ; H14.1 229.7,179.88 ; H14.1 229.7,176.02 ; H14.1 228.28,176.53 ; H14.1 231.12,179.37 ; H13.1 31.62,72.52 ; H13.1 28.27,71.1 ; H13.1 28.78,69.68 ; H13.1 32.13,71.1 ; H13.1 30.2,73.03 ; H13.1 31.62,69.68 ; H13.1 28.78,72.52 ; H13.1 30.2,69.17 ; 11.04,98.29 JHDMI1.2 ; JHDMI1.2 11.04,99.21 ; JHDMI1.2 11.96,99.21 ; JHDMI1.2 10.92,98.75 ; JHDMI1.2 11.96,98.29 ; JHDMI1.2 12.08,98.75 ; JHDMI1.2 11.5,98.17 ; JSATA2.14 238.8,20.32 ; JSATA2.14 238.8,19.54 ; JSATA2.14 238.8,21.09 ; JSATA2.14 237.4,21.09 ; JSATA2.14 236,21.09 ; JSATA2.14 236,19.54 ; JSATA2.14 236,20.32 ; JSATA2.14 237.4,19.54 ; 178.65,183.55 JDOCK1.162 ; JDOCK1.162 179.7,185.51 ; JDOCK1.162 178.65,184.53 ; JDOCK1.162 178.65,185.51 ; JDOCK1.162 180.76,183.55 ; JDOCK1.162 180.76,184.53 ; JDOCK1.162 180.76,185.51 ; JDOCK1.162 179.7,183.55 ; 113.22,185.97 PBATT2.4 ; PBATT2.4 113.89,186.18 ; PBATT2.4 114.57,185.97 ; PBATT2.4 113.22,184.63 ; PBATT2.4 114.77,185.3 ; PBATT2.4 113.02,185.3 ; PBATT2.4 114.57,184.63 ; PBATT2.4 113.89,184.42 ; H2.1 110.67,67.56 ; H2.1 112.38,63.52 ; H2.1 108.97,63.52 ; H2.1 113.01,65.22 ; H2.1 110.67,62.89 ; H2.1 112.38,66.93 ; H2.1 108.33,65.22 ; H2.1 108.97,66.93 ; 141.7,176.02 H8.1 ; H8.1 141.7,179.88 ; H8.1 139.77,177.95 ; H8.1 143.12,176.53 ; H8.1 143.12,179.37 ; H8.1 140.28,176.53 ; H8.1 140.28,179.37 ; H8.1 143.63,177.95 ; JHDMI1.8 12.08,101.75 ; JHDMI1.8 11.96,101.29 ; JHDMI1.8 10.92,101.75 ; JHDMI1.8 11.04,102.21 ; JHDMI1.8 11.04,101.29 ; JHDMI1.8 11.96,102.21 ; 161.14,175.7 JDOCK1.153 ; JDOCK1.153 161.14,176.68 ; JDOCK1.153 163.2,175.7 ; JDOCK1.153 161.14,177.66 ; JDOCK1.153 165.26,176.68 ; JDOCK1.153 165.26,177.66 ; JDOCK1.153 165.26,175.7 ; JDOCK1.153 163.2,177.66 ; 107.22,184.63 PBATT2.1 ; PBATT2.1 107.89,186.18 ; PBATT2.1 108.57,185.97 ; PBATT2.1 108.77,185.3 ; PBATT2.1 107.89,184.42 ; PBATT2.1 107.22,185.97 ; PBATT2.1 107.02,185.3 ; PBATT2.1 108.57,184.63 ; JDOCK1.156 210.26,175.7 ; JDOCK1.156 206.14,175.7 ; JDOCK1.156 208.2,175.7 ; JDOCK1.156 210.26,176.68 ; JDOCK1.156 206.14,177.66 ; JDOCK1.156 208.2,177.66 ; JDOCK1.156 210.26,177.66 ; JDOCK1.156 206.14,176.68 ; 190.65,183.55 JDOCK1.163 ; JDOCK1.163 192.76,183.55 ; JDOCK1.163 192.76,184.53 ; JDOCK1.163 190.65,184.53 ; JDOCK1.163 191.7,185.51 ; JDOCK1.163 190.65,185.51 ; JDOCK1.163 192.76,185.51 ; JDOCK1.163 191.7,183.55 ; 231.72,103.31 H21.1 ; H21.1 236.58,101.64 ; H21.1 231.72,101.64 ; H21.1 234.15,103.31 ; H21.1 236.58,99.96 ; H21.1 231.72,99.96 ; H21.1 234.15,99.96 ; H21.1 236.58,103.31 ; 203.7,179.55 JDOCK1.160 ; JDOCK1.160 202.9,179.81 ; JDOCK1.160 204.76,180.6 ; JDOCK1.160 202.65,180.6 ; JDOCK1.160 204.5,179.81 ; JDOCK1.160 204.5,181.4 ; JDOCK1.160 202.9,181.4 ; JSATA1.23 219.78,97.35 ; JSATA1.23 219.33,96.09 ; JSATA1.23 216.81,96.09 ; JSATA1.23 219.33,98.61 ; JSATA1.23 216.81,98.61 ; JSATA1.23 218.07,99.07 ; JSATA1.23 218.07,95.64 ; JSATA1.23 216.35,97.35 ; JHDMI1.23 3.48,110.97 ; JHDMI1.23 2.2,112.83 ; JHDMI1.23 2.2,110.97 ; JHDMI1.23 3.48,112.83 ; JHDMI1.23 3.48,111.9 ; JHDMI1.11 10.53,103.25 ; JHDMI1.11 9.37,103.25 ; JHDMI1.11 9.49,103.71 ; JHDMI1.11 9.49,102.79 ; JHDMI1.11 10.41,102.79 ; JHDMI1.11 10.41,103.71 ; H6.1 79.49,123.42 ; H6.1 80.21,125.33 ; H6.1 77.58,122.7 ; H6.1 75.67,127.24 ; H6.1 75.67,123.42 ; H6.1 79.49,127.24 ; H6.1 74.95,125.33 ; H6.1 77.58,127.96 ; 17.42,69.88 H23.1 ; H23.1 18.98,69.88 ; H23.1 17.17,69.1 ; H23.1 18.2,70.13 ; H23.1 19.23,69.1 ; H23.1 18.2,68.07 ; H23.1 18.98,68.32 ; H23.1 17.42,68.32 ; 218.07,145.24 JSATA1.24 ; JSATA1.24 216.81,145.69 ; JSATA1.24 218.07,148.67 ; JSATA1.24 216.81,148.21 ; JSATA1.24 216.35,146.95 ; JSATA1.24 219.78,146.95 ; JSATA1.24 219.33,148.21 ; JSATA1.24 219.33,145.69 ; 4.84,71.87 JUSB1.12 ; JUSB1.12 6.21,72.75 ; JUSB1.12 3.46,72.75 ; JUSB1.12 6.21,71.87 ; JUSB1.12 3.46,71.87
  GND2 w0.203: 125.96,185.3 PBATT2.10 ; PBATT2.10 125.96,183.29 ; PBATT2.10 127.02,183.29 ; 232.2,8.58 H17.1 ; H17.1 230.27,10.51 ; H17.1 233.62,9.09 ; H17.1 232.2,12.44 ; H17.1 234.13,10.51 ; H17.1 230.78,9.09 ; H17.1 233.62,11.93 ; H17.1 230.78,11.93 ; 211.2,63.7 H36.1 ; H36.1 214.24,60.66 ; H36.1 214.24,63.7 ; H36.1 212.72,60.1 ; H36.1 212.72,64.26 ; H36.1 210.64,62.18 ; H36.1 214.8,62.18 ; H36.1 211.2,60.66 ; H24.1 90.76,60.74 ; H24.1 89.98,60.49 ; H24.1 88.95,61.52 ; H24.1 89.2,60.74 ; H24.1 89.2,62.3 ; H24.1 89.98,62.55 ; H24.1 90.76,62.3 ; H24.1 91.01,61.52 ; JUSB1.7 13.34,81.13 ; JUSB1.7 13.34,80.07 ; JUSB1.7 12.82,79.93 ; JUSB1.7 13.49,80.6 ; JUSB1.7 12.82,81.27 ; JUSB1.4 14.84,77.63 ; JUSB1.4 13.79,77.63 ; JUSB1.4 14.32,76.43 ; JUSB1.4 14.32,77.77 ; JUSB1.4 13.79,76.57 ; JUSB1.4 13.64,77.1 ; JUSB1.4 14.99,77.1 ; JUSB1.4 14.84,76.57 ; JDOCK1.160 204.5,179.81 ; JDOCK1.160 204.76,180.6 ; JDOCK1.160 203.7,179.55 ; JDOCK1.160 202.9,179.81 ; JDOCK1.160 202.65,180.6 ; JDOCK1.160 202.9,181.4 ; JDOCK1.160 204.5,181.4 ; JUSB1.13 13.71,72.75 ; JUSB1.13 13.71,73.63 ; JUSB1.13 10.16,72.75 ; JUSB1.13 11.94,71.87 ; JUSB1.13 10.16,71.87 ; JUSB1.13 13.71,71.87 ; H11.1 103.4,116.46 ; H11.1 101.98,119.81 ; H11.1 103.91,117.88 ; H11.1 103.4,119.3 ; H11.1 100.05,117.88 ; H11.1 101.98,115.95 ; H11.1 100.56,119.3 ; H11.1 100.56,116.46 ; 11.04,101.29 JHDMI1.8 ; JHDMI1.8 11.04,102.21 ; JHDMI1.8 10.92,101.75 ; JHDMI1.8 12.08,101.75 ; JHDMI1.8 11.96,101.29 ; JHDMI1.8 11.96,102.21 ; 78.15,142.31 H40.1 ; H40.1 77.64,140.89 ; H40.1 78.15,139.47 ; H40.1 79.57,142.82 ; H40.1 79.57,138.96 ; H40.1 80.99,142.31 ; H40.1 81.5,140.89 ; H40.1 80.99,139.47 ; H25.1 80.6,17.51 ; H25.1 78.79,18.29 ; H25.1 80.6,19.07 ; H25.1 79.82,19.32 ; H25.1 80.85,18.29 ; H25.1 79.82,17.26 ; H25.1 79.04,17.51 ; H25.1 79.04,19.07 ; H16.1 13.73,3 ; H16.1 11.8,4.93 ; H16.1 9.87,3 ; H16.1 11.8,1.07 ; H16.1 10.38,4.42 ; H16.1 13.22,4.42 ; H16.1 10.38,1.58 ; H16.1 13.22,1.58 ; H20.1 189.62,1.58 ; H20.1 186.78,4.42 ; H20.1 188.2,1.07 ; H20.1 189.62,4.42 ; H20.1 190.13,3 ; H20.1 188.2,4.93 ; H20.1 186.27,3 ; H20.1 186.78,1.58 ; H7.1 84.65,166.52 ; H7.1 83.23,167.03 ; H7.1 83.23,163.17 ; H7.1 81.3,165.1 ; H7.1 81.81,166.52 ; H7.1 84.65,163.68 ; H7.1 81.81,163.68 ; H7.1 85.16,165.1 ; 166.65,180.6 JDOCK1.157 ; JDOCK1.157 168.5,181.4 ; JDOCK1.157 167.7,179.55 ; JDOCK1.157 167.7,181.66 ; JDOCK1.157 166.9,181.4 ; JDOCK1.157 166.9,179.81 ; JDOCK1.157 168.5,179.81 ; JDOCK1.157 168.76,180.6 ; 190.65,176.68 JDOCK1.155 ; JDOCK1.155 191.7,177.66 ; JDOCK1.155 190.65,177.66 ; JDOCK1.155 192.76,175.7 ; JDOCK1.155 192.76,177.66 ; JDOCK1.155 190.65,175.7 ; JDOCK1.155 191.7,175.7 ; JDOCK1.155 192.76,176.68 ; 11.5,98.17 JHDMI1.2 ; JHDMI1.2 11.04,98.29 ; JHDMI1.2 11.96,98.29 ; JHDMI1.2 10.92,98.75 ; JHDMI1.2 11.96,99.21 ; JHDMI1.2 11.04,99.21 ; JHDMI1.2 12.08,98.75 ; 108.33,65.22 H2.1 ; H2.1 108.97,66.93 ; H2.1 110.67,67.56 ; H2.1 112.38,66.93 ; H2.1 108.97,63.52 ; H2.1 110.67,62.89 ; H2.1 112.38,63.52 ; H2.1 113.01,65.22 ; 324.78,160.11 H27.1 ; H27.1 326.83,160.11 ; H27.1 325.03,159.33 ; H27.1 325.81,159.08 ; H27.1 325.81,161.13 ; H27.1 325.03,160.88 ; H27.1 326.58,160.88 ; H27.1 326.58,159.33 ; JUSB1.11 6.21,88.45 ; JUSB1.11 6.21,89.33 ; JUSB1.11 4.84,89.33 ; JUSB1.11 3.46,89.33 ; JUSB1.11 3.46,88.45 ; H18.1 341.9,188.68 ; H18.1 343.42,188.12 ; H18.1 339.82,186.6 ; H18.1 343.42,185.08 ; H18.1 341.9,184.52 ; H18.1 340.38,188.12 ; H18.1 343.98,186.6 ; H18.1 340.38,185.08 ; JHDMI1.20 11.65,96.43 ; JHDMI1.20 12.93,95.5 ; JHDMI1.20 12.93,94.57 ; JHDMI1.20 11.65,94.57 ; JHDMI1.20 10.37,95.5 ; JHDMI1.20 10.37,96.43 ; JHDMI1.20 12.93,96.43 ; JHDMI1.20 10.37,94.57 ; 190.65,184.53 JDOCK1.163 ; JDOCK1.163 191.7,185.51 ; JDOCK1.163 190.65,183.55 ; JDOCK1.163 192.76,183.55 ; JDOCK1.163 192.76,184.53 ; JDOCK1.163 192.76,185.51 ; JDOCK1.163 190.65,185.51 ; JDOCK1.163 191.7,183.55 ; JSATA2.14 237.4,21.09 ; JSATA2.14 236,19.54 ; JSATA2.14 238.8,19.54 ; JSATA2.14 238.8,21.09 ; JSATA2.14 237.4,19.54 ; JSATA2.14 236,21.09 ; JSATA2.14 238.8,20.32 ; JSATA2.14 236,20.32 ; 230.78,64.08 H15.1 ; H15.1 230.27,65.5 ; H15.1 230.78,66.92 ; H15.1 232.2,67.43 ; H15.1 233.62,64.08 ; H15.1 234.13,65.5 ; H15.1 232.2,63.57 ; H15.1 233.62,66.92 ; JSATA1.24 219.33,148.21 ; JSATA1.24 219.33,145.69 ; JSATA1.24 219.78,146.95 ; JSATA1.24 216.35,146.95 ; JSATA1.24 216.81,148.21 ; JSATA1.24 216.81,145.69 ; JSATA1.24 218.07,148.67 ; JSATA1.24 218.07,145.24 ; 113.89,184.42 PBATT2.4 ; PBATT2.4 113.02,185.3 ; PBATT2.4 114.57,185.97 ; PBATT2.4 113.22,185.97 ; PBATT2.4 114.57,184.63 ; PBATT2.4 113.89,186.18 ; PBATT2.4 114.77,185.3 ; PBATT2.4 113.22,184.63 ; H5.1 44.1,72.66 ; H5.1 40.7,76.06 ; H5.1 42.4,72.02 ; H5.1 40.7,72.66 ; H5.1 44.1,76.06 ; H5.1 44.74,74.36 ; H5.1 42.4,76.7 ; H5.1 40.06,74.36 ; 231.72,101.64 H21.1 ; H21.1 234.15,103.31 ; H21.1 236.58,101.64 ; H21.1 231.72,103.31 ; H21.1 231.72,99.96 ; H21.1 236.58,103.31 ; H21.1 236.58,99.96 ; H21.1 234.15,99.96 ; JHDMI1.21 11.65,110.93 ; JHDMI1.21 12.93,110.93 ; JHDMI1.21 10.37,110.93 ; JHDMI1.21 12.93,110 ; JHDMI1.21 10.37,110 ; JHDMI1.21 10.37,109.07 ; JHDMI1.21 11.65,109.07 ; JHDMI1.21 12.93,109.07 ; PBATT2.1 108.57,185.97 ; PBATT2.1 108.77,185.3 ; PBATT2.1 108.57,184.63 ; PBATT2.1 107.22,184.63 ; PBATT2.1 107.02,185.3 ; PBATT2.1 107.22,185.97 ; PBATT2.1 107.89,184.42 ; PBATT2.1 107.89,186.18 ; JSATA1.23 219.33,96.09 ; JSATA1.23 219.33,98.61 ; JSATA1.23 218.07,99.07 ; JSATA1.23 218.07,95.64 ; JSATA1.23 216.35,97.35 ; JSATA1.23 216.81,96.09 ; JSATA1.23 216.81,98.61 ; JSATA1.23 219.78,97.35 ; JSATA2.15 238.8,42.09 ; JSATA2.15 238.8,43.64 ; JSATA2.15 236,42.87 ; JSATA2.15 237.4,43.64 ; JSATA2.15 238.8,42.87 ; JSATA2.15 236,42.09 ; JSATA2.15 237.4,42.09 ; JSATA2.15 236,43.64 ; H14.1 231.63,177.95 ; H14.1 231.12,179.37 ; H14.1 228.28,179.37 ; H14.1 229.7,176.02 ; H14.1 231.12,176.53 ; H14.1 228.28,176.53 ; H14.1 227.77,177.95 ; H14.1 229.7,179.88 ; H4.1 178.58,63.31 ; H4.1 174.76,67.13 ; H4.1 178.58,67.13 ; H4.1 174.04,65.22 ; H4.1 176.67,67.85 ; H4.1 174.76,63.31 ; H4.1 176.67,62.59 ; H4.1 179.3,65.22 ; 9.37,106.25 JHDMI1.17 ; JHDMI1.17 10.41,105.79 ; JHDMI1.17 10.53,106.25 ; JHDMI1.17 9.49,105.79 ; JHDMI1.17 10.41,106.71 ; JHDMI1.17 9.49,106.71 ; JHDMI1.23 2.2,112.83 ; JHDMI1.23 3.48,112.83 ; JHDMI1.23 2.2,110.97 ; JHDMI1.23 3.48,110.97 ; JHDMI1.23 3.48,111.9 ; 74.95,125.33 H6.1 ; H6.1 77.58,127.96 ; H6.1 79.49,127.24 ; H6.1 75.67,127.24 ; H6.1 79.49,123.42 ; H6.1 75.67,123.42 ; H6.1 80.21,125.33 ; H6.1 77.58,122.7 ; JUSB1.10 13.71,87.57 ; JUSB1.10 13.71,88.45 ; JUSB1.10 10.16,89.33 ; JUSB1.10 10.16,88.45 ; JUSB1.10 11.94,89.33 ; JUSB1.10 13.71,89.33 ; JDOCK1.162 179.7,185.51 ; JDOCK1.162 180.76,183.55 ; JDOCK1.162 178.65,184.53 ; JDOCK1.162 180.76,185.51 ; JDOCK1.162 178.65,183.55 ; JDOCK1.162 178.65,185.51 ; JDOCK1.162 179.7,183.55 ; JDOCK1.159 192.5,181.4 ; JDOCK1.159 192.76,180.6 ; JDOCK1.159 191.7,181.66 ; JDOCK1.159 190.9,181.4 ; JDOCK1.159 190.9,179.81 ; JDOCK1.159 190.65,180.6 ; JDOCK1.159 192.5,179.81 ; JDOCK1.159 191.7,179.55 ; 184.71,68.69 H9.1 ; H9.1 186.13,65.34 ; H9.1 184.71,65.85 ; H9.1 184.2,67.27 ; H9.1 188.06,67.27 ; H9.1 186.13,69.2 ; H9.1 187.55,65.85 ; H9.1 187.55,68.69 ; 174.76,87.13 H3.1 ; H3.1 179.3,85.22 ; H3.1 178.58,83.31 ; H3.1 176.67,87.85 ; H3.1 178.58,87.13 ; H3.1 174.76,83.31 ; H3.1 176.67,82.59 ; H3.1 174.04,85.22 ; 103.72,185.3 PBATT2.11 ; PBATT2.11 105.82,185.3 ; PBATT2.11 103.72,183.29 ; PBATT2.11 104.77,183.29 ; PBATT2.11 105.82,183.29 ; 206.14,184.53 JDOCK1.164 ; JDOCK1.164 208.2,183.55 ; JDOCK1.164 206.14,183.55 ; JDOCK1.164 206.14,185.51 ; JDOCK1.164 210.26,183.55 ; JDOCK1.164 208.2,185.51 ; JDOCK1.164 210.26,184.53 ; JDOCK1.164 210.26,185.51 ; 285.32,165.2 H26.1 ; H26.1 287.13,165.98 ; H26.1 285.57,164.42 ; H26.1 287.13,164.42 ; H26.1 287.38,165.2 ; H26.1 285.57,165.98 ; H26.1 286.35,164.17 ; H26.1 286.35,166.23 ; H23.1 19.23,69.1 ; H23.1 18.98,68.32 ; H23.1 18.98,69.88 ; H23.1 18.2,68.07 ; H23.1 17.42,68.32 ; H23.1 17.42,69.88 ; H23.1 17.17,69.1 ; H23.1 18.2,70.13 ; 108.76,83.31 H1.1 ; H1.1 108.04,85.22 ; H1.1 110.67,82.59 ; H1.1 113.3,85.22 ; H1.1 112.58,87.13 ; H1.1 110.67,87.85 ; H1.1 108.76,87.13 ; H1.1 112.58,83.31 ; JDOCK1.158 180.76,180.6 ; JDOCK1.158 178.65,180.6 ; JDOCK1.158 178.9,181.4 ; JDOCK1.158 179.7,181.66 ; JDOCK1.158 180.5,181.4 ; JDOCK1.158 178.9,179.81 ; JHDMI1.22 4.73,94.53 ; JHDMI1.22 2.17,92.67 ; JHDMI1.22 4.73,93.6 ; JHDMI1.22 3.45,94.53 ; JHDMI1.22 2.17,93.6 ; JHDMI1.22 4.73,92.67 ; JHDMI1.22 2.17,94.53 ; JHDMI1.22 3.45,92.67 ; JDOCK1.152 209.88,182.58 ; JDOCK1.152 208.82,180.6 ; JDOCK1.152 210.93,178.62 ; JDOCK1.152 208.82,178.62 ; JDOCK1.152 210.93,182.58 ; JDOCK1.152 210.93,180.6 ; JDOCK1.152 208.82,182.58 ; JDOCK1.152 209.88,178.62 ; JHDMI1.11 10.53,103.25 ; JHDMI1.11 10.41,103.71 ; JHDMI1.11 10.41,102.79 ; JHDMI1.11 9.49,103.71 ; JHDMI1.11 9.49,102.79 ; JHDMI1.11 9.37,103.25 ; H8.1 143.12,179.37 ; H8.1 141.7,176.02 ; H8.1 140.28,176.53 ; H8.1 143.63,177.95 ; H8.1 141.7,179.88 ; H8.1 140.28,179.37 ; H8.1 143.12,176.53 ; H8.1 139.77,177.95 ; 109.22,184.63 PBATT2.2 ; PBATT2.2 109.02,185.3 ; PBATT2.2 110.57,184.63 ; PBATT2.2 110.57,185.97 ; PBATT2.2 109.89,184.42 ; PBATT2.2 109.22,185.97 ; PBATT2.2 110.77,185.3 ; PBATT2.2 109.89,186.18 ; JDOCK1.145 162.58,180.6 ; JDOCK1.145 160.47,182.58 ; JDOCK1.145 160.47,180.6 ; JDOCK1.145 161.53,182.58 ; JDOCK1.145 160.47,178.62 ; JDOCK1.145 162.58,178.62 ; JDOCK1.145 162.58,182.58 ; JDOCK1.145 161.53,178.62 ; 231.9,106.67 H12.1 ; H12.1 233.83,108.6 ; H12.1 230.48,107.18 ; H12.1 230.48,110.02 ; H12.1 233.31,107.18 ; H12.1 229.97,108.6 ; H12.1 231.9,110.53 ; H12.1 233.31,110.02 ; 161.14,176.68 JDOCK1.153 ; JDOCK1.153 165.26,175.7 ; JDOCK1.153 165.26,176.68 ; JDOCK1.153 163.2,177.66 ; JDOCK1.153 165.26,177.66 ; JDOCK1.153 163.2,175.7 ; JDOCK1.153 161.14,177.66 ; JDOCK1.153 161.14,175.7 ; JDOCK1.154 180.76,175.7 ; JDOCK1.154 178.65,175.7 ; JDOCK1.154 178.65,176.68 ; JDOCK1.154 180.76,176.68 ; JDOCK1.154 178.65,177.66 ; JDOCK1.154 179.7,175.7 ; JDOCK1.154 179.7,177.66 ; 9.49,100.71 JHDMI1.5 ; JHDMI1.5 10.41,99.79 ; JHDMI1.5 10.53,100.25 ; JHDMI1.5 10.41,100.71 ; JHDMI1.5 9.37,100.25 ; JHDMI1.5 9.49,99.79 ; 332.38,150.62 H19.1 ; H19.1 335.98,149.1 ; H19.1 335.42,150.62 ; H19.1 331.82,149.1 ; H19.1 333.9,147.02 ; H19.1 332.38,147.58 ; H19.1 335.42,147.58 ; H19.1 333.9,151.18 ; JDOCK1.156 210.26,177.66 ; JDOCK1.156 206.14,176.68 ; JDOCK1.156 206.14,177.66 ; JDOCK1.156 208.2,175.7 ; JDOCK1.156 210.26,175.7 ; JDOCK1.156 208.2,177.66 ; JDOCK1.156 210.26,176.68 ; JDOCK1.156 206.14,175.7 ; JUSB1.12 6.21,71.87 ; JUSB1.12 4.84,71.87 ; JUSB1.12 3.46,71.87 ; JUSB1.12 6.21,72.75 ; JUSB1.12 3.46,72.75 ; H13.1 30.2,73.03 ; H13.1 31.62,69.68 ; H13.1 28.27,71.1 ; H13.1 28.78,72.52 ; H13.1 31.62,72.52 ; H13.1 32.13,71.1 ; H13.1 30.2,69.17 ; H13.1 28.78,69.68 ; 161.14,183.55 JDOCK1.161 ; JDOCK1.161 163.2,183.55 ; JDOCK1.161 165.26,185.51 ; JDOCK1.161 161.14,185.51 ; JDOCK1.161 165.26,183.55 ; JDOCK1.161 165.26,184.53 ; JDOCK1.161 161.14,184.53 ; JDOCK1.161 163.2,185.51 ; H37.1 108.22,162.58 ; H37.1 104.62,164.1 ; H37.1 105.18,162.58 ; H37.1 108.22,165.62 ; H37.1 106.7,166.18 ; H37.1 106.7,162.02 ; H37.1 105.18,165.62 ; H37.1 108.78,164.1 ; H10.1 6.12,119.75 ; H10.1 4.7,116.4 ; H10.1 7.54,116.4 ; H10.1 6.12,115.89 ; H10.1 7.54,119.24 ; H10.1 4.19,117.82 ; H10.1 8.05,117.82 ; H10.1 4.7,119.24 ; H22.1 83.91,179.78 ; H22.1 82.23,184.64 ; H22.1 82.23,179.78 ; H22.1 83.91,184.64 ; H22.1 83.91,182.21 ; 6.3,1.32 H28.1 ; H28.1 8.48,1.32 ; H28.1 6.3,4.68 ; H28.1 8.48,3 ; H28.1 8.48,4.68
  BOTTOM w0.102: v2(23.67,117.59) v6(23.67,118.32) ; v2(94.5,183.22) 95.08,183.79 v6(95.89,183.79) ; v2(217.1,182.77) v6(217.1,183.51) ; v2(314.93,171.41) v6(314.93,172.15) ; v2(309.39,166.43) v6(309.39,167.17) ; v2(46.13,118.82) v6(46.13,119.56)
  BOTTOM w0.127: UC1.AV49 138.86,63.41 138.86,63.57 139.04,63.75 139.04,64.11 139.19,64.27 ; 143.8,64.27 143.76,64.22 143.76,63.75 143.39,63.38 UC1.AV41 ; v6(70.48,83.35) 70.48,83.9 70.16,84.21 v3(69.59,84.21) ; UC1.AV43 141.82,63.38 142.19,63.75 142.19,64.02 142.43,64.27 ; UC1.AV36 146.54,63.38 146.91,63.75 146.91,64.15 147.03,64.27
  BOTTOM w0.178: v2(128.97,76.67) 129.02,76.62 UC1.P63 ; UC1.AH22 155.59,69.35 v2(155.59,68.83) 155.19,68.83 UC1.AJ23 154.76,69.27 UC1.AH24 154.2,69.24 v2(154.2,68.61) 154.53,68.29 ; UC1.AN36 146.24,66.34 v2(146.07,66.16) ; v2(128.72,66) 128.89,66.17 UC1.AN63 ; v2(127.88,70.95) 127.88,70.93 128.33,71.38 UC1.AD63 ; UC1.AV34 148.44,62.9 UC1.AW33 ; UC1.AV34 148.02,63.23 147.72,62.93 v2(147.71,62.93) 147.71,62.91 147.37,62.58 UC1.AW35 ; UC1.AV34 148.44,63.55 UC1.AV33 ; UC1.AJ56 134.06,68.94 133.74,69.27 UC1.AH57 ; UC1.Y59 132.11,73.7 v2(131.81,74) ; UC1.AL23 154.53,67.64 ; 154.53,67.64 v2(154.2,67.31) 154.53,66.99 UC1.AM23 ; 154.53,67.64 v2(154.2,67.96) 154.53,68.29 ; 154.53,68.29 UC1.AK23 ; v2(138.9,65.36) 139.22,65.69 UC1.AP48 ; v2(136.04,67.31) 136.37,67.65 136.55,67.65 UC1.AL52 ; UC1.AY33 UC1.AW33 ; UC1.AW33 148.69,63.5 UC1.AV33 ; UC1.AU28 UC1.AV28 151.26,63.08 v2(151.29,63.04) ; UC1.AU28 150.77,64.2 150.75,64.22 150.47,64.22 150.45,64.2 UC1.AU30 ; UC1.AU28 151.74,64.2 151.76,64.22 152.05,64.22 152.06,64.2 UC1.AU26 152.99,64.2 153.01,64.22 153.29,64.22 153.31,64.2 UC1.AU24 ; v2(152.28,61.09) 152.47,61.28 UC1.AY26 ; UC1.AV33 148.74,64.2 UC1.AU33 ; UC1.AW37 145.8,62.58 146.13,62.91 v2(146.13,62.93) 146.15,62.93 146.45,63.23 UC1.AV36 ; UC1.AN31 UC1.AM31 ; UC1.AN31 149.56,66.34 UC1.AN32 149.25,66.34 v2(148.93,66.01) ; UC1.AN31 UC1.AP31 UC1.AR31 149.88,64.36 UC1.AU30 ; UC1.AG60 UC1.AG61 UC1.AG62 UC1.AG63 128.89,69.95 v2(128.81,69.87) ; v2(131.7,65.04) 131.84,64.91 131.84,64.53 132.14,64.23 UC1.AU59 ; v2(131.7,65.04) 131.81,65.15 131.81,65.64 131.79,65.65 UC1.AN60 ; v2(131.7,65.04) 131.58,64.92 UC1.AT61 130.39,64.92 UC1.AT62 130.32,64.85 129.83,64.85 129.79,64.82 129.63,64.82 UC1.AT63 129.33,64.71 128.88,64.26 v2(128.67,64.26) ; UC1.AL17 UC1.AM17 UC1.AN17 UC1.AP17 UC1.AR17 ; UC1.Y63 128.89,73.63 v2(128.72,73.46) ; v2(130.63,67.35) 130.67,67.39 UC1.AL61 UC1.AL60 131.79,67.87 131.81,67.89 131.81,68.17 131.79,68.19 UC1.AJ60 ; UC1.AU55 134.11,64.2 134.09,64.22 133.81,64.22 133.79,64.2 UC1.AU57 132.86,64.2 132.85,64.22 132.56,64.22 132.54,64.2 UC1.AU59 ; UC1.AU55 135.08,64.2 135.1,64.22 135.38,64.22 135.4,64.2 UC1.AU53 136.33,64.2 136.34,64.22 136.63,64.22 136.65,64.2 UC1.AU51 UC1.AV51 UC1.AW51 UC1.AY51 137.16,61.65 137.06,61.55 v2(137.06,60.64) ; UC1.AU55 UC1.AV55 134.6,63.08 v2(134.63,63.04) ; UC1.D8 163.76,82.77 v2(163.25,82.25) ; UC1.AR52 136.56,65.17 136.55,65.18 136.55,65.55 136.56,65.56 UC1.AP52 136.48,65.69 v2(136.09,66.08) ; UC1.AR23 154.53,65.04 v2(154.2,64.71) ; v2(154.2,64.71) 154.44,64.48 154.71,64.22 154.72,64.2 UC1.AU22 155.58,64.2 155.6,64.22 155.89,64.22 155.9,64.2 UC1.AU20 UC1.AV20 156.39,63.08 v2(156.43,63.04) ; v2(154.2,64.71) 153.82,64.32 UC1.AU24 ; v2(149.97,61.33) 150.04,61.4 UC1.AY30 ; UC1.AB7 164.2,72.8 v2(164.38,72.98) ; UC1.AK52 136.67,68.4 UC1.AJ52 ; UC1.AY16 158.92,62.29 UC1.AW16 UC1.AV16 UC1.AU16 158.44,64.2 158.42,64.22 158.14,64.22 158.12,64.2 UC1.AU18 ; v2(143.62,66.01) 143.29,66.34 UC1.AN42 142.98,66.34 v2(142.71,66.06) 142.43,66.34 UC1.AN43 UC1.AN45 ; UC1.AV41 143.3,63.23 143,62.93 v2(142.98,62.93) 142.98,62.91 142.65,62.58 UC1.AW42 ; UC1.AU59 UC1.AV59 UC1.AW59 ; UC1.AW40 144.22,62.58 144.56,62.91 v2(144.56,62.93) 144.57,62.93 144.87,63.23 UC1.AV39 ; UC1.AU24 UC1.AV24 UC1.AW24 UC1.AY24 153.82,61.39 v2(153.75,61.32) ; UC1.AU33 149.5,64.22 149.53,64.2 UC1.AU30 ; UC1.AU33 148.53,64.22 v2(147.97,64.78) ; 147.68,60.18 147.56,60.06 ; v2(139.85,66.61) 139.52,66.33 139.29,66.33 UC1.AN48 139.03,66.08 138.65,66.08 UC1.AN49 ; UC1.AY22 155.18,61.37 v2(155.23,61.31) ; UC1.AV43 141.72,63.23 141.42,62.93 v2(141.41,62.93) 141.41,62.91 141.07,62.58 UC1.AW44 ; UC1.AY18 157.61,61.4 157.52,61.31 v2(157.52,61.31) ; UC1.AV49 138.63,63.19 138.54,63.19 138.27,62.93 v2(138.26,62.93) 138.26,62.91 138.07,62.73 138,62.73 UC1.AW50 ; v2(133.21,61.28) 133.38,61.44 UC1.AY57 ; v2(128.59,68.27) 128.81,68.27 129.15,68.6 UC1.AJ63 ; v2(146.07,67.47) 146.24,67.64 UC1.AL36 ; UC1.AY53 135.81,61.62 135.77,61.58 135.77,61.26 v2(135.47,60.97) ; v2(147.97,67.38) 148.24,67.64 UC1.AL33 ; v2(147.97,64.78) 147.71,64.51 UC1.AT35 147.27,64.33 147.21,64.27 146.57,64.27 146.5,64.33 UC1.AT37 145.37,64.33 145.3,64.27 144.93,64.27 144.87,64.33 UC1.AT40 143.87,64.33 143.8,64.27 143.05,64.27 UC1.AT42 142.91,64.33 142.84,64.27 141.47,64.27 UC1.AT43 UC1.AT46 139.76,64.27 138.71,64.27 138.67,64.31 UC1.AT49 ; v2(147.97,64.78) 148.24,65.04 UC1.AR33
  BOTTOM w0.2: v5(49.08,94.44) 49.58,94.94 50.27,94.94 UV1.Y26 ; UV1.P26 50.27,99.78 49.4,99.78 v5(49.35,99.84) ; v5(55.28,111.14) 55.39,111.03 55.39,109.86 UV1.B20 ; UV1.B23 52.66,109.86 52.66,111.03 v5(52.53,111.16) ; v5(52.4,89.55) 52.78,89.93 UV1.AF23 ; v5(65.22,88.61) 65.19,88.64 UV1.AF8 ; UV1.AC2 70.14,92.38 70.85,92.38 v5(71.2,92.03) ; UV1.B14 60.15,109.82 60.15,110.38 v5(60.17,110.38)
  BOTTOM w0.203: v2(135.14,67.31) 135.47,67.64 UC1.AL54 ; v2(159.63,64.53) 159.68,64.53 UC1.AR15 ; UC1.AG1 168.34,69.84 168.58,69.61 v2(168.77,69.61) ; UC1.D59 132.24,82.34 132.76,81.82 UC1.F58 ; v2(133.24,67.31) 133.56,67.64 UC1.AL57 ; UC1.U61 130.81,75.2 v2(130.51,75.5) ; v2(168.62,78.77) 168.56,78.83 UC1.K1 ; v2(131.98,69.22) 132.26,68.94 UC1.AJ58 133.09,69.27 UC1.AH57 ; v2(131.98,69.22) 131.98,69.76 UC1.AG60 ; v2(131.98,69.22) 131.79,69.03 UC1.AJ60 ; v2(159.89,63.64) 160.31,63.23 UC1.AV14 ; UC1.AV8 162.89,63.64 162.89,63.62 v2(162.9,63.62) ; UC1.AY11 161.77,61.09 v2(161.68,61) ; PU100.3 PU100.21 v2(38.41,13.77) ; UC1.D21 156.12,82.13 156.12,82.11 156.36,81.86 156.39,81.86 156.57,81.68 v2(156.57,81.62) ; v2(167.14,76.96) 166.84,77.26 UC1.N3 ; UC1.N21 156.45,77.03 156.32,76.9 156.32,76.9 156.05,76.63 155.63,76.63 UC1.P22 155.9,77.09 v2(155.9,77.13) ; UC1.AN60 131.84,66.22 131.84,67.33 UC1.AL60 ; UC1.AN40 144.34,66.66 UC1.AN39 ; UC1.AN40 144.34,66.01 UC1.AP39 ; UC1.AN40 143.94,66.34 v2(143.62,66.01) ; UC1.AL46 140.61,67.37 v2(140.8,67.37) 141,67.37 UC1.AL45 ; v2(136.08,66.69) 136.22,66.69 136.56,66.35 UC1.AN52 ; UC1.P59 132.28,76.59 v2(132.55,76.31) 132.55,76.04 UC1.T58 ; v2(138.9,65.36) 138.57,65.04 UC1.AR49 138.23,64.88 UC1.AT49 137.27,64.31 UC1.AU51 ; v2(87.2,89.63) 87.1,89.72 PU300.22 ; v2(187.67,168.95) 188.29,168.95 188.69,168.55 U39.31 ; U39.11 184.33,168.2 v2(184.22,168.31) ; PU100.1 39.57,12.27 v2(39.74,12.1) ; UC1.AW4 166.17,61.97 UC1.AY4 166.21,61.53 v2(166.36,61.37) ; v2(167.14,73.93) 166.84,74.23 UC1.V3 ; U19.11 89.44,76.49 89.14,76.19 v2(89.14,76.08) ; v2(167.14,64.97) 167.14,65.14 166.9,65.38 UC1.AP3 ; UC1.AW60 131.82,62.58 UC1.AW59 ; v2(80.39,66.87) PU150.19 ; PU150.24 79.59,69.45 79.38,69.67 79.26,69.67 v2(79.14,69.79) ; UV4.G8 UV5.G1 ; v2(157.48,74.28) 156.97,74.28 UC1.W20 ; U18.11 270.89,179.33 v2(270.68,179.12) ; UC1.AN52 136.67,66.34 136.8,66.21 137.18,66.21 137.31,66.34 UC1.AN51 137.65,66.34 137.75,66.23 138.13,66.23 138.24,66.34 UC1.AN49 ; UC1.AN52 136.3,66.08 v2(136.09,66.08) ; UC1.AP54 135.47,65.69 v2(135.14,65.36) ; UC1.AU20 156.46,64.27 157.53,64.27 UC1.AU18 ; v2(128.92,82.66) 129,82.58 UC1.D63 129.57,82.52 UC1.D62 ; U51.11 v2(261.34,154.67) ; v2(133.24,65.36) 133.56,65.69 UC1.AP57 ; PU100.14 38.81,15.9 38.75,15.96 38.75,16.29 v2(38.62,16.42) ; UC1.R8 UC1.R10 ; UC1.W22 155.43,74.28 UC1.V23 154.65,75.06 v2(154.65,75.1) ; UC1.AM31 UC1.AL31 149.88,68.37 v2(149.81,68.44) ; UC1.AN48 UC1.AP48 ; UC1.AG21 156.19,69 v2(156.31,68.89) 156.5,69.08 UC1.AH20 ; UC1.AT43 141.41,64.37 v2(141.75,64.71) 142.08,65.04 UC1.AR43 ; UC1.E17 158.8,81.94 v2(158.48,82.26) ; v2(167.14,67.97) 167.14,68.09 166.85,68.38 UC1.AK3 ; UC1.AL51 137.32,67.64 v2(136.99,67.31) ; 166.45,82.88 166.45,83.67 UC1.B4 ; 166.45,82.88 v2(167.16,82.88) 167.49,82.55 UC1.D2 ; 166.45,82.88 166.11,82.88 165.94,82.71 UC1.D5 ; PU150.25 79.99,69.79 v2(79.65,70.14) ; UC1.J63 129.14,80 v2(129.14,80.02) ; v2(136.04,67.31) 136.23,67.31 UC1.AM52 ; PU150.23 78.93,68.47 79.16,68.7 79.16,68.89 v2(78.64,69.41) ; UC1.A48 UC1.B48 ; U46.11 v2(258.56,161.26) ; UC1.AR11 161.07,64.85 v2(161.04,64.88) 160.92,64.88 UC1.AT13 ; v2(189.04,170.24) 189.41,169.87 U39.28 ; UC1.G6 164.5,80.64 v2(164.1,81.04) 163.7,80.64 UC1.G8 ; v2(139.85,66.61) 140.12,66.34 UC1.AN46 140.54,66.34 140.61,66.26 140.99,66.26 141.06,66.34 UC1.AN45 ; UV1.AF5 68.01,89.61 v5(68.01,89.32) ; UV7.G1 35.08,94.5 35.08,93.8 UV6.G8 ; v2(84.28,87.09) 84.08,87.28 PU300.29 ; v2(169.31,63.18) 169.19,63.3 168.99,63.3 168.39,63.9 UC1.AU1 ; UC1.AD3 166.84,71.26 v2(167.14,70.96) ; v2(164.98,61.29) 164.77,61.5 UC1.AY6 ; v2(164.82,66.78) 164.73,66.78 164.43,66.48 UC1.AN7 ; v2(130.51,81.49) 130.81,81.2 UC1.F61 ; v2(131.97,61.37) 132.05,61.46 UC1.AY59 ; U39.3 187.52,167.36 187.52,168.19 v2(187.67,168.34) ; UC1.T1 v2(168.62,75.84) ; UC1.AE5 165.51,70.9 v2(165.68,71.07) ; UC1.L61 130.81,78.2 v2(130.51,78.5) ; UC1.AR23 154.72,65.04 v2(155.05,65.36) ; UC1.P62 UC1.P63 ; UC1.AY16 159,62.21 159,61.28 158.93,61.21 v2(158.93,61.22) ; UC1.AH16 159.08,68.92 158.58,68.92 UC1.AH17 ; UC1.L7 164.52,78.53 v2(164.52,78.66) ; v2(87.32,91.02) 87.23,90.92 PU300.19 ; UC1.AM1 v2(168.62,66.84) ; v2(156.08,75.1) UC1.U22 ; PU301.3 v2(95.81,104.9)
  BOTTOM w0.25: v2(62.85,110.38) 62.85,109.88 UV1.B11 ; v5(50.33,88.57) UV1.AG26 ; v5(67.57,110.57) 67.57,109.85 UV1.B5 ; v5(48.77,97.38) 48.79,97.36 UV1.U26
  BOTTOM w0.254: UC1.A28 UC1.B28 ; v2(147.87,68.68) 147.87,69.11 UC1.AH34 147.49,69.5 v2(147.07,69.5) ; v2(150.39,67.31) 150.44,67.31 150.77,67.64 UC1.AL29 ; v2(152.27,67.29) 152.62,67.64 UC1.AL26 ; v2(172.95,175.33) JDOCK1.25 ; UC1.J22 155.54,79.16 155.85,78.85 v2(155.96,78.85) ; UV1.U2 v2(69.74,97.75) ; UV6.B3 39.13,89.99 39.39,90.25 v2(39.39,90.25) ; UC1.AR39 UC1.AP39 UC1.AN39 144.6,67.15 v2(144.44,67.31) 144.34,67.31 UC1.AL40 144.34,67.96 UC1.AL39 144.6,68.1 v2(145.12,68.61) 145.12,68.62 UC1.AH38 144.88,69.5 v2(144.47,69.5) ; UC1.AR39 v2(145.12,65.36) 145.44,65.69 UC1.AP38 ; UC1.AR39 144.56,65.32 UC1.AT40 ; v2(131.81,80) 132.11,79.7 UC1.J59 ; UV5.P9 29.52,103.92 v2(29.14,104.29) ; v2(39.52,103.5) UV5.B9 ; UC1.A11 161.78,85.39 162.2,85.81 v2(162.2,87.29) ; D17.8 18.45,78.86 v2(18.66,78.65) ; UV5.B1 v2(39.52,110.7) UV4.A9 ; JIO1.56 338.88,164.45 338.59,164.73 v2(338.59,165.06) ; UC1.AL17 159.23,68.29 159.91,68.29 UC1.AJ14 160.05,68.47 160.35,68.77 v2(160.46,68.77) 160.52,68.77 UC1.AJ13 160.86,68.08 UC1.AL13 ; v2(131.16,72.48) 130.81,72.14 UC1.AC61 ; UV1.AE17 57.79,90.74 UV1.AD16 ; v2(145.34,80.85) 145.34,80.85 UC1.F38 UC1.D38 ; v2(159.53,65.8) 159.53,65.82 159.08,65.37 UC1.AR17 ; v2(147.07,69.5) 146.65,69.5 UC1.AH36 ; v2(147.07,69.5) UC1.AJ35 ; JIO1.19 336.58,173.45 v2(336.85,173.19) ; UC1.AH30 150.71,69.65 v2(150.95,69.65) ; v2(150.95,69.65) 151.23,69.65 151.62,69.27 UC1.AH28 151.88,69.27 152.2,68.94 UC1.AJ27 152,68.67 151.43,68.67 v2(151.27,68.52) 151.27,68.57 150.97,68.87 UC1.AJ29 ; v2(150.95,69.65) 150.95,68.97 UC1.AJ29 ; UC1.AP22 155.42,65.69 155.09,65.36 v2(155.05,65.36) ; UV6.A9 39.93,94.61 v2(39.53,95.01) 39.13,94.61 UV7.B1 ; v2(336.92,172.25) 336.92,171.72 336.66,171.45 JIO1.27 ; v2(182.57,182.99) 182.57,183.15 181.95,183.76 JDOCK1.58 ; UC1.AH46 139.92,68.78 v2(139.85,68.71) ; UV5.T9 27.92,103.65 v2(27.7,103.43) ; v2(160.32,86.78) 160.42,86.67 160.42,85.07 160.11,84.76 UC1.A14 160.25,84.41 160.25,83.4 UC1.C14 160.21,83.18 UC1.D14 UC1.D12 ; UC1.E11 161.41,82.26 v2(161.33,82.26) 161.41,82.34 UC1.D12 ; UV1.AD13 60.99,91.54 v2(60.65,91.2) 60.23,90.78 UV1.AE14 ; JDOCK1.63 183.45,175.61 183.66,175.4 ; v2(186.54,177.85) 186.45,177.76 JDOCK1.75 ; JDOCK1.69 184.95,175.55 v2(185.26,175.25) ; D17.3 v2(15.67,78.86) ; v2(144.47,69.5) UC1.AJ39 ; v2(144.47,69.5) 144.05,69.5 UC1.AH40 143.82,68.85 v2(143.68,68.71) 143.4,68.71 UC1.AJ41 142.93,68.7 v2(142.63,68.7) ; JIO1.57 337.19,163.95 337.51,163.64 v2(337.51,163.33) ; v2(340.93,175.25) 340.64,174.95 JIO1.14 ; UV5.M9 31.12,103.92 v2(30.74,104.29) ; UV1.AC8 65.19,92.34 v5(65.6,92.75) ; UV7.P9 29.53,88.17 v2(29.16,88.54) ; UV1.AB14 60.23,93.23 v5(59.88,93.58) ; U17.7 308.73,157.06 308.96,157.29 v2(308.96,157.47) ; UC1.Y10 162.14,73.98 161.79,73.98 161.46,74.31 v3(161.46,74.51) ; UV7.E2 v2(37.13,93.35) 37.52,93.74 UV6.D8 ; UC6.7 102.53,78.01 v2(102.54,78.02) ; JIO1.39 336.58,168.45 336.87,168.16 337.51,168.16 v2(337.56,168.11) ; UC1.F20 156.64,81.62 v2(156.57,81.62) ; UC1.AF18 UC1.AF17 158.83,70.81 v2(158.88,70.86) 159.06,70.86 UC1.AF15 ; UC1.D34 UC1.F34 147.85,80.85 v2(147.85,80.85) ; UC1.AF14 160.46,71.06 160.37,71.15 v2(160.37,71.87) ; v2(142.63,68.7) 142.11,68.7 UC1.AJ43 141.54,69.27 UC1.AH44 140.89,69.27 UC1.AJ45 140.33,68.71 v2(139.85,68.71) ; v2(142.63,68.7) 142.52,68.82 UC1.AH42 ; v2(148.9,68.61) 148.9,69.15 UC1.AH32 ; v5(57.34,93.58) 57.74,93.18 UV1.AB17 ; v2(33.88,88.54) 33.86,88.57 33.86,88.63 UV7.J8 ; UC1.AJ29 150.72,68.94 v2(150.39,68.61) ; v2(142.83,80.85) 142.83,80.85 UC1.F42 UC1.D42 ; v2(338.19,163.36) 338.19,163.66 337.41,164.45 JIO1.55 ; v2(174.31,175.2) 174.45,175.35 JDOCK1.31 ; JDOCK1.138 202.95,183.39 v2(203.01,183.33) ; UC1.AG23 154.99,69.78 v2(154.49,69.78) ; JDOCK1.108 v2(195.45,183.33) ; JIO1.33 336.38,169.95 337.51,171.08 v2(337.51,171.87) ; UV4.D8 37.51,109.49 v2(37.12,109.1) UV5.E2 ; v2(172.74,186.09) 172.74,185.71 172.95,185.49 JDOCK1.26 ; UC1.AH53 135.69,68.94 UC1.AJ54 135.04,68.94 UC1.AH55 134.39,68.94 UC1.AJ56 ; v2(165.93,177.2) 165.93,175.73 166.11,175.55 166.77,175.55 166.95,175.73 JDOCK1.1 ; UC1.L13 160.78,78.4 161.18,77.99 v2(161.34,77.99) 161.25,78.07 UC1.K12 ; JDOCK1.113 196.95,177.76 v2(196.79,177.92) ; v2(333.82,165.06) 333.82,165.27 334.17,165.62 334.79,165.62 334.96,165.45 JIO1.51 ; JIO1.45 336.58,166.95 336.81,166.73 v2(336.81,165.1) ; UV5.G9 34.78,103.56 v2(34.73,103.56) ; UC1.AH49 138.73,69.15 v2(138.73,68.71) ; v2(152.86,80.85) 152.86,80.85 UC1.F26 UC1.D26 ; PU600.22 v2(57.46,32.11) ; v2(177.33,177.96) 177.45,177.85 JDOCK1.43 ; v2(187.94,175.27) 187.95,175.28 JDOCK1.81 ; UC1.AB22 155.54,72.41 155.69,72.25 155.7,72.25 155.94,72.01 155.94,72 155.95,71.99 155.95,71.97 v2(156.08,71.85) 156.45,71.47 UC1.AD21 ; v2(162.2,79.45) 162.31,79.33 UC1.J10 ; v2(164.38,74.88) 164.38,74.58 UC1.V7 ; v2(162.88,67.45) 162.75,67.59 162.73,67.57 162.69,67.57 UC1.AL10 ; UC1.A24 UC1.B24 ; UC1.AL22 155.41,67.64 155.09,67.31 v2(155.05,67.31) ; UC1.AH19 157.91,69.38 158,69.38 v3(158.03,69.4) 158.36,69.08 UC1.AH17 ; UV7.G1 v2(35.53,94.95) UV6.F9 ; v2(29.94,110.66) 29.96,110.66 30,110.7 30.71,110.7 31.11,110.3 UV5.M1 ; v3(162.09,74.51) 162.2,74.41 UC1.V10 162.67,74.44 UC1.U9 ; JDOCK1.37 175.95,177.9 175.95,177.9 175.95,178.25 175.55,178.65 v2(175.2,178.65) ; UV7.P1 29.49,94.55 v2(29.14,94.89) 29.07,94.97 28.12,94.97 27.93,94.79 UV7.T1 ; UC1.L15 159.66,78.41 159.09,77.84 v2(159.09,77.87) 159.09,78.19 UC1.L17 ; UC1.B20 156.43,84.05 156.75,84.05 v2(156.78,84.08) 156.78,83.77 156.63,83.62 UC1.C20 ; JDOCK1.125 199.95,177.69 v2(199.64,178) 199.45,177.81 JDOCK1.123 ; UV1.AD19 56.11,91.55 v5(55.7,91.97) ; v2(177.51,183.25) 177.45,183.31 JDOCK1.44 ; v5(62.89,104.4) 63.23,104.06 UV1.K11 ; UV5.T1 27.92,110.54 28.1,110.72 29.06,110.72 v2(29.13,110.64) 29.47,110.3 UV5.P1 ; v2(37.93,87.75) UV6.D1 ; JDOCK1.47 178.45,177.84 v2(177.84,178.45) ; UC1.L58 v2(133.31,78.43) ; UV7.J2 33.53,93.76 v2(33.93,94.16) ; v2(168.71,73) 168.54,72.84 UC1.AA1 ; JTAA1.20 201.51,82.98 201.7,83.17 v2(201.71,83.17) ; v2(201.77,83.79) 202.24,83.32 202.24,82.99 202.01,82.77 JTAA1.18 ; UC1.F58 132.76,81.01 v2(132.63,80.87) 133.05,80.45 UC1.H57 ; UC1.B60 131.52,83.86 131.52,83.84 131.64,83.71 131.64,83.28 132.24,82.68 UC1.D59 ; v2(168.45,183.33) JDOCK1.8 ; JDOCK1.13 v2(169.95,177.86) ; JDOCK1.87 189.45,175.7 189.2,175.44 v2(189.2,175.22) ; JDOCK1.96 192.45,183.12 192.32,182.99 v2(192.32,182.56) ; v2(338.5,170.9) 338.95,170.45 JIO1.32 ; v2(37.92,103.5) UV4.D1 ; v2(199.95,183.35) JDOCK1.126 ; v2(169.36,177.86) 169.26,177.96 168.85,177.96 168.45,177.57 JDOCK1.7 ; v2(332.39,162.96) 332.9,162.45 JIO1.63 ; v2(139.85,68.71) 139.5,68.71 UC1.AJ47 139.03,68.71 v2(138.73,68.71) ; UV1.H2 v2(70.69,104.8) ; UC1.N10 162.63,77.23 162.63,76.35 UC1.R10 161.91,76.31 v2(161.77,76.45) ; UC1.AR52 136.38,65.04 135.81,64.47 UC1.AU53 ; v2(138.73,68.71) 138.2,68.71 UC1.AJ50 137.64,69.27 UC1.AH51 136.99,68.94 UC1.AJ52 ; UC1.U20 v2(156.08,75.1) ; v2(150.35,80.85) 150.36,80.85 UC1.F30 UC1.D30 ; v2(137.82,80.85) 137.82,80.85 UC1.F50 UC1.D50 ; v2(155.87,77.94) 155.54,77.6 UC1.M22 ; v2(156.95,67.31) 156.99,67.31 157.32,67.64 UC1.AL20 ; JDOCK1.93 190.95,175.68 191.18,175.44 v2(191.18,175.2) 190.82,175.2 190.45,175.57 JDOCK1.91 ; UC1.G3 166.91,80.37 167.21,80.07 v2(167.21,79.96) ; v2(160.36,80.31) 160.43,80.31 160.75,79.98 UC1.H13 ; JIO1.40 v2(340.88,168.45) ; UC1.H17 158.8,79.98 v2(158.48,80.31) 158.25,80.31 UC1.G18 ; UC1.A18 157.65,84.44 157.65,83.37 UC1.C18 157.64,83.18 UC1.D18 158.04,82.7 v2(158.48,82.26) ; UC1.A40 UC1.B40 ; v2(34.74,87.81) 34.79,87.81 UV7.G9 ; v2(165.68,64.92) 165.53,64.92 165.27,65.18 UC1.AR5 ; JDOCK1.55 181.45,175.29 v2(182.16,174.59) 182.16,175.27 181.94,175.49 181.94,175.66 181.95,175.66 JDOCK1.57 ; JDOCK1.132 201.45,183.3 v2(201.36,183.21) ; JDOCK1.114 v2(196.95,183.33) ; JIO1.20 338.49,173.45 v2(338.43,173.39) ; UV5.J2 33.52,109.51 v2(33.92,109.91) ; JDOCK1.70 184.91,184.56 184.91,182.9 v2(184.71,182.7) 184.77,182.63 185.61,182.63 186.45,183.47 JDOCK1.76 ; UC1.AP20 157.31,65.69 157.15,65.53 157.14,65.53 156.97,65.36 v2(156.95,65.36) ; UC1.AP10 162.48,65.81 162.8,65.5 v2(162.88,65.5) ; UC1.D54 UC1.F54 135.31,80.85 v2(135.31,80.85) ; UV6.E1 v2(37.13,88.55) UV7.E8 ; v2(171.45,175.33) JDOCK1.19 ; JDOCK1.88 189.45,183.49 v2(189.61,183.33) ; UC1.AE58 133.44,70.62 v2(133.49,70.57) ; JDOCK1.14 169.95,183.43 v2(169.87,183.35) ; UC1.AA58 v2(133.31,73.22) ; v2(192.11,175.14) 192.45,175.48 JDOCK1.95 ; v2(303.67,152.82) 303.76,152.73 U17.42 ; UC1.AB20 157.47,73.17 v2(157.47,73.27) ; UV5.E8 v2(37.12,104.3) UV4.E1 ; v2(183.77,185.87) 183.45,185.56 JDOCK1.64 ; 183.66,175.4 183.58,175.32 183.23,175.32 182.95,175.6 JDOCK1.61 ; 183.66,175.4 v3(183.66,175.37) ; v2(202.96,177.93) 202.95,177.92 JDOCK1.137 ; v2(140.32,80.85) 140.33,80.85 UC1.F46 UC1.D46 ; UC1.R22 UC1.P22 ; UC1.AF12 161.27,70.17 UC1.AG11 161.68,69.87 UC1.AF11 162.34,70.27 UC1.AE10 ; v2(147.02,66.01) 147.05,66.01 147.38,66.34 UC1.AN35 ; v2(198.87,174.94) 198.45,175.36 JDOCK1.119 ; v2(161.64,72.07) 162.23,72.07 UC1.AB10 ; v2(332.34,162.33) 332.72,161.95 JIO1.65 ; UV1.AG2 v2(70.78,89.14) ; JDOCK1.102 193.95,183.48 193.8,183.33 v2(193.8,183.27) ; JIO1.50 v2(341.44,165.95) ; UC1.AJ25 v2(153.57,69.5) ; v2(158.18,76.39) 158.28,76.49 158.28,77.25 157.92,77.62 UC1.L18 157.02,78.41 UC1.L20 ; UC1.D12 161.79,83.15 UC1.C11 ; UC1.V58 v2(133.31,74.53) ; v2(39.34,105.98) 39.12,105.76 UV4.B3 ; JDOCK1.82 187.95,183.49 v2(187.79,183.33) ; v2(165.1,81.06) 165.53,80.64 UC1.G5 ; JDOCK1.120 198.45,183.49 v2(198.59,183.35) ; JIO1.26 338.67,171.95 v2(338.52,172.1) ; JIO1.64 340.98,162.45 v2(341.08,162.35) ; UV1.P2 70.47,99.5 71.21,99.5 v5(71.51,99.2) ; JDOCK1.131 201.45,177.81 201.34,177.92 v2(201.34,178) ; v2(171.45,183.35) JDOCK1.20 ; JDOCK1.38 175.95,182.82 175.89,182.75 v2(175.89,182.43) ; UV1.E5 v5(68.13,106.84) ; v2(191.38,182.56) 191.38,183.27 190.95,183.7 JDOCK1.94 ; JDOCK1.101 193.95,175.63 194.31,175.27 v2(194.81,175.27) 195.13,175.27 195.45,175.58 JDOCK1.107 ; v2(39.53,87.75) UV7.B9 ; UV7.M1 31.13,94.55 30.73,94.95 30.01,94.95 29.97,94.91 v2(29.96,94.91) ; UV4.F9 v2(35.52,110.7) UV5.G1 ; JIO1.53 334.59,164.95 v2(334.48,165.06) ; JDOCK1.32 174.45,183.48 v2(174.59,183.35) ; UV1.AA7 66.03,94.14 v2(65.42,94.76) ; UV7.M9 31.13,88.17 v2(30.76,88.54) ; v2(27.56,87.74) 27.93,88.12 UV7.T9 ; UV1.AD21 UV1.AD22
  BOTTOM w0.3: UV1.P5 67.73,99.77 67.34,99.38 v2(67.34,99.38) ; UV1.AD16 UV1.AD15 59.42,91.54 v5(59.82,91.14) ; UV1.AD13 61.21,91.68 61.73,91.68 UV1.AD12 ; UV1.AD21 54.46,91.54 55.26,90.74 UV1.AE20 UV1.AF20 v5(55.27,88.57) ; UV1.AC22 53.57,92.34 v5(53.23,92) 53.63,91.6 UV1.AD22 ; v5(57.75,88.52) UV1.AF17 UV1.AE17 ; UV1.AE11 UV1.AF11 v5(62.71,88.41) ; v5(68.08,91.99) 67.68,92.39 UV1.AC5 ; UV1.Y5 67.33,94.48 v5(67.3,94.48)
  BOTTOM w0.305: UV1.B17 57.67,109.82 57.67,110.39 v5(57.98,110.7) ; v5(65.03,101.02) 64.85,100.84 UV1.N10 63.73,100.34 ; UV1.U14 60.23,96.87 v2(60.65,97.3) 61.2,97.84 UV1.T13 61.74,98.35 v5(61.74,98.42) 62.16,98.84 UV1.R12 ; UC1.AP26 152.36,65.36 v2(152.29,65.36) ; v5(51.54,92.84) 51.54,92.85 UV1.AB24 ; v2(64.78,97.42) 64.23,96.87 UV1.U10 ; UV1.AB20 55.27,93.18 v5(54.87,93.58) ; UC1.AV46 140.21,63.23 v2(139.84,62.86) 139.7,62.86 139.42,62.58 UC1.AW47 ; UV1.AF1 71.05,90.06 v5(71.47,90.06) ; UV1.N16 58.27,100.84 v5(58.75,101.32) 58.75,101.36 UV1.M15 59.64,102.25 v5(59.89,102.25) 60.23,102.59 UV1.L14 ; UV1.K17 57.23,103.78 v2(56.72,103.27) 56.29,102.84 UV1.L18 56.1,102.84 55.76,102.5 v5(55.64,102.5) ; UV1.V11 63.21,95.84 v5(62.69,96.36) 62.23,96.82 UV1.U12 ; v5(53.12,96.94) 52.73,97.32 UV1.U23 ; UV1.K15 59.23,103.81 v5(58.69,103.27) 58.26,102.84 UV1.L16 58.23,102.81 v2(57.73,102.31) 57.26,101.84 UV1.M17 ; UV1.E11 62.73,107.34 v5(63.13,107.74) ; UC1.AG11 162.09,69.35 v2(162.09,68.7) ; UV1.M11 63.36,101.84 v5(63.72,102.21) 64.23,102.71 UV1.L10 64.93,102.84 v5(65.11,103.02) ; UV1.Y23 53.13,95.28 v5(53.13,95.3) ; v5(68.15,101.9) 68.15,101.9 UV1.L5 ; UC1.G22 155.76,81.01 156,81.01 v2(156,81.02) ; UC1.AN23 154.53,66.34 v2(154.2,66.01) 154.53,65.69 UC1.AP23 ; UV1.H5 v5(67.31,104.38) ; UV1.B27 49.13,110.14 v5(49.09,110.14) ; v2(150.4,65.36) 150.46,65.36 UC1.AP29 ; v5(64.78,109.42) 65.1,109.74 UV1.B8 ; UV1.L2 70.12,102.32 v2(69.72,102.72) ; v2(58.15,107.72) 57.77,107.34 UV1.E17 ; UV1.L25 50.73,102.72 v5(50.73,102.74) ; v2(56.78,99.33) 57.23,99.78 UV1.P17 ; UV5.J8 33.52,104.62 v2(33.16,104.26) ; v5(60.02,88.53) 60.23,88.74 UV1.AF14 UV1.AE14 59.83,91.14 v5(59.82,91.14) ; v2(70.65,107.33) 70.61,107.29 UV1.E2 ; v3(66.41,92.77) 66.02,93.16 66.02,93.18 UV1.AB7 ; UV1.T11 v2(63.73,98.34) UV1.R10 ; UV1.N18 56.13,100.84 v5(55.64,100.34) ; v5(60.65,106.94) 60.63,106.94 UV1.E14 ; UV1.H23 52.34,105.19 v5(52.34,105.22) ; UV1.N12 62.22,100.84 v5(61.75,100.37) 61.23,99.85 UV1.P13 61.23,99.79 v5(60.79,99.35) 60.28,98.84 UV1.R14 ; v5(71.33,110.14) UV1.B1 ; v5(60.8,95.45) 61.19,95.84 UV1.V13 ; UV1.E20 v5(54.87,106.94) ; 63.73,100.34 UV1.P11 ; 63.73,100.34 v5(63.77,100.34) ; v5(49.92,91.99) 49.93,91.99 UV1.AC26 ; v5(61.16,104.45) 61.23,104.38 UV1.K13 ; UV1.E22 53.24,107.73 v5(53.19,107.73) ; v5(70.53,110.94) UV1.A2 ; UV1.AE20 55.29,90.74 v5(55.68,91.14) 55.71,91.14 UV1.AD19 UV1.AD18 56.94,91.54 v5(57.34,91.14) 57.35,91.14 UV1.AE17 ; UV1.A26 50.33,110.59 v5(49.93,110.99) ; UV1.R16 58.26,98.84 v5(58.74,99.32) 59.23,99.81 UV1.P15 ; v2(334.86,178.55) 334.86,178.32 335.23,177.95 JIO1.1 ; v5(50.72,107.71) 50.72,107.7 UV1.E25 ; UV1.H25 50.73,105.2 v5(50.73,105.22) ; UV1.N14 60.27,100.84 v5(60.77,101.34) 60.77,101.38 UV1.M13 61.71,102.32 v2(61.73,102.32) 62.23,102.82 UV1.L12 ; UV1.T15 59.22,97.84 v5(58.71,97.33) 58.23,96.85 UV1.U16 ; UV1.T17 57.23,97.86 v2(56.78,98.31) 56.25,98.84 UV1.R18 ; v5(64.77,106.92) UV1.E8 ; UV1.V17 57.22,95.84 56.69,96.37 v5(56.56,96.37) 56.23,96.7 UV1.U18 ; UV1.V15 59.22,95.84 58.86,95.48 v5(58.73,95.48) ; UV1.L23 v5(53.15,102.74)
  BOTTOM w0.356: JDIMM2.19 167.88,27.7 v2(167.6,27.98) ; JDIMM2.63 181.08,24.88 v2(181.96,24) ; v2(136.05,16.84) 135.53,16.84 135.08,17.29 JDIMM1.150 ; v2(133.33,19.62) 133.28,19.57 JDIMM1.144 ; JDIMM2.65 181.68,27.4 182.27,27.99 v2(183.26,27.99) ; v2(140.11,16.76) 140.48,17.12 JDIMM1.168 ; JDIMM2.13 166.08,27.67 v2(166.4,28) ; JDIMM1.153 135.98,27.6 v2(136.16,27.78) ; JDIMM1.49 102.38,27.6 v2(102.2,27.78) ; JDIMM2.168 v2(214.98,16.83) ; v2(206.56,27.73) 206.28,27.45 JDIMM2.139 ; v2(104.31,27.77) 104.31,27.82 104.18,27.69 JDIMM1.55 ; JDIMM1.189 146.78,27.36 v2(147.73,28.32) ; v2(102.78,16.75) 103.44,16.75 103.88,17.18 JDIMM1.54 ; v2(98.8,27.83) 98.78,27.81 JDIMM1.37 ; JDIMM1.66 107.48,17.32 v2(107.96,16.84) ; JDIMM2.185 v2(220.08,27.81) ; v2(97.06,27.84) 96.98,27.76 JDIMM1.31 ; JDIMM2.162 v2(213.18,16.84) ; JDIMM1.185 145.58,27.7 145.51,27.77 v2(145.51,27.85) ; JDIMM1.127 128.18,25.04 v2(127.82,24.69) ; JDIMM2.61 180.48,27.87 180.5,27.9 v2(180.5,28) ; v2(91.35,28.71) 91.56,28.71 92.02,28.25 92.02,27.85 91.58,27.41 JDIMM1.13 ; JDIMM1.71 108.98,28.11 108.6,28.49 v2(107.84,28.49) ; JDIMM1.14 v2(91.88,19.84) ; JDIMM2.153 210.48,27.49 210.41,27.55 210.41,28 210.87,28.46 v2(211.01,28.46) ; v2(106.04,16.78) 106.04,16.84 105.68,17.19 JDIMM1.60 ; JDIMM1.44 v2(100.88,16.84) ; JDIMM1.178 v2(143.48,16.84) ; JDIMM2.187 220.68,28.45 v2(220.18,28.94) ; v2(163.23,23.87) 163.08,24.02 JDIMM2.3 ; v2(204.69,16.82) 204.78,16.91 JDIMM2.134 ; v2(221.66,16.83) 221.58,16.91 JDIMM2.190 ; v2(106.59,28.38) 106.52,28.46 106.4,28.46 105.98,28.04 JDIMM1.61 ; JDIMM1.170 141.08,16.96 v2(140.88,16.76) ; JDIMM2.25 169.68,27.87 169.71,27.9 v2(169.71,28.01) ; JDIMM2.196 v2(223.38,16.75) ; v2(148.18,27.82) 148.31,27.82 148.58,27.56 JDIMM1.195 ; JDIMM1.128 128.48,19.51 v2(128.3,19.68) ; v2(131.25,27.86) 131.35,27.86 131.78,27.43 JDIMM1.139 ; JDIMM2.2 v2(162.78,19.63) ; v2(208.17,28.46) 208.96,28.46 209.88,27.54 JDIMM2.151 ; v2(173.35,27.97) 173.35,27.87 173.28,27.8 JDIMM2.37 ; v2(214.95,27.79) 214.68,27.51 JDIMM2.167 ; JDIMM2.55 178.68,27.61 178.98,27.91 v2(178.98,27.98) ; JDIMM1.20 93.68,16.76 93.78,16.76 v2(93.87,16.67) ; JDIMM1.72 109.28,17.3 v2(108.8,16.82) ; JDIMM2.144 v2(207.78,16.84) ; JDIMM1.38 v2(99.08,16.84) ; v2(138.86,28.38) 139.71,28.38 140.18,27.91 JDIMM1.167 ; v2(208.17,27.84) 208.08,27.74 JDIMM2.145 ; JDIMM2.172 v2(216.18,16.84) ; v2(147.29,28.76) 146.18,27.65 JDIMM1.187 ; JDIMM1.48 102.08,19.16 101.54,19.7 101.54,20.72 v2(101.67,20.85) ; v2(135.76,28.25) 135.84,28.33 136.36,28.33 136.72,27.98 136.72,27.57 136.58,27.43 JDIMM1.155 ; v2(134.61,27.81) 134.91,27.81 135.38,27.34 JDIMM1.151 ; JDIMM2.189 v2(221.28,27.82) ; JDIMM1.43 v2(100.58,27.83) ; JDIMM2.20 v2(168.18,19.62) ; JDIMM2.54 v2(178.38,19.63) ; v2(93.44,27.78) 93.44,27.73 93.38,27.67 JDIMM1.19 ; v2(206.23,16.84) 206.23,16.85 205.98,17.1 JDIMM2.138 ; v2(182.79,21.42) 182.95,21.58 183.84,21.58 184.37,21.04 184.37,19.54 183.78,18.95 JDIMM2.72 ; JDIMM1.156 v2(136.88,16.84) ; v2(131.6,20.57) 130.88,19.84 JDIMM1.136 ; JDIMM1.25 95.18,27.66 v2(95.29,27.77) ; v2(129.46,27.86) 129.57,27.86 129.98,27.45 JDIMM1.133 ; v2(142.81,27.81) 142.15,27.81 141.98,27.64 JDIMM1.173 ; JDIMM1.11 90.98,27.69 v2(91.35,28.06) ; JDIMM1.179 143.78,28.27 143.89,28.38 v2(143.89,28.48) ; JDIMM1.162 v2(138.68,16.84) ; JDIMM1.2 88.28,18.87 87.85,19.3 v2(87.85,19.6) ; v2(169.82,19.63) 169.98,19.46 JDIMM2.26 ; JDIMM1.172 v2(141.68,16.84) ; JDIMM2.150 v2(209.58,16.84) ; JDIMM2.44 v2(175.38,19.63) ; JDIMM2.136 205.38,16.84 v2(205.38,16.84) ; v2(204.71,27.85) 204.48,27.62 JDIMM2.133 ; JDIMM2.31 171.48,27.47 170.95,27.99 v2(170.85,27.99) ; v2(217.86,27.94) 218.28,27.52 JDIMM2.179 ; v2(97.81,16.8) 97.68,16.8 97.28,17.2 JDIMM1.32 ; v2(211.01,27.82) 211.08,27.75 JDIMM2.155 ; JDIMM2.184 v2(219.78,16.84) ; JDIMM2.38 v2(173.58,19.63) ; JDIMM1.65 107.18,27.56 107.43,27.81 v2(107.91,27.81) ; v2(175.7,27.98) 176.68,27.98 176.88,27.77 JDIMM2.49 ; v2(106.54,27.8) 106.58,27.76 JDIMM1.63 ; JDIMM2.128 v2(202.98,16.84) ; JDIMM2.173 216.48,27.49 215.59,28.38 v2(214.98,28.38) ; JDIMM1.134 130.28,16.88 v2(130.46,16.7) ; JDIMM1.3 88.58,25.17 v2(88.04,24.63) ; v2(212.76,27.83) 212.88,27.71 JDIMM2.161 ; v2(165.49,27.99) 165.48,27.98 JDIMM2.11 ; JDIMM2.60 v2(180.18,19.63) ; v2(174.05,28.13) 174.53,28.13 175.08,27.58 JDIMM2.43 ; JDIMM2.66 181.98,19.62 v2(182,19.64) ; v2(90.26,27.93) 90.24,27.9 90.24,27.54 90.38,27.4 JDIMM1.9 ; v2(96.21,19.6) 96.08,19.47 JDIMM1.28 ; JDIMM1.46 v2(101.48,16.86) ; JDIMM1.8 90.08,16.9 89.75,16.57 v2(89.68,16.57) ; JDIMM1.26 v2(95.48,16.89) ; JDIMM1.196 v2(148.88,16.84) ; v2(170.85,19.68) 170.58,19.41 JDIMM2.28 ; JDIMM2.127 202.68,27.63 201.86,28.44 v2(201.7,28.44) ; v2(176.58,19.77) JDIMM2.48 ; v2(131.54,19.7) 131.48,19.64 JDIMM1.138 ; v2(133.48,27.81) 133.58,27.71 JDIMM1.145 ; JDIMM2.170 v2(215.58,16.82) ; JDIMM2.14 v2(166.38,19.63) ; v2(164.27,28) 164.38,28 164.88,27.51 JDIMM2.9 ; JDIMM1.184 v2(145.28,16.84) ; JDIMM2.71 183.48,27.29 184.14,27.95 v2(184.45,27.95) ; JDIMM2.178 v2(217.98,16.84) ; JDIMM1.190 v2(147.08,16.84) ; JDIMM2.195 v2(223.08,27.82) ; JDIMM2.32 v2(171.78,19.63) ; JDIMM2.156 v2(211.38,16.84) ; v2(138.86,27.79) 138.64,27.79 138.38,27.52 JDIMM1.161
  BOTTOM w0.381: RC169.2 174.18,70.85 174.49,70.55 175.43,70.55 v2(175.45,70.52) ; U30.3 v2(246.51,151.82) ; v2(185.12,80.85) 185.12,80.82 184.79,80.49 184.57,80.49 184.18,80.1 UC2.3 ; v2(24.95,72.45) 24.88,72.45 24.65,72.22 24.65,72.17 24.2,71.72 US1.1 ; RC240.2 121.16,74.22 121.68,74.74 v3(122.01,74.74) ; Q125.4 v2(86.73,147.33) ; v2(223.97,106.54) 224.06,106.45 Q19.4 ; U86.3 v2(92.16,142.61) ; UV14.3 v2(97.87,79.98)
  BOTTOM w0.4: v5(67.31,96.96) 67.71,97.36 UV1.U5 ; UV1.P23 52.73,99.86 v5(53.13,100.26) ; v5(70.59,94.5) 70.21,94.88 UV1.Y2
  BOTTOM w0.406: v5(62.3,93.58) 62.7,93.18 UV1.AB11
  BOTTOM w0.432: Q140.1 95.92,162.1 95.65,161.84 v2(95.65,161.45)
  BOTTOM w0.457: v2(27.4,29.24) 27.68,28.96 C217.1 ; R214.2 16.51,25.24 v2(16.05,25.7) ; RV88.1 69.34,84.46 v3(69.59,84.21) ; C152.2 88.92,74.71 89.09,74.89 89.09,76.03 v2(89.14,76.08) ; v2(125.94,62.55) 125.52,62.98 RC129.2 ; JMINI2.9 234.9,144.5 235.02,144.61 v2(235.73,144.61) ; v2(197.04,174.36) 196.39,173.7 196.39,172.84 196.41,172.82 C194.2 ; Q19.1 v2(223.87,105.15)
  BOTTOM w0.508: v2(200.98,65.11) 200.98,65.49 200.65,65.82 U2.4 ; C230.1 v2(28.7,20.21) ; v2(97.18,84.52) 96.9,84.24 RC22.2 ; C2988.2 186.45,174.15 v2(186.55,174.26) ; C142.2 289.58,144.82 v2(289.45,144.94) ; v2(14.22,30.4) 14.73,30.4 C228.2 ; JSD1.24 24.03,36.42 v2(24.82,35.64) ; v3(198.52,75.1) 198.52,75.41 JTAA1.22 ; v2(255.64,152.67) 256.18,153.2 C249.2 ; v2(318.72,186.74) 318.7,186.76 JMINI1.35 ; RV2654.2 75.82,110.69 v2(75.96,110.83) ; v2(299.15,158.1) 299.15,157.8 299.56,157.39 299.91,157.39 C410.2 ; RC127.1 98.95,80.1 v2(98.77,79.92) ; JMINI2.21 235.46,152.5 v2(235.68,152.72) ; PR309.2 v2(77.87,96.8) ; PC306.2 78.06,85.14 78.63,84.57 v2(78.88,84.57) ; RV2440.2 31.89,114.5 32.15,114.76 v2(32.73,114.76) ; R2678.2 96.16,140.37 v2(95.37,139.58) ; v2(182.06,75.55) 182.26,75.35 RC198.2 182.69,74.89 183.33,74.26 183.84,74.26 ; JMINI1.54 326.47,187.6 v2(326.41,187.54) ; RV2652.2 75.85,107.99 v2(76.09,108.24) ; C135.2 307.91,161.75 C136.2 308.64,161.44 308.93,161.15 v2(308.93,160.54) ; C405.2 312.48,158.63 312.56,158.55 v2(312.56,157.72) ; v2(205.86,62.75) 206.7,62.75 C76.1 ; v2(324.3,176.24) C261.1 C260.1 ; JMINI1.21 313.1,186.68 v2(313.12,186.65) ; v2(63.55,53.97) 63.11,53.97 PC675.2 63.04,54.7 v2(63.58,54.7) ; CV2951.2 CV2955.2 31.2,85.66 31.64,86.1 v2(31.64,86.09) ; PD2.1 88.97,169.86 v2(88.15,170.67) ; C50.2 v2(13.61,16.58) ; C119.2 310.23,159.69 v2(310.23,160.54) ; v2(15.76,30.01) 15.89,29.88 16.4,29.88 C219.1 16.62,29.76 C229.2 ; v2(307.15,186.47) 307.5,186.82 JMINI1.15 ; JSATA1.4 218.45,133.19 v2(217.57,134.07) ; CC3.1 199.25,59.68 ME1.1 199.38,59.7 v2(199.86,60.18) ; CV2945.2 27.37,112.93 v2(27.76,112.54) ; v2(31,114.76) RV2906.1 30.99,114.06 CV2948.2 ; PD1.1 89.2,167.92 v2(88.9,168.21) ; v3(210.11,81.88) 209.95,82.03 JTAA1.25 209.06,81.16 v3(210.23,81.16) ; PC106.2 v2(43.88,10.65) ; v2(258.74,180.1) 258.99,179.85 JSIM1.2 ; PC614.2 v2(63.56,29.6) ; v2(311.92,181.39) 311.9,181.37 JMINI1.18 ; JMINI2.4 241.25,142.5 v2(240.88,142.86) ; JMINI1.27 315.5,186.69 v2(315.23,186.42) ; v2(93.03,78.37) 92.8,78.14 C154.2 ; C247.2 v2(10.99,71.16) ; CD1.2 80.08,28.56 v2(79.52,29.12) ; JMINI1.34 318.3,181.36 v2(318.32,181.38) ; v2(193.1,170.55) 193.1,170.86 192.73,171.23 C192.2 ; C145.2 266.95,177.84 v2(266.92,177.81) ; v2(210.23,80) 209.05,80 JTAA1.23 210.81,79.13 211.12,79.44 v2(211.12,79.97) ; v2(33.16,55.36) R53.2 C273.2 ; v3(87.19,79.16) 87.19,78.32 C153.2 ; v2(94.5,173.6) 95.02,173.07 PR21.2 ; PC677.2 59.91,57.28 v2(59.88,57.26) ; v2(221.59,111.6) JSATA1.17 ; v2(93.23,140.37) 93.18,140.32 C458.1 ; PC10.2 v2(93.82,172.72) ; v2(19.7,34.2) 19.32,33.82 C220.1 ; CV2966.2 v2(29.36,85.87) ; v2(18.22,27.27) 17.97,27.02 C227.2 ; v2(261.13,156.88) 260.8,156.56 C427.2 ; JMINI2.26 v2(240.81,154.5) ; JMINI2.35 232.78,158.1 232.53,158.35 v2(232.53,158.36) ; JSATA1.7 220.93,129.38 v2(221.78,130.24) ; JSD1.3 29.67,47.9 v2(28.91,48.66) ; v2(304.36,159.75) 304.83,159.75 C118.2 ; C114.2 223.84,125.99 v2(224.6,126.76) ; JSD1.21 29.21,50.75 v2(28.07,51.89) ; C239.2 v2(32.45,48.6) ; v2(76.09,109.03) 75.93,108.87 RV2648.2 ; R167.2 312.94,162.22 v3(313.02,162.14) ; CV2940.2 36.07,112.57 v2(36.03,112.54) ; JMINI2.43 v2(235.47,161.3) ; v2(40.84,85.9) CV2920.2 ; v2(122.84,80.13) 122.79,80.18 RC258.2 ; v2(36.55,24.85) 36.67,24.98 PR702.1 ; C5.2 213,68.67 v2(212.66,69) ; PR109.2 v2(34.66,9.69) ; v2(164.43,19.77) 164.58,19.63 JDIMM2.8 ; C225.1 v2(17.08,20.62) ; v2(49.75,118.62) 49.94,118.44 CV232.2 ; U33.1 101.22,142.21 v2(100.65,142.79) ; v2(60.98,115.86) 60.72,115.61 RV45.1 ; SW6.4 248.05,124.02 v2(248.57,124.54) ; v2(210.25,74.92) 208.94,76.23 JTAA1.21 ; JSIM1.10 247.52,185.1 246.68,185.94 v2(246.37,185.94) ; D88.1 v2(98.72,164.78) ; CC8.2 180.76,78.47 180.15,77.86 v2(180.14,77.86) ; v2(32.73,114.76) 32.84,114.64 RV2438.2 ; v2(32.73,114.76) 32.91,114.94 CV2901.2 ; v2(29.45,26.16) C255.2 C210.2 ; v2(6.98,19.93) 6.98,19.93 JBT1.3 ; v2(87.29,85.43) 86.76,84.9 PC310.2 ; v2(14.62,32.29) 14.45,32.13 R27.2 ; C232.1 C233.1 v2(23.11,33.68) ; JDIMM2.46 175.98,19.96 v2(175.97,19.96) ; CV2956.2 38.36,85.23 v2(38.74,84.85) 38.74,84.66 38.43,84.34 CV2928.2 ; RV90.1 RV89.1 RV2441.1 v2(58.87,115.74) ; PC420.2 v2(130.55,180.3) ; C226.1 18.34,23.34 v2(18.61,23.6) ; PC309.2 88.22,84.54 v2(88.92,84.54) ; v2(178.27,76.92) 177.75,76.92 RC306.1 ; C338.2 v2(246.7,148.7) ; v2(249.77,174.28) 248.91,175.15 JSIM1.12 ; v2(305.37,186.52) 305.1,186.8 JMINI1.9 ; PR306.2 84.05,95.93 PC300.2 84.89,95.74 v2(84.91,95.72) ; v2(53.36,81.83) 52.98,82.2 RV2703.2 ; v2(26.74,118.78) 26.95,119 QV2806.1 ; C224.1 15.67,24.06 v2(16.12,23.61) ; PC150.1 PC151.1 74.69,69.89 v2(74.57,70.01) ; JMINI2.29 233.06,155.7 v2(232.66,155.3) 233.07,154.9 JMINI2.27 ; v2(176.57,172.55) 176.57,172.41 176.58,172.4 176.58,172.06 176.9,171.74 C25.2 ; PC419.2 130.55,176.36 v2(130.79,176.12) ; v2(90.52,75.32) 90.52,75.02 90.21,74.71 C163.2 ; v2(24.9,96.76) 25.35,96.32 RV2908.1 ; JMINI2.15 v2(232.55,146.9) ; C461.2 104.85,142.72 v2(105.05,142.53) ; C120.2 v2(306.32,160.21) ; PC116.2 v2(68.29,16.7) ; CV2947.2 27.37,114.49 v2(27.57,114.69) ; PC317.2 84.28,86.08 v2(84.28,87.09) ; JSIM1.11 266.27,177.31 266.18,177.41 v2(266.18,177.76) ; JMINI1.43 321.9,186.71 v2(321.91,186.7) ; v2(55.34,21.14) 53.66,22.83 PR616.1 ; v2(19.69,19.92) 19.69,20.61 C214.2 ; CE20.2 75.76,24.29 CE14.2 ; v2(182.32,82.04) 183.52,82.04 RC76.2 ; v2(47.18,9.54) 47.78,9.54 PR103.2 ; v2(216.81,119.86) 217.45,119.22 JSATA1.11 ; v2(29.59,39.51) 30.36,38.75 JSD1.22 ; JIO1.81 341.33,157.33 342.46,158.45 v2(342.46,161.01) ; C137.2 v2(318.74,158.53) ; SW6.6 249.9,123.35 v2(251.1,124.55) ; C240.2 32.45,53.33 32.15,53.63 v2(31.89,53.63) ; CV87.2 v2(96.71,76.03) ; C212.2 19.6,20.67 C214.2 ; C451.2 96.84,161.58 v2(96.41,161.58) ; v2(53.52,26.92) PC624.2 PR624.2 PR625.2 PR622.1 ; C130.2 306.06,161.07 v3(306.29,160.84) ; PC679.2 v2(66.81,61.31) ; v2(14.88,112.94) R474.2 16.37,112.33 16.88,111.82 16.88,110.35 16.52,109.99 QZ22.4 ; PC107.1 v2(40.82,17.27) ; PC623.1 53.07,25.14 v2(53.53,25.6) ; RC233.2 RC241.2 118.16,74.02 v2(117.95,74.23) ; R211.2 21.14,33.46 C215.2 21.58,33.7 v2(22.23,33.7) ; PR635.2 PC621.1 v2(57.8,35.34) ; PC112.2 40.63,9.69 v2(40.94,9.38) ; U1.4 204.87,71.03 v2(205.4,71.56) ; PC625.2 PC626.2 51.65,29.98 51.51,29.84 50.46,29.84 v2(50.36,29.74) ; PR305.2 86.56,96.55 v2(86.56,96.55) ; PC12.2 v2(97.34,150.85) ; PC678.2 63.53,57.41 v2(63.68,57.26) ; v5(55.27,88.57) 57.7,88.57 v5(57.75,88.52) 60.01,88.52 v5(60.02,88.53) 61.97,88.53 v5(62.1,88.41) v5(62.71,88.41) ; PC157.2 81.04,72.5 v2(81.04,73.06) ; v2(29.16,28.76) 29.16,28.94 29.68,29.46 C234.1 ; v2(300.68,154.16) 300.85,154.34 C123.2 ; v2(98.03,72) 97.65,72.38 97.65,72.68 CC41.2 ; C259.2 v2(302.18,176.21) ; PR204.2 234.25,88.26 v2(233.63,87.64) ; PH302.2 v2(44.89,45.85) ; v2(98.7,72) 98.67,72.02 RC131.1 ; JSATA1.1 217.84,137 v2(217.77,137.07) ; v2(77.36,26.2) 77.99,25.56 RC221.2 ; v2(198.92,83.2) 198.92,82.45 JTAA1.26 ; CE14.2 v2(75.07,25.18) ; CE14.2 CE22.2 ; CV3060.2 v2(47.52,118.96) ; JSIM1.9 265.75,185.1 v2(264.56,186.3) ; C111.2 225.74,114.43 v2(226.56,115.25) ; PC506.2 132.63,176.16 133.11,176.64 v2(133.11,177.58) ; C456.2 RC324.1 103.55,126.88 v2(103.88,126.55) ; R205.1 25.27,20.57 v2(25.27,20.05) ; CV2946.2 30.06,112.74 v2(30.37,112.43) ; PC680.2 63.63,56.01 v2(63.69,55.95) ; SW6.5 250.61,128.4 251.7,129.49 v2(252.22,129.49) ; v2(18.88,30.4) 18.46,30.82 C216.1 ; R268.2 C310.2 176.02,174.47 v2(176.02,175.17) ; JSATA1.13 220.67,116.68 v2(221.76,117.77) ; v2(299.44,185.56) 299.05,185.95 JMINI1.53 ; v2(205.59,60.08) CMOS1.1 204.3,60.53 CC4.1 ; C241.2 v2(15.71,22.11) ; PC105.2 v2(42.1,10.78) ; C231.1 v2(27.62,20.4) ; v2(228.34,82.21) 228.26,82.28 PC205.2 ; C129.2 301.05,151.29 v2(299.68,152.66) 299.68,151.44 C144.2 ; C455.2 v2(94.05,167.04) ; RC195.2 78.17,24.14 78.5,23.81 v2(78.91,23.81) ; 11.4,36.9 12.36,37.86 v2(12.79,37.86) ; R163.2 v2(318.51,161.33) ; v2(56.28,115.61) 56.02,115.61 55.64,115.23 RV92.1 ; C139.2 298.52,161.07 297.04,159.6 v2(297.04,159.63) ; JBT1.4 6.8,26.28 v2(6.8,26.28) ; v2(30.05,28.81) 30.05,27.97 C223.1 ; C440.2 83.95,157.83 v2(83.16,157.05) ; v2(34,24.78) 33.88,24.9 PC708.2 ; RC232.2 v2(121.16,71.21) ; v2(13.58,23.3) 13.58,23.18 14.11,22.64 C213.2 ; v2(59.88,55.95) 59.94,56.01 PC676.2 ; PC115.2 v2(33.05,14.28) ; RV29.2 v2(97.65,76.03) ; PC401.2 101.46,171.87 v2(101.26,171.66) ; v2(240.79,151.33) 240.82,151.3 JMINI2.18 ; v2(257.76,152.31) C425.2 258.72,151.9 v2(258.31,151.5) ; v2(160.39,172.25) PC504.2 ; v2(236.67,140.07) 235.05,138.45 JMINI2.53 ; C85.1 195.47,61.51 v2(195.34,61.63) ; CV2957.2 CV2953.2 34.67,84.19 v2(33.98,83.5) ; v2(28.21,83.5) 27.04,83.5 26.67,83.88 CV2961.2 ; PC303.2 v2(95.58,108.43) ; C246.2 v2(9.61,70.65) ; JSD1.6 28.9,55 v2(28.7,55.19) ; v2(235.47,165.49) 234.7,166.27 JMINI2.54 ; RV2447.2 v2(27.04,102.52) ; v2(232.89,93.86) PR205.2 PC206.2 ; v2(224.91,128.1) 225.65,128.85 JSPK1.5 ; 51.8,82.58 51.8,83.7 CV3051.2 ; JIO1.82 v2(336.09,179.08) ; v2(315.12,181.39) 315.1,181.37 JMINI1.26 ; v2(60.02,53.97) 60.51,53.97 PC674.2 60.59,54.68 v2(60.01,54.68) ; RV93.1 v2(76.26,114.38) ; C290.2 v2(19.62,86.98) ; C122.2 298.16,155.84 v2(298.36,156.04) ; v2(192.01,72.08) 190.67,72.08 190.31,71.72 C6.2 ; C121.2 301.11,158.1 v2(299.89,158.1) ; v2(12.93,27.89) 14.01,27.89 14.37,27.53 C211.2 ; v2(78.12,73.06) 78.25,72.94 PC156.1 ; C248.2 v2(245.94,165.85) ; PC111.2 v2(33.49,18.12) ; v3(182.06,171.87) 181.88,171.69 C2992.2 ; RV2437.2 33.16,83.83 v2(32.9,83.58) 32.65,83.58 32.2,84.02 RV2439.2 ; PC319.2 v2(83.58,82.92) ; C422.2 v2(264.3,151.24) ; PR516.2 v2(153.81,175.68) ; R121.1 165.62,173.37 v2(166.13,173.87) ; RV46.1 v2(61.61,115.86) ; JMINI2.34 242.29,157.71 v2(240.92,157.71) ; JBT1.2 12.19,24.23 v2(12.77,24.8) ; RC239.2 120.55,72.94 v2(120.41,72.81) ; v2(316.32,186.32) 316.3,186.34 JMINI1.29 ; R26.2 v2(249.65,152.61) ; CV2919.2 38.11,112.98 37.6,112.47 v2(37.35,112.47) ; RV2442.2 v2(59.76,115.71) ; PC114.2 v2(36.32,9.69) ; JMINI2.50 v2(244.34,164.1) ; PR602.2 62.75,25.58 62.47,25.31 v2(61.64,25.31) ; JMINI1.4 303.1,181.12 v2(303.52,181.55) ; C409.2 v2(261.76,156.89) ; PR308.2 80.53,96.36 v2(80.97,96.8) 81.42,96.35 PR307.2 ; RV2436.2 v2(75.4,106.39) ; C206.2 v2(204.03,167.93) ; PC613.2 57.34,22.12 PC619.2 57.35,21.54 56.68,20.87 v2(55.95,20.87) ; v2(226.56,122.69) 225.86,123.39 C113.2 ; RC260.2 v2(123.97,82.08) ; CD2.2 79.39,27.47 v2(79.26,27.34) ; PC301.2 87.45,96.1 v2(87.9,96.55) 88.34,96.1 PR310.2 ; R160.2 v3(309.57,160.51) ; C454.2 v2(92.85,161.12) ; CV3058.2 v2(46.13,118.82) ; v2(127.57,16.6) CD12.2 CD13.2 ; CV2964.2 v2(26.67,86.12) ; v2(29.36,83.64) CV2968.2 ; JTAA1.24 v2(200.68,79.13) ; v2(52.8,118.78) 52.25,118.23 CV3059.2 ; PR708.2 v2(32.99,24.85) ; v2(221.59,109.06) JSATA1.19 ; JMINI1.50 v2(324.7,181.39) ; C258.2 v2(299.56,176.21) ; PC414.2 v2(101.29,170.98) ; C214.2 C218.1 ; PC503.2 v2(160.52,173.52) ; RV2650.2 v2(75.96,112.56) ; C408.2 v2(319,159.93) ; C112.2 v2(225.06,115.99)
  vias: v2(0.53,61.15) v2(0.53,53.4) v2(0.53,45.83) v2(0.53,37.38) v2(1.31,113.55) v2(1.29,92.8) v2(1.34,87.9) v2(1.29,33.79) v2(1.29,26.17) v2(1.31,7.63) v2(1.36,121.86) v2(1.36,67.09) v2(1.77,11.85) v2(2.2,52.49) v2(2.3,61.86) v2(2.38,43.01) v2(2.35,18.4) v2(2.59,71.6) v2(3.95,37.81) v2(4.74,55.33) v2(5.1,46.29) v2(5.2,110.98) v2(6.81,94.51) v2(7.18,62.06) v2(7.25,37.93) v2(7.95,64.41) v2(8.47,57.49) v2(9.77,50.99) v2(10.63,121.88) v2(10.77,65.39) v2(12.49,61.51) v2(12.82,42.3) v2(13.55,125.69) v2(13.55,119.42) v2(13.86,118.86) v2(14.19,119.39) v2(15.18,95.82) v2(15.15,95.16) v2(15.15,94.5) v2(15.15,93.81) v2(15.23,7.45) v2(15.61,56.91) v2(15.89,42.46) v2(17.29,61.61) v2(17.92,125.84) v2(18.43,109.18) v2(19.02,48.81) v2(19.12,7.99) v2(19.22,41.01) v2(20.84,102.96) v2(20.76,102.09) v2(20.76,100.29) v2(20.89,106.18) v2(20.85,104.76) v2(21.12,99.55) v2(21.12,97.72) v2(21.08,28.32) v2(21.12,26.61) v2(21.08,24.93) v2(21.13,19.47) v2(21.3,108.11) v2(22.78,31.43) v2(22.81,28.3) v2(22.79,26.6) v2(22.81,24.89) v2(22.77,19.29) v2(23.39,78.51) v2(23.41,77.3) v2(23.59,60.72) v2(23.82,18.66) v2(23.86,103.73) v2(24.14,100.65) v2(24.45,28.3) v2(24.45,26.58) v2(24.47,24.89) v2(24.69,76.75) v2(24.81,78.08) v2(24.93,97.83) v2(25.14,73.63) v2(25.37,39.76) v2(25.39,22.72) v2(25.54,125.84) v2(25.72,101) v2(26.43,50.71) v2(26.51,64.35) v2(26.53,20.99) v2(26.61,44.78) v2(26.69,27.75) v2(26.86,7.99) v2(27.19,46.41) v2(27.63,37.78) v2(28.29,52.97) v2(28.39,47.86) v2(28.46,100.37) v2(29.2,98.51) v2(29.33,40.42) v2(29.73,60.87) v2(29.84,24.34) v2(29.96,99.4) v2(31.3,30.92) v2(31.79,32.02) v2(32.27,61.63) v2(33.16,125.84) v2(33.93,30.39) v2(33.93,29.24) v2(34.41,8.01) v2(34.79,53.5) v2(34.83,29.81) v2(35.42,53.5) v2(35.71,30.26) v2(35.71,29.37) v2(36.06,53.5) v2(36.69,53.5) v2(36.66,36.74) v2(36.66,36.1) v2(36.97,37.24) v2(37.33,53.5) v2(37.36,36.74) v2(37.36,36.1) v2(37.74,37.24) v2(38.05,36.74) v2(38.05,36.1) v2(38.5,37.24) v2(38.56,36.42) v2(39.95,99.2) v2(40.56,99.2) v2(40.78,125.84) v2(42.23,8.01) v2(43.93,23.41) v2(44.57,23.43) v2(44.62,17.36) v2(44.95,16.78) v2(45.15,38.62) v2(45.15,37.35) v2(45.2,23.41) v2(45.28,17.36) v2(45.84,53.59) v2(45.91,50.63) v2(46.24,84.11) v2(46.24,82.84) v2(46.45,54.24) v2(46.45,53.58) v2(46.57,50.63) v2(46.56,50.02) v2(46.88,84.11) v2(46.88,82.84) v2(47.05,38.04) v2(47.24,36.33) v2(47.31,38.68) v2(47.31,37.41) v2(47.63,36.84) v2(47.69,38.04) v2(47.92,108.95) v2(47.94,38.68) v2(47.94,37.41) v2(47.94,36.33) v2(48.4,125.84) v2(48.94,54.13) v2(48.94,53.39) v2(49.72,37.98) v2(49.72,8.01) v2(49.84,14.57) v2(49.84,13.93) v2(49.84,13.3) v2(49.84,12.66) v2(49.84,12.03) v2(49.97,38.62) v2(49.97,37.35) v2(50.35,37.98) v2(50.48,14.57) v2(50.48,13.93) v2(50.48,13.3) v2(50.48,12.66) v2(50.48,12.03) v2(50.58,66.65) v2(50.62,65.61) v2(50.61,38.62) v2(50.61,37.35) v2(50.99,37.98) v2(51.11,14.57) v2(51.11,13.93) v2(51.11,13.3) v2(51.11,12.66) v2(51.11,12.03) v2(51.24,38.62) v2(51.24,37.35) v2(51.32,81.44) v2(51.96,81.44) v2(52.4,91.14) v2(53.02,38.62) v2(53.13,126.07) v2(53.4,37.98) v2(53.66,38.62) v2(53.66,37.35) v2(54.04,37.98) v2(54.42,38.62) v2(54.42,37.35) v2(54.67,37.98) v2(55.05,38.62) v2(55.05,37.35) v2(55.31,37.98) v2(55.44,39.25) v2(55.69,38.62) v2(55.69,37.35) v2(55.94,37.98) v2(56.32,38.62) v2(56.32,37.35) v2(56.39,29.6) v2(56.45,28.07) v2(56.58,37.98) v2(56.78,111.77) v2(56.96,38.62) v2(56.96,37.35) v2(57.21,37.98) v2(57.25,79.89) v2(57.32,28.79) v2(57.34,7.99) v2(57.59,38.62) v2(57.59,37.35) v2(57.67,78.13) v2(57.83,77.42) v2(57.91,37.98) v2(58.04,29.6) v2(58.1,28.07) v2(58.33,127.16) v2(58.47,80.62) v2(58.74,45.47) v2(58.74,43.7) v2(58.74,42.17) v2(59.12,40.27) v2(59.12,39.5) v2(59.43,80.99) v2(60.34,41.64) v2(60.38,44.92) v2(60.39,43.45) v2(62.22,91.15) v2(62.6,128.79) v2(62.69,78.85) v2(62.87,77.25) v2(63.95,93.64) v2(64.3,85.1) v2(64.91,84.97) v2(64.96,7.99) v2(65.2,38.25) v2(65.29,86.83) v2(65.33,37.52) v2(65.4,78.83) v2(65.72,37.98) v2(65.97,38.62) v2(66.1,37.35) v2(66.44,90.33) v2(66.36,37.98) v2(66.59,78.8) v2(66.61,38.62) v2(66.74,37.35) v2(66.99,37.98) v2(67.17,82.89) v2(67.24,38.62) v2(67.37,37.35) v2(67.61,79.36) v2(67.63,37.98) v2(67.61,28) v2(67.83,28.97) v2(67.88,38.62) v2(68.04,131.99) v2(68.01,37.35) v2(68.26,37.98) v2(68.39,27.98) v2(68.51,38.62) v2(68.49,28.97) v2(68.64,37.35) v2(68.9,37.98) v2(69.15,38.62) v2(69.08,27.95) v2(69.23,28.94) v2(69.28,37.35) v2(69.53,37.98) v2(69.58,79.31) v2(69.78,38.62) v2(69.94,77.41) v2(69.91,37.35) v2(70.17,37.98) v2(70.42,38.62) v2(70.55,37.35) v2(70.75,37.99) v2(71.92,135.43) v2(71.87,77.38) v2(72.48,38.93) v2(72.48,38.34) v2(72.49,37.76) v2(72.48,37.12) v2(72.58,7.99) v2(72.76,62.39) v2(73.06,61.89) v2(73.09,39) v2(73.09,38.39) v2(73.09,37.73) v2(73.09,37.12) v2(73.37,62.39) v2(73.7,61.86) v2(73.67,38.92) v2(73.67,38.34) v2(73.67,37.76) v2(73.67,37.17) v2(73.98,62.37) v2(74.31,61.86) v2(74.67,138.64) v2(76.77,58.38) v2(76.77,57.74) v2(77.41,58.38) v2(77.41,57.74) v2(78.44,56.51) v2(78.77,55.98) v2(79.07,56.51) v2(79.62,9.94) v2(79.76,65.79) v2(79.76,63.7) v2(79.9,146.42) v2(80.01,68.02) v2(80.01,67.38) v2(80.01,66.37) v2(80.15,36.28) v2(80.33,34.38) v2(80.33,32.7) v2(80.39,63.7) v2(80.53,148.4) v2(80.69,46.52) v2(80.71,45.93) v2(80.71,45.33) v2(80.71,44.72) v2(80.71,44.13) v2(80.71,43.5) v2(80.71,42.89) v2(80.69,42.3) v2(80.79,185.56) v2(80.9,68.02) v2(80.9,67.38) v2(80.9,66.43) v2(80.9,65.79) v2(81.03,63.7) v2(81.83,159.78) v2(83.32,91.28) v2(83.32,89.37) v2(84.03,112.77) v2(84.03,112.13) v2(84.24,105.27) v2(84.27,104.58) v2(84.28,90.32) v2(84.67,112.77) v2(84.67,112.13) v2(84.74,105.65) v2(84.75,104.91) v2(84.9,78.35) v2(85.06,187.39) v2(85.11,76.64) v2(85.23,91.28) v2(85.23,89.37) v2(85.28,98.39) v2(85.72,78.35) v2(85.87,98.39) v2(86.55,98.39) v2(87.16,10.02) v2(87.31,98.39) v2(87.9,98.34) v2(88.54,98.34) v2(88.54,21.59) v2(88.74,174.45) v2(88.68,78.1) v2(89.17,72.55) v2(89.36,174.42) v2(89.44,78.1) v2(89.58,20.47) v2(89.93,72.55) v2(90.13,98.4) v2(90.21,176.05) v2(90.21,175.28) v2(90.21,174.69) v2(90.21,174.05) v2(90.2,78.1) v2(90.24,25.07) v2(90.19,21.41) v2(90.45,176.66) v2(90.83,176.1) v2(90.83,175.46) v2(90.83,174.7) v2(90.83,174.07) v2(90.89,98.4) v2(90.95,72.55) v2(91.32,25.04) v2(91.46,13.13) v2(91.71,72.55) v2(91.84,98.84) v2(92.52,101.18) v2(92.64,105.75) v2(92.64,104.61) v2(92.64,103.6) v2(92.64,102.45) v2(92.6,99.86) v2(92.6,98.72) v2(92.68,187.39) v2(93.04,13.7) v2(93.11,72.55) v2(93.23,97.95) v2(93.3,21.43) v2(93.41,106.54) v2(93.41,105.12) v2(93.41,104.1) v2(93.41,103.09) v2(93.36,101.38) v2(93.36,100.37) v2(93.36,99.1) v2(93.74,72.55) v2(93.99,105.75) v2(93.99,104.61) v2(93.99,103.6) v2(93.99,102.45) v2(94.25,100.88) v2(94.25,99.73) v2(94.25,98.72) v2(94.3,62.83) v2(94.68,10.02) v2(95.22,12.61) v2(95.37,62.8) v2(95.43,21.38) v2(95.47,64.58) v2(95.65,146.47) v2(95.65,145.2) v2(95.66,20.17) v2(96.28,146.47) v2(96.28,145.83) v2(96.38,143.57) v2(96.37,23.9) v2(96.49,20.42) v2(96.68,154.34) v2(96.66,153.76) v2(96.72,21.54) v2(96.92,146.47) v2(96.92,145.83) v2(96.92,145.2) v2(97.25,153.76) v2(97.18,24.41) v2(97.26,154.34) v2(98.31,57.69) v2(98.95,60.87) v2(98.95,60.24) v2(98.95,59.6) v2(98.88,24.43) v2(99.09,166.43) v2(99.56,129.73) v2(99.56,127.82) v2(99.9,57.51) v2(100.3,187.39) v2(100.45,166.25) v2(100.68,20.55) v2(100.8,21.4) v2(101.06,77.15) v2(101.24,155.87) v2(101.49,24.4) v2(101.52,21.84) v2(101.62,167.17) v2(101.72,149.49) v2(102.25,167.17) v2(102.51,149.11) v2(102.45,9.99) v2(102.63,60.87) v2(102.63,60.11) v2(102.63,59.47) v2(102.84,19.78) v2(104.18,24.1) v2(104.18,22.58) v2(104.49,21.31) v2(106.03,19.56) v2(106.05,24.1) v2(106.69,22.02) v2(107.02,21.44) v2(107.41,176.03) v2(107.38,175.42) v2(107.84,187.01) v2(108.04,176.03) v2(108.02,175.42) v2(108.52,21.31) v2(108.75,179.21) v2(108.75,178.57) v2(108.75,177.94) v2(108.75,177.3) v2(108.75,176.67) v2(108.75,176.03) v2(108.75,175.45) v2(108.88,174.87) v2(108.88,174.28) v2(108.88,173.7) v2(108.98,24.1) v2(108.98,22.58) v2(109.28,20.55) v2(109.39,175.27) v2(109.41,174.56) v2(109.41,99.55) v2(109.41,98.92) v2(109.41,95.67) v2(109.41,95.06) v2(109.39,92.19) v2(109.92,9.99) v2(110.25,142.1) v2(111.62,22.58) v2(111.67,99.55) v2(111.67,98.92) v2(111.7,95.67) v2(111.7,95.06) v2(111.67,92.19) v2(112.07,57.57) v2(112.28,21.97) v2(113.73,58.32) v2(113.78,122.26) v2(113.96,99.55) v2(113.96,98.92) v2(113.98,95.67) v2(113.98,95.06) v2(113.96,92.19) v2(114.68,22.07) v2(115.56,187.01) v2(115.72,21.31) v2(116.1,22.58) v2(116.16,113.04) v2(116.24,99.55) v2(116.24,98.92) v2(116.24,92.19) v2(116.27,95.67) v2(116.27,95.06) v2(116.77,113.07) v2(117.03,72.63) v2(117.77,63.21) v2(117.98,22.58) v2(118.15,65.01) v2(118.28,20.55) v2(118.38,9.99) v2(118.53,99.55) v2(118.53,98.92) v2(118.53,92.19) v2(118.56,95.67) v2(118.56,95.06) v2(119.41,24.1) v2(120.03,184.03) v2(119.98,22.08) v2(120.62,184.03) v2(120.75,21.32) v2(120.79,99.55) v2(120.79,98.92) v2(120.82,95.67) v2(120.82,95.06) v2(120.82,92.19) v2(120.76,22.11) v2(122.7,165.59) v2(122.7,164.96) v2(122.92,21.31) v2(123.1,99.55) v2(123.1,98.92) v2(123.13,95.67) v2(123.13,95.06) v2(123.1,92.19) v2(123.12,22.68) v2(123.18,187.01) v2(123.87,67.45) v2(124.17,73.25) v2(124.4,92.39) v2(124.58,165.49) v2(124.81,74.8) v2(124.78,70.85) v2(124.86,164.91) v2(124.87,67.14) v2(125.16,165.47) v2(125.18,22.58) v2(125.39,99.55) v2(125.39,98.92) v2(125.42,95.67) v2(125.42,95.06) v2(125.39,92.19) v2(125.49,164.91) v2(125.8,165.49) v2(125.9,65.26) v2(125.96,66.73) v2(126,9.99) v2(126.38,165.49) v2(126.66,74.81) v2(126.7,23.34) v2(126.77,73.26) v2(126.76,64.45) v2(127.71,147.1) v2(127.68,63.41) v2(128.24,24.28) v2(128.24,22.76) v2(128.24,21.23) v2(128.29,147.07) v2(129.35,156.03) v2(129.32,58.43) v2(129.41,153.36) v2(129.81,57.02) v2(130.23,24.51) v2(130.28,22) v2(130.28,20.47) v2(130.65,154.7) v2(130.62,59.86) v2(130.78,187.39) v2(131.02,55.42) v2(131.11,58.34) v2(132.14,153.36) v2(132.15,91.89) v2(132.15,90.15) v2(132.27,156.09) v2(132.43,59.63) v2(132.39,56.8) v2(132.56,23.43) v2(132.56,21.9) v2(132.56,20.38) v2(132.99,93.94) v2(133.62,9.99) v2(133.82,83.07) v2(133.77,58.18) v2(134.34,24.02) v2(134.34,22.49) v2(134.34,20.97) v2(134.42,95.2) v2(134.38,93.38) v2(134.64,92.11) v2(134.61,90.31) v2(135.15,59.56) v2(135.64,105.18) v2(135.79,20.13) v2(135.87,24.02) v2(135.87,22.67) v2(136.38,83.13) v2(137.48,105.05) v2(137.84,21.31) v2(138.11,53.48) v2(138.1,52.87) v2(138.4,187.39) v2(138.41,96.23) v2(138.5,24.1) v2(138.5,22.58) v2(138.6,20.55) v2(139.26,115.73) v2(139.28,83.07) v2(139.45,96.21) v2(139.67,21.31) v2(140.38,89.17) v2(140.42,87.16) v2(140.43,20.55) v2(140.81,114.21) v2(140.81,53.74) v2(140.81,53.16) v2(140.89,24.71) v2(141.02,22.17) v2(141.11,8.01) v2(141.27,115.84) v2(141.45,124.7) v2(141.41,61.6) v2(141.52,86.7) v2(141.75,101.87) v2(141.79,83.07) v2(141.94,89.9) v2(141.96,20.55) v2(142.15,185.58) v2(142.64,125.76) v2(142.65,54.01) v2(142.65,53.42) v2(142.72,21.31) v2(142.81,115.53) v2(142.76,100.29) v2(143.04,86.66) v2(142.97,61.6) v2(143.06,88.5) v2(143.2,113.58) v2(143.45,24.1) v2(143.45,22.58) v2(143.73,20.55) v2(143.77,84.95) v2(144.29,83.07) v2(144.5,100.33) v2(144.52,96.81) v2(144.49,21.31) v2(144.82,98.51) v2(144.8,88.1) v2(145.35,86.42) v2(145.58,24.1) v2(145.58,22.58) v2(146.45,184.06) v2(146.45,183.43) v2(146.78,90.44) v2(146.83,88.18) v2(146.78,86.42) v2(146.8,83.07) v2(147.08,184.06) v2(147.08,183.43) v2(147.41,23.98) v2(147.41,22.45) v2(147.72,184.06) v2(147.72,183.43) v2(147.72,60.04) v2(148.07,101.56) v2(148.35,184.06) v2(148.35,183.43) v2(148.45,120.08) v2(148.48,118.3) v2(148.53,111.01) v2(148.49,87.81) v2(148.52,85.81) v2(148.66,8.01) v2(148.99,184.06) v2(148.99,183.43) v2(149.31,83.07) v2(149.65,101.41) v2(149.62,97.12) v2(149.7,117.39) v2(149.77,185.58) v2(149.77,99.22) v2(149.82,58.67) v2(149.82,57.37) v2(149.82,54.75) v2(150.26,100.54) v2(150.84,116.22) v2(151.16,21.78) v2(151.45,58.02) v2(151.45,55.42) v2(151.81,99.27) v2(151.81,83.07) v2(151.98,100.44) v2(152.14,88.53) v2(152.9,93.43) v2(153.12,58.29) v2(153.15,56.45) v2(153.33,95.49) v2(153.33,89.65) v2(153.44,54.15) v2(153.53,85.99) v2(153.58,143.65) v2(153.74,93.08) v2(153.66,87.77) v2(154.1,83.08) v2(155.06,146.04) v2(155.1,144.15) v2(155.36,142.66) v2(155.44,58.67) v2(155.44,56.07) v2(156.35,10.02) v2(156.55,145.43) v2(156.73,87.79) v2(156.75,142.54) v2(157.04,58.02) v2(157.15,146.72) v2(157.39,185.58) v2(157.47,85.41) v2(158.43,146.64) v2(158.48,124.88) v2(158.64,87.54) v2(158.82,96.18) v2(159.2,92.56) v2(159.88,88.07) v2(159.99,89.85) v2(160.14,187.39) v2(160.46,138.48) v2(160.62,96.15) v2(160.67,137.4) v2(160.7,90.61) v2(160.84,161.03) v2(161.01,92.54) v2(161.51,67.07) v2(161.51,66.48) v2(161.7,143.14) v2(162.23,144.62) v2(162.65,21.04) v2(163.52,60.69) v2(163.77,153.94) v2(163.97,10.02) v2(164.35,123.74) v2(164.4,121.86) v2(164.42,24.1) v2(164.42,22.58) v2(164.46,125.36) v2(166.03,121.88) v2(165.95,24.1) v2(165.95,22.58) v2(166.19,123.64) v2(166.26,160.36) v2(166.46,125.51) v2(166.54,104.5) v2(167.5,154.04) v2(167.47,104.5) v2(167.83,125.61) v2(167.83,121.93) v2(167.8,24.1) v2(168.09,123.76) v2(168.14,22.8) v2(168.42,90.28) v2(168.63,153.21) v2(170.03,24.89) v2(170.15,20.74) v2(170.19,65.58) v2(170.17,21.93) v2(170.27,151.14) v2(170.7,22.87) v2(170.81,64.79) v2(171.19,21.93) v2(171.64,24.1) v2(171.65,22.76) v2(171.59,10.02) v2(172.1,150.89) v2(172.25,160.29) v2(172.43,20.64) v2(172.9,162.1) v2(172.94,160.82) v2(173.27,159.88) v2(173.28,24.1) v2(173.28,22.58) v2(173.52,167.25) v2(173.9,166.79) v2(174.46,160.54) v2(174.72,186.3) v2(174.72,158.48) v2(174.82,20.28) v2(175.91,180.2) v2(176.26,181.44) v2(176.31,24.91) v2(176.34,20.76) v2(176.65,165.01) v2(176.6,107.58) v2(176.6,106.54) v2(176.98,23.25) v2(177.26,165.01) v2(177.66,180.07) v2(178.15,144.79) v2(178.43,22.95) v2(178.53,174.41) v2(178.63,24.28) v2(178.68,20.87) v2(179.21,10.02) v2(179.98,175.04) v2(180.3,69.52) v2(180.48,22.58) v2(180.58,20.87) v2(180.71,24.25) v2(181.19,104.43) v2(182.01,186.3) v2(182.41,104.33) v2(182.57,180.63) v2(182.59,148.27) v2(183,187.39) v2(183.02,149.08) v2(183.05,20.33) v2(183.48,23.02) v2(184.04,24.04) v2(184.78,185.89) v2(184.98,143.9) v2(184.98,143.29) v2(185.06,151.32) v2(185.06,144.56) v2(185.22,103.26) v2(185.59,103.92) v2(185.56,83.68) v2(185.72,7.96) v2(186.2,179.51) v2(186.44,23.32) v2(186.45,118.35) v2(186.48,20.78) v2(186.58,185.89) v2(186.71,21.98) v2(186.93,101.61) v2(186.86,100.34) v2(187.37,22.64) v2(188.28,172.02) v2(188.43,84.14) v2(188.56,21.53) v2(188.55,20.24) v2(190.11,22.01) v2(190.39,123.61) v2(190.37,121.58) v2(190.36,20.53) v2(190.5,125.48) v2(190.62,187.39) v2(190.71,7.92) v2(190.91,146.76) v2(190.97,23.09) v2(192.08,123.64) v2(192.12,20.76) v2(192.29,125.51) v2(192.42,121.7) v2(192.42,111.04) v2(192.42,110.02) v2(192.42,109.03) v2(192.52,23.42) v2(192.59,146.95) v2(192.59,146.31) v2(192.6,22.15) v2(192.93,161.43) v2(192.98,165.95) v2(193.31,173.9) v2(193.44,166.31) v2(194.04,21.19) v2(194.05,125.61) v2(194.07,123.61) v2(194.18,121.67) v2(194.29,21.97) v2(194.48,94.53) v2(194.55,170.55) v2(194.61,19.6) v2(195.22,173.9) v2(195.19,24.79) v2(195.29,22.34) v2(195.88,161.71) v2(196.05,73.34) v2(196.05,72.73) v2(196.05,66.03) v2(196.42,170.51) v2(196.38,82.38) v2(196.41,81.77) v2(196.36,81.11) v2(196.41,80.53) v2(196.64,73.34) v2(196.64,72.73) v2(196.65,24.1) v2(196.88,22.72) v2(196.88,21.19) v2(197.4,161.66) v2(197.94,24.1) v2(198.12,150.06) v2(198.12,148.09) v2(198.24,187.39) v2(198.19,170.57) v2(198.42,10.02) v2(198.85,161.05) v2(199.11,149.07) v2(199.23,178.46) v2(199.53,24.1) v2(199.53,22.58) v2(199.53,21.05) v2(199.74,170.57) v2(200.02,173.62) v2(200.09,148.03) v2(200.21,149.99) v2(200.59,16.05) v2(201.57,72.12) v2(201.58,24.1) v2(202.05,161.14) v2(201.96,16.06) v2(202.75,24.21) v2(202.75,22.69) v2(202.75,21.16) v2(202.94,99.91) v2(202.99,102.04) v2(203.52,145.81) v2(203.67,147.46) v2(204.05,149.87) v2(204.11,148.78) v2(204.79,152.56) v2(205.1,24.75) v2(205.45,21.68) v2(205.45,20.41) v2(205.86,187.39) v2(207.48,9.99) v2(207.92,24.1) v2(207.92,22.58) v2(207.92,21.05) v2(209.79,24.43) v2(209.77,23.16) v2(210.31,45.89) v2(211.22,19.58) v2(211.26,24.46) v2(211.26,23.19) v2(211.76,44.46) v2(212.76,28.46) v2(213.02,20.4) v2(213.29,156.41) v2(213.27,24.46) v2(213.48,187.39) v2(214.9,20.22) v2(215.13,21.95) v2(215.1,9.99) v2(215.16,24.48) v2(215.64,134) v2(216.22,132.6) v2(216.45,21.49) v2(216.45,20.22) v2(216.47,66.36) v2(217.24,133.29) v2(217.57,151.19) v2(217.57,58.89) v2(217.9,151.68) v2(217.92,24.48) v2(217.87,23.18) v2(218,21.53) v2(218.05,20.28) v2(218.23,151.19) v2(218.58,151.68) v2(218.73,161.49) v2(218.74,160.16) v2(218.76,160.84) v2(218.86,151.14) v2(219.19,151.68) v2(219.37,161.49) v2(219.39,160.84) v2(219.37,160.16) v2(219.5,151.12) v2(219.78,151.68) v2(219.9,161.81) v2(219.9,161.17) v2(219.9,160.54) v2(219.9,159.9) v2(219.9,159.27) v2(219.88,19.6) v2(219.95,24.46) v2(219.96,22.27) v2(220.08,151.14) v2(220.36,151.68) v2(220.53,161.17) v2(220.53,160.54) v2(220.53,159.9) v2(220.53,159.27) v2(220.62,161.84) v2(220.64,150.56) v2(220.67,151.14) v2(220.97,151.65) v2(221.1,187.39) v2(221.25,151.12) v2(221.22,150.53) v2(221.22,149.95) v2(221.5,24.4) v2(221.5,23.19) v2(221.71,132.93) v2(221.81,135.44) v2(221.78,134.73) v2(221.78,132.17) v2(222.57,53.22) v2(222.63,50.36) v2(222.72,9.99) v2(223.08,131.26) v2(223.38,21.65) v2(223.38,20.46) v2(223.61,185.58) v2(223.69,133.34) v2(223.98,51.82) v2(225.3,53.22) v2(225.3,50.36) v2(225.72,95.74) v2(225.72,95.01) v2(225.75,94.4) v2(226.08,134.17) v2(226.22,131.87) v2(226.58,163.49) v2(226.58,133.69) v2(226.74,166.08) v2(226.84,165.49) v2(226.76,164.1) v2(226.86,164.73) v2(227.66,54.57) v2(228.12,86.48) v2(228.12,85.86) v2(228.12,85.27) v2(228.44,134.03) v2(228.76,53.6) v2(228.86,134.45) v2(228.95,50.46) v2(230.32,136.99) v2(230.32,136.38) v2(230.34,135.77) v2(230.32,135.17) v2(230.72,154.36) v2(230.76,90.81) v2(230.76,89.77) v2(230.76,88.89) v2(231.23,185.58) v2(231.36,144.18) v2(231.64,90.8) v2(231.64,89.78) v2(231.62,88.91) v2(232.56,154.22) v2(232.86,144.89) v2(233.52,40.19) v2(233.52,39.56) v2(233.72,71.64) v2(234.18,41.1) v2(234.38,28.89) v2(234.38,26.96) v2(234.38,24.98) v2(234.38,23.07) v2(234.94,77.96) v2(235.5,162.01) v2(235.6,158.08) v2(235.6,155.99) v2(235.63,154.6) v2(235.68,146.49) v2(235.88,29.6) v2(235.92,26.02) v2(235.92,22.21) v2(236.13,19.06) v2(236.72,44.03) v2(236.9,105.55) v2(236.9,96.53) v2(236.9,89.8) v2(236.9,84.06) v2(236.91,62.97) v2(236.9,57.16) v2(236.9,50.56) v2(236.9,15.12) v2(237.33,122.08) v2(238.6,133.15) v2(238.85,185.58) v2(238.93,18.91) v2(238.98,27.93) v2(239.31,133.15) v2(239.92,133.15) v2(243.07,187.41) v2(244.87,146.16) v2(244.95,122.08) v2(249.09,153.86) v2(250.69,187.41) v2(252.83,122.1) v2(255.13,187.41) v2(256.68,162.09) v2(256.69,161.26) v2(256.69,160.31) v2(259.1,144.23) v2(259.91,129.2) v2(260.44,145.71) v2(260.49,152.82) v2(261.37,152.83) v2(262.02,161.96) v2(262.02,161.33) v2(262.02,160.69) v2(262.02,160.06) v2(262.02,159.42) v2(262.19,187.41) v2(262.27,152.82) v2(262.65,161.96) v2(262.65,161.33) v2(262.65,160.69) v2(262.65,160.06) v2(262.65,159.42) v2(266.69,136.08) v2(269.81,187.41) v2(270.06,180.92) v2(270.89,180.92) v2(271.14,171.61) v2(271.08,161.56) v2(271.71,180.92) v2(271.8,172.22) v2(271.85,171.64) v2(272.68,159.94) v2(272.81,162.14) v2(273.14,158.58) v2(273.21,157.47) v2(273.73,142.86) v2(273.77,161.04) v2(277.43,187.41) v2(281.35,142.91) v2(285.05,187.41) v2(288.97,142.91) v2(292.55,163.74) v2(292.57,164.71) v2(292.93,166.58) v2(292.93,165.54) v2(296.59,142.91) v2(298.52,165.9) v2(298.47,165.13) v2(298.47,164.09) v2(299.4,165.91) v2(299.39,165.13) v2(299.4,164.09) v2(300.24,164.11) v2(300.28,165.89) v2(300.32,165.13) v2(300.75,190.38) v2(304.21,142.91) v2(305.49,165.62) v2(306.03,164.92) v2(306.04,163.89) v2(306.83,154.44) v2(306.83,152.79) v2(306.83,151.2) v2(308.37,190.38) v2(308.55,154.44) v2(308.55,152.73) v2(308.55,151.2) v2(310.2,152.73) v2(310.26,154.44) v2(310.26,151.2) v2(311.83,142.91) v2(315.99,190.38) v2(316.7,184.82) v2(318.34,184.7) v2(318.89,185.97) v2(319.45,142.91) v2(319.5,176.92) v2(322.14,170.27) v2(322.26,171.45) v2(323.61,190.38) v2(324.68,171.41) v2(325.52,154.14) v2(326.15,154.16) v2(326.38,172.05) v2(326.36,171.05) v2(327.07,142.91) v2(328.03,171.68) v2(329.33,172.4) v2(330.09,157.9) v2(330.93,171.97) v2(331.23,190.38) v2(334.69,142.91) v2(335.8,190.37) v2(340.93,169.84) v2(340.91,164.25) v2(341.09,173.24) v2(341.57,174.94) v2(342.31,142.91) v2(342.57,164.03) v2(342.66,170.75) v2(344.39,181.36) v2(344.39,176.64) v2(344.41,172.33) v2(344.41,164.71) v2(344.39,157.06) v2(344.41,148.86) v3(7.03,38.72) v3(25.75,36.33) v3(27.17,35.22) v3(27.78,35.76) v3(29.34,35.61) v3(95.65,145.83) v3(96.28,145.2) v3(100.88,144.06) v3(101.67,150.68) v3(101.82,146.82) v3(101.89,152.24) v3(102.12,145.45) v3(102.95,146.66) v3(111.17,126.37) v3(113.1,126.33) v3(114.16,128.7) v3(115.49,127.64) v3(115.6,129.11) v3(116.68,129.86) v3(117.01,127.93) v3(117.09,125.23) v3(117.09,123.96) v3(117.09,122.69) v3(118.13,130.19) v3(118.36,125.23) v3(118.36,123.96) v3(119.29,130.21) v3(119.42,129.2) v3(119.63,125.23) v3(119.63,123.96) v3(120.74,130.25) v3(121.97,129.51) v3(125.28,104.47) v3(141.49,100.35) v3(160.62,131.2) v3(181.98,165.31) v3(182.62,165.11) v3(186.29,88.48) v3(187.9,89.04) v3(188.51,92.43) v3(189.93,92.41) v3(198.2,99.59) v3(203.05,93) v3(204.36,106.03) v3(204.36,91.71) v3(204.47,96.38) v3(205.13,99.8) v3(213.27,23.16) v3(214.7,93.99) v3(215.92,93.19) v5(52.39,90.34) v5(52.53,88.85) v5(52.53,88.24) v5(174.78,156.87) v6(22.23,74.78) v6(46.38,36.98) v6(51.68,80.86) v6(64.95,114.44) v6(68.63,26.54) v6(75.59,37.59) v6(81.87,45.11) v6(83.95,64.98) v6(89.72,97.66) v6(98.4,98.68) v6(103,166.5) v6(137.37,54.37) v6(138.74,31.09) v6(140.35,54.53) v6(144.08,53.48) v6(149.81,184.36) v6(173.49,165.96) v6(186.16,144.47) v6(194.07,166.93) v6(201.1,21.02) v6(210.62,31.74) v6(218.58,162.34) v6(225.97,96.44) v6(262.61,163.11)
