# Allegro board Alpine15_LA-A101PR10-0826C.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PCIE_PTX_GLANRX_P3_C: length 2.7
  TOP w0.102: U21.41 195.57,149.67 195.49,149.59 195.14,149.59 195.13,149.6 194.54,149.6 194.49,149.66 194.03,149.66 C178.2
PCIE_PTX_MMIRX_N1: length 223.2
  IN1 w0.097: v2(148.52,87.23) 148.33,87.04 148.15,87.04 147.92,87.27 147.92,88.14 147.29,88.77 146.13,88.77 143.66,91.24 141.07,91.24 140.31,90.48 140.31,90.46 139.38,89.53 139.38,88.75 134.42,83.79 131.73,83.79 129.51,81.57 128.46,81.57 127.07,80.17 124.53,80.17 123.96,79.6 122.7,79.6 122.14,80.16 119.56,80.16 117.09,77.69 115.97,77.69 112.46,74.17 105.92,74.17 103.67,71.92 103.67,70.97 101.77,69.07 101.77,66.86 97.24,62.33 97.24,59.55 95.09,57.39 80.92,57.39 78.29,60.01 75.98,60.01 74.51,61.48 71.62,61.48 65.78,67.32 56.61,67.32 54.75,69.18 36.74,69.18 34.13,66.56 30.85,66.56 9.8,45.5 9.8,22.52 15.59,16.72 22.82,16.72 24.7,18.6 24.7,19.14 v2(24.8,19.23)
  BOTTOM w0.076: UC1.C30 150.09,83.2 150.09,83.37 149.85,83.61 149.67,83.61 149.53,83.75 149.5,83.86 149.5,83.99 149.52,84.05 149.54,84.06 149.56,84.14 149.56,84.29 149.48,84.56 149.43,84.73 149.24,84.92 149.24,86.75 148.97,87.02 148.72,87.02 148.52,87.22 v2(148.52,87.23)
  BOTTOM w0.102: v2(24.8,19.23) 24.55,19.48 24.55,19.67 24.23,19.99 24.08,19.99 23.98,20.09 23.98,20.36 C236.1
PCIE_PTX_MMIRX_N1_C: length 2.4
  BOTTOM w0.102: C236.2 23.94,21.94 23.94,22.14 23.33,22.75 23.33,22.91 23.39,22.98 U27.5
PCIE_PTX_MMIRX_P1: length 223.2
  IN1 w0.097: v2(148.52,86.42) 148.69,86.42 148.79,86.52 148.79,86.73 148.69,86.83 148.06,86.83 147.7,87.19 147.7,88.06 147.2,88.56 146.05,88.56 143.57,91.03 141.16,91.03 140.52,90.39 140.52,90.37 139.59,89.44 139.59,88.66 134.5,83.58 131.82,83.58 129.6,81.36 128.55,81.36 127.15,79.96 124.62,79.96 124.05,79.39 122.61,79.39 122.06,79.95 119.64,79.95 117.18,77.48 116.06,77.48 112.54,73.96 106.01,73.96 103.88,71.83 103.88,70.89 101.98,68.99 101.98,66.77 97.46,62.25 97.46,59.46 95.18,57.18 80.83,57.18 78.2,59.8 75.89,59.8 74.43,61.27 71.53,61.27 65.69,67.11 56.52,67.11 54.67,68.97 36.83,68.97 34.22,66.35 30.94,66.35 10.01,45.42 10.01,22.6 15.68,16.93 22.73,16.93 24.49,18.69 24.49,18.97 24.4,19.07 24.4,19.16 24.32,19.24 v2(24.11,19.24)
  BOTTOM w0.076: UC1.C31 149.79,83.38 149.73,83.45 149.57,83.45 149.53,83.48 149.48,83.53 149.38,83.68 149.36,83.77 149.34,83.83 149.34,84.02 149.35,84.05 149.37,84.1 149.38,84.14 149.39,84.15 149.4,84.17 149.4,84.27 149.29,84.65 149.08,84.86 149.08,86.68 148.9,86.86 148.31,86.86 148.21,86.76 148.21,86.54 148.32,86.42 v2(148.52,86.42)
  BOTTOM w0.102: v2(24.11,19.24) 24.12,19.24 24.34,19.46 24.34,19.58 24.15,19.77 23.99,19.77 23.77,20 23.77,20.33 C235.1
PCIE_PTX_MMIRX_P1_C: length 2.4
  BOTTOM w0.102: U27.6 22.99,22.98 23.11,22.86 23.11,22.66 23.72,22.05 23.72,21.88 C235.2
PCIE_PTX_WLANRX_N4: length 198.3
  TOP w0.102: C242.1 287.16,172.07 287.01,172.22 283.71,172.22 278.14,166.66 274.02,162.53 272.24,162.53 272.05,162.34 272.05,162.06 v4(272.28,161.84)
  IN3 w0.086: v4(272.28,161.84) 272.05,161.61 272.05,161.41 265.75,155.11 256.28,155.11 251.81,150.63 251.81,147.28 244.96,140.43 239.87,140.43 239.41,139.97 239.4,139.97 238.54,139.1 233.11,139.1 232.77,138.77 230.46,138.77 228.45,136.76 224.16,136.76 223.36,135.97 220.88,135.97 219.74,134.82 214.71,134.82 212.21,132.32 212.21,131.99 208.58,128.36 208.58,119.65 200.37,111.44 198.58,111.44 193.86,106.72 181.92,106.72 174.24,99.03 168.55,99.03 168.15,98.64 157.71,98.64 157.17,99.18 155.77,99.18 153.67,101.28 151.41,101.28 151.3,101.16 151.3,100.93 v3(151.45,100.77)
  BOTTOM w0.076: UC1.B29 150.92,83.94 151.39,84.41 151.39,85.02 151.2,85.21 151.2,85.58 151.4,85.79 151.4,87.07 151.43,87.1 151.43,87.12
  BOTTOM w0.102: v3(151.45,100.77) 151.45,100.11 151.13,99.8 149.61,99.8 147.06,97.24 147.06,93.85 147.42,93.48 147.87,93.48 151.43,89.93 151.43,87.12
PCIE_PTX_WLANRX_N4_C: length 39.4
  TOP w0.102: v4(317.24,185.1) 317.45,185.31 317.45,185.6 317.3,185.75 316.79,185.75 316.12,185.08 307.89,185.08 304.12,181.3 304.12,181.3 303.77,180.95 303.76,180.95 301.98,179.17 299.2,179.17 299.19,179.16 298.64,179.16 298.63,179.17 296.14,179.17 289.26,172.29 288.29,172.29 288.08,172.07 C242.2
  BOTTOM w0.102: JMINI1.31 317.1,187.07 317.47,186.7 317.47,185.32 v4(317.24,185.1)
PCIE_PTX_WLANRX_P4: length 198.4
  TOP w0.102: v4(271.64,161.84) 271.83,162.03 271.83,162.43 272.15,162.75 273.93,162.75 277.93,166.75 277.93,166.75 283.62,172.44 286.85,172.44 C243.1
  IN3 w0.086: v3(150.81,100.81) 150.93,100.81 151.12,101 151.12,101.23 151.34,101.45 153.74,101.45 155.85,99.35 157.24,99.35 157.78,98.82 168.08,98.82 168.47,99.21 174.17,99.21 181.85,106.89 193.79,106.89 198.51,111.61 200.29,111.61 208.4,119.72 208.4,128.43 212.03,132.06 212.03,132.39 214.64,135 219.67,135 220.81,136.14 223.29,136.14 224.08,136.93 228.38,136.93 230.39,138.94 232.7,138.94 233.04,139.28 238.47,139.28 239.33,140.14 239.34,140.14 239.8,140.6 244.88,140.6 251.63,147.35 251.63,150.71 256.21,155.28 265.67,155.28 271.87,161.48 271.87,161.6 v4(271.64,161.84)
  BOTTOM w0.076: 151.21,87.12 151.21,87.1 151.23,87.07 151.23,85.86 151.03,85.65 151.03,85.14 151.22,84.95 151.22,84.48 151.13,84.39 151.01,84.39 150.92,84.48 UC1.A29
  BOTTOM w0.102: 151.21,87.12 151.21,89.84 147.78,93.27 147.33,93.27 146.84,93.76 146.84,97.33 149.52,100.01 151.04,100.01 151.23,100.2 151.23,100.38 150.81,100.8 v3(150.81,100.81)
PCIE_PTX_WLANRX_P4_C: length 39.3
  TOP w0.102: C243.2 288.33,172.5 289.17,172.5 296.05,179.39 v3(298.91,179.39) 301.9,179.39 303.67,181.16 303.68,181.16 303.9,181.39 303.9,181.39 307.8,185.29 316.03,185.29 316.7,185.97 317.39,185.97 317.67,185.68 317.67,185.31 v3(317.88,185.1)
  BOTTOM w0.102: JMINI1.33 317.9,186.84 317.68,186.62 317.68,185.3 v3(317.88,185.1)
PCIE_WAKE#: length 500.1
  TOP w0.102: v2(169.87,131.08) 170.06,131.27 170.06,131.78 R340.2 ; U38.B38 168.69,127.86 168.79,127.76 168.79,127.42 v2(168.37,127) ; v3(87.01,16.55) 87.5,17.04 JEXP1.40 ; v3(231.54,142.35) v1(232.25,142.35)
  IN3 w0.102: v3(210.25,90.64) 209.11,89.5 209.11,61.2 213.86,56.45 213.86,53.43 214.93,52.36 216.63,52.36 219.3,49.69 224.45,49.69 227.42,46.72 228.21,46.72 230.88,44.06 230.88,35.93 233.8,33.01 233.8,31.91 232.6,30.72 232.6,18.06 231.61,17.07 231.61,16.62 226.33,11.34 150.94,11.34 150.84,11.24 147.34,11.24 146.14,10.04 139.44,10.04 137.84,11.64 115.87,11.64 113.45,14.06 94.89,14.06 93.45,15.51 88.05,15.51 v3(87.01,16.55) ; v3(178.53,111.72) 180.81,114.01 186.68,114.01 187.66,114.99 194.1,114.99 194.73,114.36 197.84,114.36 198.29,114.81 198.83,114.81 202.71,118.68 202.71,121.32 205.17,123.78 205.17,127.31 205.17,134.07 205.17,134.13 209.64,138.59 216.35,138.59 218,140.25 226.25,140.25 226.38,140.38 228.36,142.35 v3(231.54,142.35) 230.8,143.09 230.8,144.33 232.69,146.23 232.94,146.23 233.61,146.9 234.5,146.9 235.32,147.73 235.32,151.53 234.71,152.14 234.71,161.78 236.16,163.23 236.16,167.02 236.69,167.55 246.07,167.55 249.32,164.3 254.21,164.3 255.22,165.31 266.02,165.31 266.15,165.45 270.08,169.38 276.08,169.38 280.58,173.87 288,173.87 298.01,183.88 298.08,183.88 298.31,184.11 v3(298.31,184.14)
  BOTTOM w0.102: JMINI2.1 232.59,141.3 v3(231.54,142.35) ; v3(210.25,90.64) 208.1,90.64 205,93.74 204.98,93.74 204.83,93.89 201.18,93.89 196.61,98.46 196.61,99.75 196.61,100.12 195.13,101.61 193.46,101.61 192.27,102.81 189.96,102.81 187.53,105.23 185.63,105.23 179.14,111.72 v3(178.53,111.72) 178.3,111.95 178.3,117.34 177.89,117.75 177.89,123.65 178.12,123.88 178.12,126.3 176.24,128.18 169.55,128.18 v2(168.37,127) 168,127.37 168,128.07 169.8,129.86 169.8,131.01 v2(169.87,131.08) ; JMINI1.1 301.9,186.91 299.13,184.14 v3(298.31,184.14)
PD#B: length 2
  TOP w0.102: U83.5 300.15,161.88 R2626.1
PE_REXT: length 4
  BOTTOM w0.102: U27.4 23.79,22.87 24.53,22.13 24.63,22.13 25.17,21.59 R205.2 25.22,21.58 v1(26.2,20.6)
PE_RST#: length 15.6
  IN3 w0.102: v2(18.29,31.83) 17.03,30.58 17.03,26.42 v2(18.4,25.05)
  BOTTOM w0.102: R443.2 v2(18.29,31.83) 17.97,31.52 14.58,31.52 14.54,31.48 14.24,31.48 R27.1 13.79,31.03 v1(12.97,31.03) ; v2(18.4,25.05) 18.55,25.2 U27.15
PECI_EC: length 132.8
  TOP w0.102: R375.2 155.41,134.4 v2(155.84,134.83)
  IN2 w0.102: v2(124.62,114.25) 124.62,113.96 129.59,108.98 131.47,108.98 131.8,109.31 136.24,109.31 140.28,105.27 141.77,105.27 142.08,104.96 145.18,104.96 145.28,105.07 150.77,105.07 151.04,104.79 151.04,101.97 149.51,100.43 148.44,100.43 146.7,98.69 146.7,93.7 150.35,90.06 150.35,86.02 150.77,85.6 150.77,81.68 151.36,81.09 151.36,77.85 149.22,75.7 132.4,75.7 132.05,76.06 129.99,76.06 129.75,76.29 128.79,76.29 v2(128.36,76.72)
  IN3 w0.102: v2(155.84,134.83) 155.84,134.37 149.13,127.66 149.13,123.09 145.37,119.34 128.81,119.34 127.18,117.72 127.18,116.93 124.62,114.36 v2(124.62,114.25)
  BOTTOM w0.076: UC1.N62 130.16,77.21 129.87,76.92 129.45,76.92 129.28,77.09 128.74,77.09 v2(128.36,76.72)
PECI_EC_R: length 10.6
  TOP w0.102: U38.A48 162.44,129.3 162.36,129.37 161.69,129.37 159.77,131.3 159.5,131.3 158.57,132.23 158.57,132.63 158.31,132.89 156.47,132.89 v6(156.23,133.13) 156.11,133.13 155.59,132.61 C395.1 155,133.28 R375.1
PEG_A_CLKRQ#: length 77.3
  TOP w0.102: v1(67.76,96.51) 67.76,96.46 v2(68.11,96.1) 68.33,96.32 QC11.3 ; RC162.2 108.84,111.68 v3(108.51,111.68)
  IN1 w0.097: v3(71.21,119.42) 71.39,119.24 71.39,115.38 68.82,112.81 68.82,111.48
  IN1 w0.102: v2(68.11,96.1) 69.79,96.1 70.5,96.81 70.5,99.02 71.59,100.11 71.59,101.69 68.82,104.46 68.82,111.48
  IN3 w0.102: v3(108.51,111.68) 107.45,111.68 105.2,113.93 105.2,119.96 102.72,122.44 83.84,122.44 80.43,119.04 71.59,119.04 v3(71.21,119.42)
PEG_EXP: length 171.2
  IN1 w0.097: v3(91.34,15.98) 90.97,16.35 90.97,17.2 90.15,18.02 87.63,18.02 85.11,20.55 85.11,31.63 88.97,35.5 91.25,35.5 102.26,46.51 102.26,46.95 102.63,47.32 103.05,47.32 113.04,57.31 113.04,57.78 v4(113.23,57.96)
  IN3 w0.086: v3(125.87,104.78) 125.98,104.67 126.7,104.67 131.89,99.48 141.24,99.48 v3(141.47,99.7)
  BOTTOM w0.076: 141.37,87.49 141.1,87.22 141.1,86.41 141.51,86.01 141.51,85.27 141.99,84.79 141.99,84.44 142.03,84.4 142.03,84.04 141.99,84 141.99,83.79 142.21,83.56 142.4,83.56 142.83,83.13 UC1.C42
  BOTTOM w0.102: v3(125.87,104.78) 125.87,104.77 126,104.65 126.36,104.65 126.85,104.15 126.85,95.82 126.17,95.13 126.17,91.4 125.28,90.52 108.27,90.52 104.78,87.04 104.78,83.62 106.07,82.33 106.07,78.98 109.22,75.83 109.22,72.58 114.89,66.92 114.89,61.32 113.22,59.65 113.22,57.97 v4(113.23,57.96) ; v3(141.47,99.7) 141.69,99.48 142,99.48 142.23,99.25 142.23,98.53 141.95,98.25 141.95,92.16 141.27,91.48 141.27,89.67 141.37,89.57 141.37,87.49 ; RC188.1 92.19,14.12 92.19,13.95 92.09,13.85 91.21,13.85 90.97,14.1 90.97,15.61 91.18,15.81 v3(91.34,15.98)
PEG_EXP#: length 170.6
  IN1 w0.097: v3(90.71,15.98) 90.71,17.09 90.04,17.76 87.53,17.76 84.84,20.44 84.84,31.74 88.86,35.76 91.14,35.76 102,46.61 102,47.06 102.52,47.58 102.94,47.58 112.78,57.42 112.78,57.78 v4(112.59,57.96)
  IN3 w0.086: v3(125.87,104.15) 125.87,104.15 126.04,104.32 126.04,104.38 126.13,104.46 126.61,104.46 131.81,99.27 141.27,99.27 v3(141.47,99.07)
  BOTTOM w0.076: 140.96,87.44 140.94,87.41 140.94,86.35 141.34,85.94 141.34,85.2 141.82,84.72 141.82,84.37 141.86,84.33 141.86,84.11 141.82,84.07 141.82,83.72 142.17,83.37 142.17,83.37 142.18,83.35 142.18,83.35 142.27,83.27 UC1.C43
  BOTTOM w0.102: RC160.1 92.52,14.08 92.52,13.91 92.21,13.59 91.1,13.59 90.71,13.99 v3(90.71,15.98) ; v4(112.59,57.96) 112.96,58.33 112.96,59.77 114.62,61.43 114.62,66.8 108.96,72.47 108.96,75.72 105.81,78.87 105.81,82.22 104.52,83.51 104.52,87.15 108.16,90.79 125.17,90.79 125.9,91.52 125.9,95.25 126.58,95.93 126.58,104.04 126.25,104.38 125.99,104.38 125.87,104.27 v3(125.87,104.15) ; 140.96,87.44 141.1,87.58 141.1,89.46 141,89.56 141,91.59 141.68,92.27 141.68,98.36 141.96,98.64 141.96,99.14 141.89,99.21 141.61,99.21 v3(141.47,99.07)
PEG_GTX_C_HRX_N0: length 16.5
  TOP w0.102: CV2403.1 71.21,93.1 71.29,93.18 71.69,93.18 72.83,92.05 v3(72.83,90.88) 72.83,85.03 72.81,85.01 72.81,84.47 72.83,84.45 72.83,82.04 70.89,80.11 70.89,79.37 R106.1
PEG_GTX_C_HRX_N0_M: length 73
  TOP w0.102: v3(80.06,33.33) 80.07,33.33 80.9,34.16 81.89,34.16 82.35,34.62 82.35,35.23 82.2,35.38 82.1,35.38 81.83,35.11 R97.2
  IN3 w0.086: v2(58.46,77.39) 58.69,77.16 58.69,75.58 71.35,62.92 71.35,62.49 74.73,59.11 74.73,57.24 79.57,52.4 79.57,34.36 80.13,33.8 80.21,33.8 80.28,33.72 80.28,33.56 v3(80.06,33.33)
  BOTTOM w0.102: R101.1 70.84,79.32 70.84,79.5 70.53,79.82 65.6,79.82 63.64,77.86 63.64,77.04 63.2,76.59 59.04,76.59 58.68,76.96 58.68,77.18 v2(58.46,77.39)
PEG_GTX_C_HRX_N0_R: length 112.2
  TOP w0.102: v3(70.58,77.4) 70.82,77.64 70.82,77.75 R106.2
  IN3 w0.076: 161.3,83.7 161.3,83.69 161.31,83.69 161.31,83.63 161.31,83.63 161.31,83.03 161.7,82.64 161.7,81.3 161.87,81.13 162.07,81.13 v2(162.25,80.94)
  IN3 w0.086: v3(70.58,77.4) 70.78,77.19 70.78,76.93 71.09,76.62 72.5,76.62 72.91,77.03 85.62,77.03 85.92,76.72 93.21,76.72 96.87,73.06 102.88,73.06 105.09,75.27 110.27,75.27 111.7,76.7 116.85,76.7 123.81,83.66 124.27,83.66 126.48,85.87 131.6,85.87 132.49,86.76 137.36,86.76 140.97,90.36 143.02,90.36 144.72,88.66 149.35,88.66 151.15,86.86 152.67,86.86 153.25,87.44 153.25,87.92 154.55,89.22 156.15,89.22 156.48,89.55 157.27,89.55 159.33,87.49 159.33,86.07 161.3,84.1 161.3,83.7
  BOTTOM w0.076: v2(162.25,80.94) 162.25,81.09 162.44,81.29 UC1.F10
  BOTTOM w0.102: v3(70.58,77.4) 70.82,77.64 70.82,77.75 R106.2
PEG_GTX_C_HRX_N1: length 126.9
  TOP w0.102: v2(68.22,79.34) 68.35,79.34 68.56,79.54 68.56,80.85 70.18,82.47 70.18,86.84 68.84,88.19 68.56,88.19 68.42,88.05 68.42,87.84 CV2405.1
  IN3 w0.076: 163.81,83.7 163.81,83.69 163.81,83.68 163.81,81.41 163.55,81.15 163.33,81.15 v2(163.21,81.04)
  IN3 w0.086: v2(68.22,79.34) 68.34,79.46 68.34,79.46 68.42,79.54 68.42,80.02 68.64,80.24 80.47,80.24 81.04,79.67 86,79.67 86.95,78.71 89.75,78.71 90.81,79.77 92.47,79.77 93.92,81.22 98.14,81.22 98.7,81.77 104.86,81.77 106.03,80.61 112.64,80.61 115.89,83.86 115.89,86.27 117.21,87.59 131.1,87.59 131.77,88.26 136.61,88.26 140.51,92.16 146.78,92.16 148.08,90.86 154.65,90.86 155.47,91.68 160.55,91.68 161.49,90.74 162.12,90.74 163.43,89.43 163.43,85.12 163.81,84.73 163.81,83.7
  BOTTOM w0.076: v2(163.21,81.04) 163.46,81.29 UC1.F8
PEG_GTX_C_HRX_N2: length 126.3
  TOP w0.102: CV2407.1 68.53,86.57 68.95,86.57 69.28,86.24 69.28,85.41 68.1,84.23 68.1,82 66.26,80.16 v2(66.26,79.35)
  IN3 w0.076: 162.78,83.7 162.78,83.69 162.78,83.68 162.78,83.46 162.83,83.41 162.83,81.34 162.79,81.3 162.79,80.64 163.06,80.37 v2(163.15,80.37)
  IN3 w0.086: 162.78,83.7 162.78,85.78 161.07,87.49 161.07,89.62 160.13,90.56 155.83,90.56 155.47,90.2 147.82,90.2 146.75,91.27 140.7,91.27 137.02,87.59 132.01,87.59 131.33,86.91 125.59,86.91 116.32,77.63 111.32,77.63 110.25,76.57 104.66,76.57 102,73.9 97.27,73.9 93.56,77.62 87.87,77.62 87.63,77.86 83.29,77.86 83.02,78.13 66.34,78.13 66.06,78.42 66.06,79.15 v2(66.26,79.35)
  BOTTOM w0.076: v2(163.15,80.37) 162.76,79.98 UC1.H10
PEG_GTX_C_HRX_N3: length 123.6
  TOP w0.102: v2(66.31,83.46) 66.1,83.24 65.7,83.24 CV2401.1
  IN3 w0.076: 164.62,83.7 164.62,83.69 164.62,83.68 164.62,82.08 164.52,81.98 164.28,81.98 164.16,82.09 v2(164.16,82.25)
  IN3 w0.086: v2(66.31,83.46) 66.27,83.41 65.74,83.41 65.51,83.18 65.51,81.86 66.66,80.71 92.42,80.71 94.04,82.33 105.74,82.33 106.9,81.17 112.38,81.17 115.15,83.94 115.15,86.39 116.93,88.18 130.9,88.18 131.46,88.73 136.35,88.73 140.32,92.7 146.91,92.7 148.25,91.35 154.06,91.35 156.47,93.76 161.03,93.76 165.58,89.21 165.58,87.1 164.62,86.14 164.62,83.7
  BOTTOM w0.076: v2(164.16,82.25) 164.27,82.25 UC1.E6
PEG_GTX_C_HRX_P0: length 16.5
  TOP w0.102: R105.1 71.11,79.26 71.11,80.02 73.04,81.95 v3(73.04,84.75) 73.04,90.55 73.05,90.56 73.05,91.22 73.04,91.24 73.04,92.14 71.78,93.39 71.45,93.39 CV2402.1
PEG_GTX_C_HRX_P0_M: length 73
  TOP w0.102: v3(80.69,33.33) 80.66,33.37 80.66,33.61 80.99,33.95 81.98,33.95 82.57,34.53 82.57,35.32 82.29,35.6 82.08,35.6 R96.2
  IN3 w0.086: v3(80.69,33.33) 80.46,33.57 80.46,33.79 80.28,33.97 80.2,33.97 79.75,34.43 79.75,52.48 74.91,57.31 74.91,59.18 71.53,62.56 71.53,62.99 58.87,75.65 58.87,77.15 59.1,77.38 v2(59.1,77.39)
  BOTTOM w0.102: R100.1 71.06,79.31 71.06,79.59 70.62,80.03 65.51,80.03 63.43,77.95 63.43,77.13 63.11,76.81 59.13,76.81 58.89,77.05 58.89,77.19 v2(59.1,77.39)
PEG_GTX_C_HRX_P0_R: length 112.1
  TOP w0.102: v3(71.21,77.4) 71.03,77.58 71.03,77.76 71.34,78.07 R105.2
  IN3 w0.076: 161.48,83.7 161.48,83.1 161.87,82.71 161.87,81.37 161.94,81.29 162.17,81.29 162.26,81.38 v2(162.26,81.64)
  IN3 w0.086: 161.48,83.7 161.48,84.17 159.5,86.14 159.5,87.57 157.34,89.72 156.4,89.72 156.07,89.39 154.47,89.39 153.08,88 153.08,87.51 152.6,87.03 151.22,87.03 149.42,88.84 144.8,88.84 143.09,90.54 140.9,90.54 137.29,86.93 132.42,86.93 131.53,86.04 126.41,86.04 124.2,83.83 123.74,83.83 116.78,76.87 111.62,76.87 110.2,75.45 105.02,75.45 102.81,73.24 96.94,73.24 93.28,76.9 86,76.9 85.69,77.2 72.84,77.2 72.43,76.79 71.16,76.79 70.96,77 70.96,77.14 v3(71.21,77.4)
  BOTTOM w0.076: v2(162.26,81.64) 162.55,81.94 UC1.E10
  BOTTOM w0.102: R105.2 71.34,78.07 71.03,77.76 71.03,77.58 v3(71.21,77.4)
PEG_GTX_C_HRX_P1: length 126.9
  TOP w0.102: CV2404.1 68.54,88.4 68.93,88.4 70.4,86.93 70.4,82.38 68.77,80.76 68.77,79.56 v2(68.99,79.34)
  IN3 w0.076: 163.64,83.7 163.64,83.69 163.64,83.69 163.64,81.47 163.49,81.32 163.44,81.32 163.23,81.52 v2(163.23,81.66)
  IN3 w0.086: v2(68.99,79.34) 68.73,79.07 68.66,79.07 68.6,79.13 68.6,79.95 68.71,80.07 80.39,80.07 80.97,79.49 85.92,79.49 86.87,78.54 89.83,78.54 90.88,79.59 92.54,79.59 93.99,81.04 98.21,81.04 98.77,81.6 104.79,81.6 105.96,80.43 112.71,80.43 116.07,83.78 116.07,86.2 117.28,87.42 131.17,87.42 131.84,88.09 136.68,88.09 140.58,91.99 146.7,91.99 148,90.69 154.73,90.69 155.54,91.51 160.48,91.51 161.42,90.56 162.05,90.56 163.25,89.36 163.25,85.05 163.64,84.66 163.64,83.7
  BOTTOM w0.076: v2(163.23,81.66) 163.47,81.66 163.64,81.83 UC1.E8
PEG_GTX_C_HRX_P2: length 126.2
  TOP w0.102: v2(65.68,79.35) 66.04,79.72 66.04,80.25 67.88,82.09 67.88,84.32 69.07,85.5 69.07,86.16 68.86,86.36 68.68,86.36 68.29,85.96 CV2406.1
  IN3 w0.076: 162.61,83.7 162.61,83.69 162.61,83.68 162.61,83.39 162.66,83.34 162.66,81.41 162.63,81.37 162.63,80.67 v2(162.26,80.3)
  IN3 w0.086: v2(65.68,79.35) 65.88,79.15 65.88,78.35 66.27,77.96 82.95,77.96 83.22,77.69 87.56,77.69 87.8,77.44 93.48,77.44 97.2,73.73 102.07,73.73 104.74,76.39 110.32,76.39 111.39,77.46 116.4,77.46 125.67,86.73 131.4,86.73 132.09,87.42 137.09,87.42 140.77,91.1 146.68,91.1 147.75,90.03 155.54,90.03 155.9,90.39 160.06,90.39 160.9,89.55 160.9,87.41 162.61,85.7 162.61,83.7
  BOTTOM w0.076: v2(162.26,80.3) 162.59,80.64 UC1.G10
PEG_GTX_C_HRX_P3: length 123.5
  TOP w0.102: v2(66.31,82.81) 66.09,83.03 65.7,83.03 CV2408.1
  IN3 w0.076: 164.79,83.7 164.79,83.69 164.79,83.69 164.79,82.01 164.59,81.81 164.43,81.81 v2(164.22,81.59)
  IN3 w0.086: 164.79,83.7 164.79,86.07 165.75,87.03 165.75,89.29 161.1,93.94 156.4,93.94 153.99,91.53 148.33,91.53 146.98,92.87 140.24,92.87 136.28,88.91 131.39,88.91 130.83,88.35 116.86,88.35 114.98,86.47 114.98,84.01 112.31,81.34 106.98,81.34 105.81,82.51 93.97,82.51 92.35,80.89 66.74,80.89 65.69,81.93 65.69,83.11 65.82,83.24 65.98,83.24 66.31,82.9 v2(66.31,82.81)
  BOTTOM w0.076: UC1.F6 164.28,81.59 v2(164.22,81.59)
PEG_GTX_HRX_N0: length 7.5
  TOP w0.102: v2(64.77,92.77) 64.46,92.77 64.38,92.85 64.38,93.13 64.53,93.28 66.45,93.28 66.46,93.27 67,93.27 67.01,93.28 67.14,93.28 67.28,93.14 69.95,93.14 70.3,92.8 CV2403.2
  BOTTOM w0.076: UV1.AB9 64.36,93.18 64.66,92.88
  BOTTOM w0.102: 64.66,92.88 v2(64.77,92.77)
PEG_GTX_HRX_N1: length 8
  TOP w0.102: v5(63.12,92.76) 63.22,92.76 63.34,92.65 63.34,92.44 63.71,92.07 63.93,92.07 64.27,91.74 64.27,91.57 v3(64.77,91.06) 66.64,89.19 66.64,88.43 66.88,88.19 67.39,88.19 67.48,88.1 67.48,87.82 CV2405.2
  BOTTOM w0.102: UV1.AC10 63.54,92.34 v5(63.12,92.76)
PEG_GTX_HRX_N2: length 8.5
  TOP w0.102: v5(63.2,91.94) 63.2,91.8 63.35,91.64 63.58,91.64 63.87,91.35 63.87,91.26 66.16,88.98 v3(66.16,88.54) 66.16,88.23 66.44,87.95 66.44,86.8 66.76,86.49 67.04,86.49 CV2407.2
  BOTTOM w0.102: v5(63.2,91.94) 63.15,91.94 62.75,92.34 UV1.AC11
PEG_GTX_HRX_N3: length 11.5
  TOP w0.102: CV2401.2 64.2,83.33 63.99,83.33 63.53,83.79 63.53,83.86 63.54,83.87 63.54,84.4 63.53,84.41 v3(63.53,87.12) 63.53,88.15 63.77,88.39 63.77,89.84 62.81,90.8 62.81,91.96 62.83,91.97 62.83,92.17 v5(62.27,92.72)
  BOTTOM w0.102: UV1.AB12 61.87,93.13 v5(62.27,92.72)
PEG_GTX_HRX_P0: length 7.6
  TOP w0.102: v5(63.95,92.78) 64.16,92.99 64.16,93.22 64.44,93.5 v3(66.73,93.5) 67.23,93.5 67.37,93.36 70.02,93.36 CV2402.2
  BOTTOM w0.076: v5(63.95,92.78) 64.35,92.38 UV1.AC9
PEG_GTX_HRX_P1: length 8
  TOP w0.102: v5(63.12,93.58) 63.48,93.22 63.48,93.23 63.55,93.15 63.55,92.53 63.8,92.29 64.02,92.29 64.48,91.83 64.48,91.65 64.72,91.41 64.75,91.41 65.12,91.05 65.12,91.02 65.7,90.44 66.86,89.28 66.86,88.52 66.97,88.4 67.11,88.4 CV2404.2
  BOTTOM w0.102: v5(63.12,93.58) 63.52,93.18 UV1.AB10
PEG_GTX_HRX_P2: length 8.5
  TOP w0.102: CV2406.2 66.97,86.27 66.67,86.27 66.22,86.71 66.22,87.86 65.94,88.14 65.94,88.26 65.93,88.28 65.93,88.81 65.94,88.82 65.94,88.89 63.66,91.17 63.66,91.26 63.49,91.43 63.34,91.43 63.2,91.28 v2(63.2,91.14)
  BOTTOM w0.102: UV1.AD11 62.77,91.54 63.17,91.14 v2(63.2,91.14)
PEG_GTX_HRX_P3: length 11.5
  TOP w0.102: v5(62.31,91.95) 62.54,91.95 62.6,91.89 62.6,90.71 63.55,89.75 63.55,88.48 63.31,88.24 63.31,87.4 63.29,87.37 63.29,86.84 63.31,86.82 v3(63.31,84.14) 63.31,83.7 63.9,83.11 64.44,83.11 64.56,82.99 64.56,82.8 CV2408.2
  BOTTOM w0.102: v5(62.31,91.95) 61.92,92.34 UV1.AC12
PEG_HTX_C_GRX_N0: length 107.4
  TOP w0.102: CU16.1 154.53,94.94 154.53,95.15 154.4,95.29 154.09,95.29 153.84,95.54 153.84,95.85 v3(153.63,96.06)
  IN3 w0.086: v2(69.07,83.18) 69.32,83.43 70.24,83.43 70.93,84.11 71.42,84.11 71.51,84.03 71.51,83.59 71.7,83.4 72.27,83.4 72.46,83.59 72.46,84.03 72.54,84.11 72.96,84.11 73.05,84.03 73.05,83.59 73.24,83.4 73.81,83.4 74,83.59 74,84.03 74.08,84.11 76.78,84.11 78.58,82.31 90.87,82.31 92.42,83.86 100.47,83.86 101,84.39 105.19,84.39 106.15,85.35 106.15,87.45 108.56,89.85 129.56,89.85 132.35,92.65 137.05,92.65 138.8,94.4 145.02,94.4 145.5,94.88 145.5,95.46 148.08,98.03 152.7,98.03 153.92,96.81 153.92,96.28 153.7,96.06 v3(153.63,96.06)
  BOTTOM w0.076: UV1.AG7 66.06,89.14 66.27,88.93 66.27,88.71 66.55,88.43 66.55,88.25
  BOTTOM w0.102: 66.55,88.25 66.55,86.45 66.89,86.1 66.89,84.85 68.3,83.44 68.81,83.44 v2(69.07,83.18)
PEG_HTX_C_GRX_N1: length 110.4
  TOP w0.102: CU18.1 152.78,92.42 152.78,92.57 v3(152.56,92.79)
  IN3 w0.086: v3(152.56,92.79) 152.56,92.78 152.85,92.49 152.85,92.39 152.78,92.32 148.73,92.32 147.44,93.61 140.04,93.61 136,89.58 130.88,89.58 130.6,89.29 108.7,89.29 106.62,87.21 106.62,84.92 105.56,83.86 101.77,83.86 101.26,83.35 92.75,83.35 91.21,81.8 77.56,81.8 77.04,82.32 77.04,82.96 76.85,83.15 76.28,83.15 76.09,82.96 76.09,81.97 75.92,81.8 75.67,81.8 75.5,81.97 75.5,83.07 75.22,83.35 74.83,83.35 74.55,83.07 74.55,81.91 74.44,81.8 74.05,81.8 73.96,81.88 73.96,82.47 73.78,82.66 73.21,82.66 73.02,82.47 73.02,81.88 72.93,81.8 72.51,81.8 72.42,81.88 72.42,82.47 72.24,82.66 68.64,82.66 66.34,84.96 65.69,84.96 65.47,85.18 v2(65.47,85.28)
  BOTTOM w0.076: 65.71,88.25 65.71,88.74 65.51,88.94 65.51,89.53 65.71,89.73 65.71,90.42 UV1.AE7
  BOTTOM w0.102: v2(65.47,85.28) 65.64,85.11 66.02,85.11 66.16,85.25 66.16,85.76 65.71,86.21 65.71,88.25
PEG_HTX_C_GRX_N2: length 96.9
  TOP w0.102: CU20.1 148,99.71 147.11,99.71 146.93,99.53 146.93,98.87 145.72,97.66 144.79,97.66 v2(144.53,97.4)
  IN3 w0.086: v2(144.53,97.4) 144.32,97.61 135.09,97.61 128.63,91.15 107.89,91.15 104.87,88.13 104.87,86.02 104.58,85.74 92.24,85.74 90.49,83.99 86.07,83.99 85.08,84.98 78.2,84.98 77.72,85.46 70.43,85.46 69.22,86.67 66.96,86.67 65.96,87.67 65.4,87.67 65.22,87.5 v2(65.22,87.43)
  BOTTOM w0.076: UV1.AF9 64.19,89.94 64.07,89.83 64.07,89.66 64.19,89.55 64.66,89.55 64.77,89.44 64.77,89 64.51,88.74 64.51,88.63
  BOTTOM w0.102: v2(65.22,87.43) 65.03,87.62 64.75,87.62 64.51,87.86 64.51,88.63
PEG_HTX_C_GRX_N3: length 99.1
  TOP w0.102: CU22.1 147.89,98.26 147.34,98.26 145.18,96.1 144.65,96.1 v2(144.54,96.21)
  IN3 w0.086: v2(144.54,96.21) 144.54,96.21 144.36,96.04 143.41,96.04 142.41,97.04 135.2,97.04 128.84,90.68 108.08,90.68 105.34,87.94 105.34,85.83 104.76,85.25 92.47,85.25 90.69,83.48 84.37,83.48 83.99,83.86 78.25,83.86 77.13,84.97 70.15,84.97 68.98,86.14 68.2,86.14 68.01,85.95 68.01,85.49 67.93,85.4 67.51,85.4 67.42,85.49 67.42,85.95 67.23,86.14 66.79,86.14 66.49,86.45 64.68,86.45 64.43,86.19 64.43,85.87 v2(64.28,85.72)
  BOTTOM w0.102: UV1.AG10 63.81,88.88 63.81,87.17 64.49,86.49 64.49,85.93 v2(64.28,85.72)
PEG_HTX_C_GRX_P0: length 107.4
  TOP w0.102: v4(154.26,96.06) 154.05,95.85 154.05,95.63 154.18,95.5 154.49,95.5 154.75,95.24 154.75,94.94 CU17.1
  IN3 w0.086: v4(154.26,96.06) 154.09,96.23 154.09,96.89 152.77,98.21 148,98.21 145.33,95.53 145.33,94.96 144.95,94.57 138.73,94.57 136.98,92.82 132.28,92.82 129.49,90.03 108.49,90.03 105.98,87.52 105.98,85.43 105.12,84.57 100.93,84.57 100.39,84.03 92.35,84.03 90.8,82.49 78.65,82.49 76.85,84.29 74.01,84.29 73.82,84.1 73.82,83.66 73.73,83.58 73.31,83.58 73.23,83.66 73.23,84.1 73.04,84.29 72.47,84.29 72.28,84.1 72.28,83.66 72.19,83.58 71.77,83.58 71.69,83.66 71.69,84.1 71.5,84.29 70.86,84.29 70.17,83.6 69.28,83.6 v3(69.07,83.81)
  BOTTOM w0.076: 66.77,88.25 66.77,88.26 66.73,88.3 66.73,88.32 66.72,88.34 66.72,88.5 66.44,88.78 66.44,89.01 66.56,89.14 UV1.AG6
  BOTTOM w0.102: v3(69.07,83.81) 68.92,83.65 68.39,83.65 67.11,84.94 67.11,86.22 66.77,86.56 66.77,88.25
PEG_HTX_C_GRX_P1: length 110.3
  TOP w0.102: CU19.1 152.99,92.38 152.99,92.56 v3(153.2,92.77)
  IN3 w0.086: v2(65.47,84.64) 65.61,84.79 66.27,84.79 68.57,82.49 72.16,82.49 72.25,82.4 72.25,81.81 72.44,81.62 73.01,81.62 73.19,81.81 73.19,82.4 73.28,82.49 73.7,82.49 73.79,82.4 73.79,81.81 73.98,81.62 74.51,81.62 74.73,81.84 74.73,83 74.9,83.17 75.15,83.17 75.32,83 75.32,81.9 75.6,81.62 75.99,81.62 76.27,81.9 76.27,82.88 76.35,82.97 76.78,82.97 76.86,82.88 76.86,82.25 77.49,81.62 91.28,81.62 92.83,83.17 101.33,83.17 101.84,83.68 105.63,83.68 106.8,84.85 106.8,87.14 108.78,89.12 130.67,89.12 130.95,89.4 136.08,89.4 140.11,93.44 147.36,93.44 148.66,92.14 152.85,92.14 153.03,92.32 153.03,92.6 153.2,92.77 v3(153.2,92.77)
  BOTTOM w0.076: 65.92,88.25 65.92,88.3 65.87,88.35 65.87,88.81 65.68,89.01 65.68,89.46 65.78,89.57 66.09,89.57 66.19,89.67 66.19,89.84 66.09,89.94 UV1.AF7
  BOTTOM w0.102: 65.92,88.25 65.92,86.31 66.08,86.16 66.37,85.86 66.37,85.16 66.11,84.9 65.73,84.9 v2(65.47,84.64)
PEG_HTX_C_GRX_P2: length 96.8
  TOP w0.102: v2(144.53,97.99) 144.64,97.88 145.63,97.88 146.71,98.96 146.71,99.62 147.02,99.92 147.86,99.92 148.23,100.29 CU21.1
  IN3 w0.086: v2(65.22,88.01) 65.23,88.01 65.4,87.84 66.03,87.84 67.03,86.84 69.29,86.84 70.5,85.63 77.79,85.63 78.27,85.15 85.16,85.15 86.15,84.16 90.41,84.16 92.17,85.91 104.51,85.91 104.69,86.1 104.69,88.21 107.81,91.32 128.56,91.32 135.02,97.78 144.32,97.78 v2(144.53,97.99)
  BOTTOM w0.076: UV1.AE9 64.35,90.61 64.72,90.25 64.72,89.73 64.93,89.51 64.93,88.93 64.72,88.72 64.72,88.63
  BOTTOM w0.102: 64.72,88.63 64.72,87.95 64.84,87.83 65.05,87.83 v2(65.22,88.01)
PEG_HTX_C_GRX_P3: length 99.2
  TOP w0.102: v2(144.54,95.62) 144.8,95.88 145.27,95.88 147.43,98.04 147.91,98.04 148.23,97.73 CU23.1
  IN3 w0.086: v2(144.54,95.62) 144.3,95.86 143.34,95.86 142.34,96.86 135.27,96.86 128.92,90.51 108.15,90.51 105.51,87.87 105.51,85.76 104.83,85.08 92.54,85.08 90.77,83.3 84.3,83.3 83.92,83.68 78.18,83.68 77.06,84.8 70.07,84.8 68.9,85.97 68.28,85.97 68.19,85.88 68.19,85.42 68,85.23 67.43,85.23 67.24,85.42 67.24,85.88 67.16,85.97 66.72,85.97 66.42,86.27 64.76,86.27 64.61,86.12 64.61,85.91 64.76,85.76 v3(64.99,85.76)
  BOTTOM w0.102: UV1.AG9 64.02,88.81 64.02,87.26 64.71,86.58 64.71,86.04 v3(64.99,85.76)
PEG_HTX_GRX_N0: length 13
  TOP w0.102: R102.2 154.27,92.06 154.51,92.3 154.51,92.79 v2(154.33,92.98) 154.51,93.16 154.51,93.37 CU16.2
  BOTTOM w0.076: 154.38,88.57 154.38,88.56 154.41,88.53 154.41,88.31 155.15,87.57 155.15,85.87 155.25,85.77 155.25,84.4 155.05,84.2 155.05,83.78 154.69,83.42 154.69,83.28 154.79,83.18 154.93,83.18 155.06,83.31 UC1.C23
  BOTTOM w0.102: v2(154.33,92.98) 154.51,92.79 154.51,92.63 154.38,92.51 v3(154.38,91.68) 154.38,90.02 154.37,90 154.37,89.47 154.38,89.46 154.38,88.57
PEG_HTX_GRX_N0_M: length 109.3
  TOP w0.102: R102.1 154.54,91.15 154.61,91.07 154.61,87.07 154.47,86.93 154.07,86.93 153.88,87.12 v2(153.88,87.2) ; v2(125.38,70.91) 125.45,70.91 125.68,70.67 125.68,69.67 125.12,69.11 123.95,69.11 121.81,66.97 121.81,62.29 107.67,48.16 107.67,45.54 98.58,36.45 86.49,36.45 85.74,37.2 82.06,37.2 81.98,37.27 81.98,37.48 R99.2
  IN3 w0.086: v2(125.38,70.91) 125.54,71.06 125.54,71.91 126.18,72.55 128,72.55 128.46,73.01 128.94,73.01 129.32,73.38 129.32,74.85 129.22,74.95 129.22,76.17 129.68,76.64 129.68,79.56 130.67,80.56 131.46,80.56 132.73,81.83 132.73,82.97 133.95,84.19 150.99,84.19 152.47,85.66 152.47,85.92 153.51,86.96 153.64,86.96 v2(153.88,87.2)
PEG_HTX_GRX_N1: length 10.1
  TOP w0.102: CU18.2 152.65,90.92 152.65,90.62 151.84,89.81 151.84,89.28 152.11,89.01 152.49,89.01 v2(152.64,88.86)
  BOTTOM w0.076: 153.54,88.27 153.55,88.26 153.59,88.26 153.72,88.12 153.81,88.12 154.5,87.44 154.5,85.88 154.86,85.53 154.86,85.18 154.42,84.75 154.42,84.49 154.57,84.25 154.69,84.2 154.75,84.06 UC1.B23
  BOTTOM w0.102: v2(152.64,88.86) 152.64,88.91 152.86,89.13 152.96,89.13 153.18,88.91 153.18,88.63 v3(153.35,88.46) 153.54,88.27
PEG_HTX_GRX_N2: length 23.8
  TOP w0.102: CU20.2 149.56,99.9 150.45,99.9 150.75,99.59 150.75,99.47 150.56,99.27 v3(150.38,99.27)
  BOTTOM w0.076: 155.96,88.57 155.96,88.55 155.98,88.52 155.98,87.99 155.93,87.94 155.93,85.01 156.15,84.79 156.15,84.44 155.82,84.11 155.82,83.77 155.58,83.53 155.58,83.25 155.66,83.17 155.78,83.17 155.87,83.25 UC1.B21
  BOTTOM w0.102: 155.96,88.57 155.96,90.68 156.33,91.05 156.33,94.91 155.81,95.43 155.81,96.67 153.95,98.53 v3(152.64,98.53) 150.98,98.53 150.71,98.79 150.71,99.05 150.49,99.27 v3(150.38,99.27)
PEG_HTX_GRX_N3: length 21.2
  TOP w0.102: v3(150.85,97.3) 150.77,97.38 150.77,97.88 150.31,98.34 149.39,98.34 CU22.2
  BOTTOM w0.076: 155.17,88.57 155.17,88.56 155.2,88.53 155.2,88.23 155.59,87.84 155.59,84.44 155.59,84.44 155.59,84.2 155.52,84.12 UC1.B22
  BOTTOM w0.102: v3(150.85,97.3) 150.6,97.54 150.6,97.71 150.71,97.83 153.51,97.83 154.99,96.34 v3(154.99,95.76) 154.99,95.17 155.62,94.55 155.62,91.49 155.17,91.05 155.17,88.57
PEG_HTX_GRX_P0: length 13
  TOP w0.102: CU17.2 154.73,93.33 154.73,93.16 v2(154.91,92.98) 154.73,92.79 154.73,92.42 R104.2
  BOTTOM w0.076: 154.6,88.57 154.6,88.55 154.58,88.52 154.58,88.38 155.31,87.64 155.31,85.94 155.41,85.84 155.41,84.33 155.22,84.13 155.22,83.8 155.35,83.66 155.35,82.88 UC1.C22
  BOTTOM w0.102: 154.6,88.57 v3(154.6,89.74) 154.6,91.4 154.61,91.41 154.61,91.95 154.6,91.96 154.6,92.42 154.73,92.54 154.73,92.79 v2(154.91,92.98)
PEG_HTX_GRX_P0_M: length 109.4
  TOP w0.102: v2(153.91,86.47) 154.08,86.64 154.16,86.71 154.56,86.71 154.83,86.98 154.83,90.89 R104.1 ; v2(126.03,70.9) 125.9,70.78 125.9,69.58 125.21,68.9 124.04,68.9 122.02,66.88 122.02,62.2 107.89,48.07 107.89,45.45 98.67,36.23 86.4,36.23 85.65,36.98 82.07,36.98 R98.2
  IN3 w0.086: v2(126.03,70.9) 125.9,70.9 125.72,71.08 125.72,71.84 126.25,72.38 128.08,72.38 128.53,72.83 129.02,72.83 129.5,73.31 129.5,74.93 129.39,75.03 129.39,76.1 129.86,76.57 129.86,79.49 130.75,80.38 131.53,80.38 132.91,81.75 132.91,82.9 134.02,84.01 151.07,84.01 152.64,85.59 152.64,85.84 153.58,86.78 153.79,86.78 153.91,86.65 v2(153.91,86.47)
PEG_HTX_GRX_P1: length 10.1
  TOP w0.102: v4(152.65,89.55) 152.65,89.45 152.43,89.23 152.2,89.23 152.06,89.37 152.06,89.72 152.87,90.53 152.87,90.77 153.25,91.15 CU19.2
  BOTTOM w0.076: 153.69,88.42 153.7,88.42 153.7,88.38 153.79,88.29 153.88,88.29 154.66,87.51 154.66,85.95 155.02,85.6 155.02,85.11 154.59,84.68 154.59,84.54 154.68,84.38 154.75,84.35 154.9,84.41 UC1.A23
  BOTTOM w0.102: 153.69,88.42 153.69,88.45 153.39,88.75 153.39,89 153.05,89.34 152.86,89.34 v4(152.65,89.55)
PEG_HTX_GRX_P2: length 23.8
  TOP w0.102: v4(151.15,99.27) 150.97,99.45 150.97,99.68 150.54,100.11 149.39,100.11 CU21.2
  BOTTOM w0.076: UC1.C21 156.25,83.49 156.01,83.73 156.01,84.03 156.34,84.36 156.34,84.84 156.1,85.08 156.1,87.87 156.15,87.92 156.15,88.53 156.18,88.56 156.18,88.57
  BOTTOM w0.102: 156.18,88.57 156.18,90.59 156.54,90.96 156.54,94.99 156.02,95.52 156.02,96.76 154.04,98.74 152.94,98.74 152.92,98.75 152.38,98.75 152.37,98.74 151.07,98.74 150.93,98.88 150.93,99.06 v4(151.15,99.27)
PEG_HTX_GRX_P3: length 21.2
  TOP w0.102: CU23.2 149.14,97.85 149.41,98.12 150.22,98.12 150.55,97.79 150.55,97.61 150.23,97.3 v4(150.21,97.3)
  BOTTOM w0.076: UC1.A21 155.76,84.67 155.76,87.91 155.36,88.3 155.36,88.52 155.39,88.55 155.39,88.57
  BOTTOM w0.102: v4(150.21,97.3) 150.38,97.47 150.38,97.8 150.62,98.04 153.6,98.04 155.21,96.43 155.21,96.04 155.22,96.02 155.22,95.49 155.21,95.48 155.21,95.26 155.83,94.64 155.83,91.4 155.39,90.96 155.39,88.57
PEG_VGA: length 114.1
  TOP w0.102: RC179.1 59.52,80.06 59.52,80.25 v3(59.71,80.44) ; v2(139.22,95.64) 139.04,95.46 139.04,93.45 139.98,92.51 139.98,90.64 139.73,90.39 139.73,88.45 139.86,88.31 140.16,88.31 v2(140.43,88.58)
  IN1 w0.097: v3(59.71,80.44) 59.49,80.22 59.49,79.94 59.89,79.54 63.26,79.54 64.48,78.32 71.69,78.32 77.05,83.68 85.66,83.68 86.04,84.05 90.66,84.05 92.48,85.88 101.53,85.88 107.31,91.66 125.45,91.66 127.32,93.53 127.32,94.25 131.36,98.29 137.84,98.29 139.07,97.07 139.07,95.8 v2(139.22,95.64) ; v2(140.43,88.58) 140.65,88.36 140.65,88.35 140.84,88.35 141.11,88.61 141.11,90.23 141.43,90.55 142.98,90.55 144.12,89.41 144.12,86.69 144.92,85.89 144.92,85.11 v2(145.08,84.95)
  BOTTOM w0.076: UC1.B39 144.78,83.92 145.08,84.21 v2(145.08,84.95)
  BOTTOM w0.102: RC179.1 59.49,80.09 59.49,80.22 v3(59.71,80.44)
PEG_VGA#: length 114.1
  TOP w0.102: v3(59.07,80.44) 59.25,80.26 59.25,80.05 RC157.1 ; v2(138.61,95.67) 138.78,95.5 138.78,93.34 139.72,92.4 139.72,90.75 139.46,90.5 139.46,88.34 139.75,88.05 140.18,88.05 v2(140.44,87.79)
  IN1 w0.097: v2(144.36,84.95) 144.66,85.24 144.66,85.79 143.86,86.58 143.86,89.3 142.87,90.29 141.54,90.29 141.37,90.12 141.37,88.51 140.95,88.09 140.75,88.09 v2(140.44,87.79) ; v2(138.61,95.67) 138.81,95.86 138.81,96.96 137.73,98.03 131.47,98.03 127.58,94.14 127.58,93.42 125.56,91.4 107.42,91.4 101.64,85.61 92.59,85.61 90.77,83.79 86.15,83.79 85.77,83.42 77.16,83.42 71.8,78.06 64.37,78.06 63.16,79.28 59.78,79.28 59.22,79.83 59.22,80.29 v3(59.07,80.44)
  BOTTOM w0.076: UC1.A39 144.78,84.44 144.66,84.31 144.49,84.31 144.36,84.44 v2(144.36,84.95)
  BOTTOM w0.102: RC157.1 59.22,80.02 59.22,80.29 v3(59.07,80.44)
PEG_VGA_EXP: length 97.1
  TOP w0.102: v3(92.07,13.18) 92.24,13.35 92.24,14.06 RC200.1
  IN3 w0.086: v3(92.07,13.18) 92.08,13.18 92.49,12.76 92.49,12.58 92.27,12.36 85.06,12.36 84.01,13.4 84.01,23.95 82.95,25.02 82.95,28.88 83.88,29.82 83.88,47.71 84.81,48.63 84.81,56.98 81.24,60.54 79.93,60.54 78.76,61.72 78.76,63.87 77.16,65.48 77.16,67.95 77.45,68.25 77.45,72.18 76.21,73.42 68.73,73.42 64.27,77.89 62.82,77.89 v4(62.39,78.32)
  BOTTOM w0.102: RC201.2 59.55,78.83 59.4,78.68 59.4,78.21 59.66,77.95 62.02,77.95 v4(62.39,78.32)
PEG_VGA_EXP#: length 97.1
  TOP w0.102: v3(92.71,13.18) 92.51,13.38 92.51,14.07 RC164.1
  IN3 w0.086: v4(62.39,77.68) 62.39,77.68 64.18,77.68 68.64,73.21 76.13,73.21 77.24,72.1 77.24,68.34 76.95,68.04 76.95,65.39 78.55,63.79 78.55,61.63 79.85,60.34 81.16,60.34 84.6,56.89 84.6,48.72 83.67,47.79 83.67,29.9 82.74,28.97 82.74,24.93 83.81,23.87 83.81,13.31 84.97,12.15 92.36,12.15 92.7,12.49 92.7,13.18 v3(92.71,13.18)
  BOTTOM w0.102: v4(62.39,77.68) 59.54,77.68 59.13,78.1 59.13,78.64 RC165.2
PEX_PLL_CLK_OUT: length 5.1
  BOTTOM w0.102: v1(55.13,86.4) RV2.2 54.14,87.57 53.23,88.48 53.23,89.57 53.6,89.94 UV1.AF22
PEX_PLL_CLK_OUT#: length 6.1
  BOTTOM w0.102: v1(53.69,85.15) 53.69,85.77 53.23,86.23 RV2.1 53.23,87.72 53.03,87.92 53.03,89.66 53.23,89.86 53.23,90.34 UV1.AE22
PEX_PLLVDD_GPU: length 20.5
  TOP w0.508: CV97.1 59.8,94.35 v2(59.83,94.38) 59.94,94.26 CV227.1 ; v2(50.44,85.81) v1(51.2,85.05) 51.38,84.87 CV3056.1 52.64,84.77 LV74.1
  IN3 w0.508: 53.61,92.75 52.26,92.75 51.71,92.2 51.71,87.08 v2(50.44,85.81) ; v2(59.83,94.38) 59.45,94.38 57.86,92.79 55.57,92.79
  BOTTOM w0.254: UV1.AA15 59.43,93.98 v2(59.83,94.38) 60.22,93.98 UV1.AA14
PEX_TERMP: length 7.8
  BOTTOM w0.102: RV2703.1 52.98,84.23 52.03,85.18 51.44,85.18 v1(51.2,85.42) 51.2,88.3 50.79,88.71 50.79,89.54 51.13,89.89 UV1.AF25
PGOOD_3V_5V: length 3.9
  TOP w0.102: PR58.2 211.89,152.62 PR60.2 211.89,153.36 v1(212.19,153.67) 212.89,154.37 PU51.7
PIRQ#_TPM: length 91.9
  TOP w0.102: v2(166.49,76.96) 166.26,77.19 166.26,78.08 166.21,78.13 166.21,78.69 166.51,78.99 168.17,78.99 169.75,80.57 171.61,80.57 171.78,80.39 172.37,80.39 172.82,80.84 v1(173.95,80.84) 178.37,80.84 179.93,82.39 181.27,82.39 181.61,82.05 v2(181.71,82.05) 181.71,82.07 182.62,82.97 RC146.2 ; R73.2 211.94,122.03 v2(211.6,121.69)
  IN2 w0.102: v2(211.6,121.69) 211.19,121.69 210.98,121.91 210.4,121.91 210.05,121.55 210.05,109.24 213.81,105.48 213.81,99.66 v3(212.83,98.68)
  IN3 w0.102: v3(212.83,98.68) 212.31,98.16 204.66,98.16 204.21,97.7 204.21,97.13 203.79,96.71 203.79,95.97 204.33,95.43 204.33,94.94 203.95,94.56 203.15,94.56 201.82,93.23 201.82,87.83 198.91,84.92 v2(198.5,84.92)
  BOTTOM w0.076: v2(166.49,76.96) 166.19,77.26 UC1.N4
  BOTTOM w0.102: v2(198.5,84.92) 198.17,84.92 196.74,83.49 192.02,83.49 191.69,83.16 186.27,83.16 185.94,82.83 182.49,82.83 v2(181.71,82.05)
PIRQD: length 79.2
  TOP w0.102: R75.2 211.76,120.53 v3(210.91,120.53)
  IN1 w0.097: v3(210.91,120.53) 210.53,120.15 210.53,115.42 209.11,114 209.11,113.98 205.17,110.04 205.17,109.31 198.77,102.91 v4(198.77,101.99)
  IN2 w0.102: v3(177.79,95.16) 177.79,93.36 175.68,91.25 174.72,91.25 171.14,87.67 171.14,80.71 170.88,80.45 170.88,79.32 170.27,78.71 170.27,77.97 v2(169.85,77.54)
  IN3 w0.102: v4(198.77,101.99) 198.29,101.51 196.51,101.51 196.49,101.48 196.28,101.48 194.48,99.68 191.15,99.68 190.29,98.82 183.77,98.82 179.68,94.73 179.23,94.73 178.83,95.13 178.83,95.27 178.58,95.52 178.15,95.52 v3(177.79,95.16)
  BOTTOM w0.076: UC1.N2 167.78,77.63 168.81,77.63 168.89,77.54 v2(169.85,77.54) 170.49,77.54 170.78,77.84
  BOTTOM w0.102: 170.78,77.84 171.06,78.12 171.48,78.12 171.67,77.93 171.67,77.35 172.13,76.9 173.28,76.9 173.61,76.57 RC148.2
PLT_LAN_RST#: length 6.7
  TOP w0.102: R201.1 192.17,154.89 U20.4 193.15,154.28 R25.1 194.67,153.74 v1(194.94,153.48) 194.94,153.18 195.39,152.73 196.66,152.73 196.91,152.48 U21.36
PLTRST_GPU#: length 134.3
  TOP w0.102: RC180.1 191.41,74.13 191.89,74.61 v6(191.89,75.2) 191.89,76.11 191.7,76.3 v3(191.7,76.29)
  IN1 w0.097: v2(97.22,79.97) 97.22,80.25 97.78,80.81 102.2,80.81 102.43,80.58 107.58,80.58 108.27,79.89 112.89,79.89 115.79,82.79 115.79,83.56 119.65,87.42 133.12,87.42 135.71,90.01 135.71,91.23 138.25,93.77 138.92,93.77 139.7,94.55 146.33,94.55 147.41,93.47 148.62,92.26 151.37,92.26 152.34,93.23 152.34,93.69 153.79,95.13 154.38,95.13 154.85,95.6 154.85,97.09 156.51,98.75 156.52,98.75 156.81,99.03 165.46,99.03 166.14,99.71 170.39,99.71 170.63,99.48 178.79,99.48 180.21,100.9 182.03,100.9 v3(182.64,101.51)
  IN2 w0.102: v3(191.7,76.29) 191.7,76.3 191.39,76.61 191.39,81.89 190.9,82.38 190.9,86.85 191.23,87.18 191.23,92.52 188.73,95.02 186.22,95.02 184.38,96.85 184.38,98.8 183.99,99.19 183.99,100.17 v3(182.64,101.51)
  BOTTOM w0.102: UV14.2 v2(97.22,79.97)
PLTRST_LAN#: length 133.8
  TOP w0.102: RC91.1 190.19,73.85 190.19,75.5 191.13,76.44 191.13,76.57 191.46,76.9 192.95,76.9 195.84,74.01 196.66,74.01 197.54,73.14 v1(198.58,73.14) 200.02,73.14 200.3,73.42 202.53,73.42 203.57,72.38 205.91,72.38 v3(206.47,72.93) ; R201.2 192.51,155.8 192.73,155.59 193.31,155.59 193.8,156.08 U20.2 193.8,157.21 193.62,157.39 192.37,157.39 191.56,156.58 191.56,154.52 v2(191.41,154.37)
  IN1 w0.097: v2(191.41,154.37) 192.65,154.37 192.79,154.23 192.79,147.96 195.57,145.17 195.57,144.16 196.24,143.49 196.24,139.85 198,138.1 198.46,138.1 205.22,138.1 208.65,134.66 208.65,132.82 209.18,132.29 209.18,115.84 203.9,110.56 203.9,110.36 203.9,109.9 197.51,103.51 197.51,101.55 197.51,101.55 197.51,100.91 197.79,100.63 197.79,98.76 198.73,97.83 198.73,89.55 199.28,88.99 201.83,88.99 204.45,86.37 204.45,82.05 203.66,81.26 203.66,79.92 204.18,79.4 204.18,76.34 205.5,75.02 206.47,74.05 v3(206.47,72.93)
PLTRST_MMI#: length 264.8
  TOP w0.102: v1(17.83,35.09) 17.84,35.09 18.29,34.64 v2(18.29,34.02) ; v3(190.83,78.47) 190.41,78.05 190.41,76.54 189.63,75.76 RC90.1
  IN1 w0.097: v3(161.51,91.44) 161.61,91.44 162.28,92.11 164.35,92.11 164.91,92.67 165.32,92.67 165.32,92.67 171.66,92.67 172.12,93.13 178.05,93.13 178.2,93.28 184.17,93.28 184.85,92.6 186.07,92.6 186.07,92.6 186.53,92.6 186.56,92.6 187.86,93.9 188,93.9 188.11,94.02 v3(188.08,94.02) ; v3(25.59,57.14) 18.29,49.83 v2(18.29,34.02)
  IN2 w0.076: 159.3,89.95 158.21,88.86 158.21,87.67 157.75,87.21 157.75,86.91 156.71,85.86 156.71,85.15
  IN2 w0.102: 159.3,89.95 160.79,91.44 v3(161.51,91.44) ; 156.71,85.15 156.68,85.13 156.68,84.53 156.3,84.15 156.3,82.59 155.36,81.65 155.36,76.48 153.93,75.04 153.93,72.52 155.18,71.26 155.18,69.66 154.6,69.07 153.31,69.07 153.26,69.12 143.72,69.12 143.39,69.46 138.75,69.46 137.89,68.59 134.86,68.59 134.62,68.34 129.14,68.34 128.06,69.43 120.12,69.43 118.74,70.81 118.74,74.59 118.42,74.9 103.93,74.9 102.64,73.62 96.99,73.62 94.07,76.54 92.85,76.54 92.37,77.02 88.84,77.02 88.26,76.44 88.26,75.91 87.85,75.5 83.05,75.5 81.7,76.85 61.66,76.85 57.97,80.54 57.97,82.32 56.73,83.55 51.5,83.55 49.83,81.87 49.83,73.42 45.61,69.2 36.62,69.2 25.59,58.17 v3(25.59,57.14) ; v3(188.08,94.02) 188.08,93.53 187.14,92.59 187.14,91.62 187.65,91.11 188.67,91.11 189.91,89.88 189.91,86.51 190.34,86.08 190.34,78.97 v3(190.83,78.47)
  BOTTOM w0.102: v2(18.29,34.02) R443.1
PLTRST_VMM2320#: length 177.6
  TOP w0.102: RC92.1 v6(188.74,74.99) 188.74,75.66 189.76,76.68 189.76,87.05 v3(190.45,87.74) ; v3(163.74,171.13) 166.41,168.46 168.7,168.46 173.38,163.79 175.66,163.79 175.93,163.51 175.93,163.04 U6.A13
  IN1 w0.097: v3(175.4,108.06) 171.72,108.06 170.13,106.48 168.89,106.48 168.73,106.64 166.37,106.64 165.7,107.3 164.35,107.3 164.23,107.18 162.47,107.18 162.47,107.17 154.73,107.17 150.83,111.07 150.69,111.07 148.91,112.85 148.91,114.08 142.43,120.56 v3(139.38,120.56)
  IN2 w0.102: v3(190.45,87.74) 190.58,87.87 190.58,92.38 188.5,94.46 185.98,94.46 183.82,96.62 183.82,98.57 183.43,98.96 183.43,99.92 179.96,103.39 179.96,105.41 177.31,108.06 v3(175.4,108.06)
  IN3 w0.102: v3(163.74,171.13) 162.86,170.24 158.84,170.24 151.58,162.98 151.58,149.64 150.49,148.54 145.58,148.54 143.32,146.29 143.32,139.48 133.57,129.73 133.57,120.99 134,120.56 v3(139.38,120.56)
PM_APWROK: length 84.2
  TOP w0.102: v3(189.63,60.29) 189.63,60.13 189.18,59.68 RC144.1 ; v6(189.63,58.37) 189.63,59.23 RC144.1 ; RC144.1 189.11,59.75 189.11,61.01 188.72,61.4 UC7.2 ; v2(165.9,116.7) 166.44,117.23 U38.A9
  IN2 w0.102: v3(189.63,60.29) 189.91,60.57 191.41,60.57 191.61,60.36 192.18,60.36 193.22,61.4 193.22,69.94 193.75,70.47 193.75,92.76 189.55,96.97 188.18,98.33 188.18,101.41 187.09,102.5 187.09,103.26 186.9,103.45 186.9,103.46 186.66,103.69 186.66,103.69 185.77,104.58 185,104.58 185,105.14 179.64,110.5 179.64,111.59 179.11,112.13 177.64,112.13 176.73,111.22 172.8,111.22 172.41,111.61 171.38,111.61 169.48,113.5 169.48,114.16 168.44,115.2 167.25,115.2 165.9,116.54 v2(165.9,116.7)
PM_APWROK_R: length 41.7
  TOP w0.102: v6(191.53,59.92) 191.29,60.16 v2(190.72,60.16) 190.24,59.68 RC144.2 190.09,59.92 190.11,59.93 190.11,60.47 UC7.4
  IN3 w0.076: 171.03,60.57 170.25,60.57 167.83,62.99 167.83,66.02 167.53,66.31 167.53,71.08 167.29,71.32 167,71.32 165.68,72.63 v2(165.68,72.98)
  IN3 w0.102: v2(190.72,60.16) 190.11,59.55 188.67,59.55 188.36,59.24 185.44,59.24 184.39,60.29 183.57,60.29 183.39,60.29 182.85,60.82 181.17,60.82 179.7,59.35 177.73,59.35 176.34,57.95 174.39,57.95 171.77,60.57 171.03,60.57
  BOTTOM w0.089: UC1.AB5 165.51,72.8 v2(165.68,72.98)
PM_LANPHY_ENABLE: length 167.4
  TOP w0.102: v3(188.28,141.29) v1(192.32,141.29) 196.57,141.29 196.92,141.64 R180.1 ; v2(164.82,67.43) 164.35,66.97 164.35,64.68 163.82,64.14 163.82,62.9 163.82,62.89 163.82,62.75 164.17,62.39 167.56,62.39 169.8,60.15 170.49,60.15 RC197.1 173.45,57.19 173.45,54.74 177.91,50.28 203.89,50.28 205.27,51.66 205.27,51.85 205.27,52.97 205.93,53.63 206.82,53.63 207.46,54.27 v3(207.46,55.28)
  IN2 w0.102: v3(188.28,141.29) 188.63,140.94 188.63,132.01 187.6,130.97 187.6,129.48 188.99,128.09 188.99,127.27 189.22,127.04 189.22,126.84 189.99,126.07 189.99,119.55 189.75,119.31 189.75,114.97 189.96,114.77 189.96,113.07 189.09,112.2 189.09,110.76 189.71,110.15 189.71,108.35 196.26,101.81 196.26,98.61 197.57,97.29 197.7,97.16 198.24,96.62 199.1,95.76 199.1,91.32 200.42,90 200.42,85.73 202.59,83.56 202.59,81.63 204,80.22 204,76.49 200.75,73.24 200.75,68.21 204.69,64.27 204.69,61.48 204.07,60.86 204.07,59.03 207.46,55.64 v3(207.46,55.28)
  BOTTOM w0.076: UC1.AM7 164.51,67.13 v2(164.82,67.43)
POA_WAKE#: length 4.5
  TOP w0.102: U38.B68 161.38,119.64 161.15,119.42 161.15,117.97 v1(161.97,117.15) 162.07,117.05 RP17.3
POWER_SW#_MB: length 216.5
  TOP w0.102: SW5.1 229.23,121.31 v3(231.42,123.51) ; R329.2 161.29,110.94 C340.1 161.93,110.32 176.42,110.32 178.32,112.23 181.58,112.23 186.91,106.89 196.38,106.89 199,109.51 199.19,109.51 199.19,109.51 200.83,109.51 202.35,111.04 207.31,111.04 210.74,107.61 210.74,106.9 v3(210.73,106.89) ; JPWR1.10 310.25,169.74 310.2,169.79 308.34,169.79 308.07,169.51 D27.2 308.07,167.19 308.37,166.89 308.37,164.89 305.15,161.66 305.15,159.93 304.51,159.3 303.72,159.3 303.32,158.89 298.5,158.89 297.64,158.03 290.92,158.03 290,158.94 277.63,158.94 255.08,136.4 v3(255.08,136.31)
  BOTTOM w0.102: v3(255.08,136.31) 256.85,136.31 257.1,136.05 257.1,131.97 258.11,130.97 258.11,129.93 v6(255.59,127.42) 253.97,127.42 253.66,127.72 SW6.1 249.39,125.02 247.41,125.02 246.36,123.96 231.88,123.96 v3(231.42,123.51) 230.86,122.95 230.47,122.95 228.9,121.37 228.9,113.79 228.56,113.45 226.83,111.72 226.83,106.79 227.78,105.84 227.78,103.71 227.39,103.32 226.21,102.14 224.94,102.14 222.87,102.14 222.69,102.32 215.31,102.32 v3(210.73,106.89)
POWER_SW_IN#: length 10.7
  TOP w0.102: R329.1 R327.2 C343.1 162.18,113.26 162.04,113.4 v2(161.81,113.4) ; U38.B67 161.9,120.14 v2(162.25,119.8)
  BOTTOM w0.102: v2(162.25,119.8) 162.75,119.29 162.75,116.93 163.03,116.65 163.03,116.37 162.37,115.71 v1(162.37,114.98) 162.37,113.96 v2(161.81,113.4)
PROC_OPI_RCOMP: length 9.4
  TOP w0.381: v2(161.97,56.31) 161.64,55.98 161.64,55.16 161.17,54.69 RC237.1
  BOTTOM w0.254: 160.32,59.57 160.32,59.83 159.86,60.29 159.86,61.3 159.58,61.58 159.52,61.63 UC1.AY15
  BOTTOM w0.381: v2(161.97,56.31) 161.86,56.21 v1(161.01,56.21) 160.32,56.91 160.32,59.57
PROCHOT#_EC: length 166.9
  TOP w0.076: v3(128.59,79.72) 127.93,79.06 127.75,79.06
  TOP w0.102: v2(131.82,75.5) 130.11,77.2 127.65,77.2 v3(127.24,76.8) ; U38.A46 163.44,129.45 163.2,129.69 163.2,129.98 163.07,130.11 162.39,130.11 162.27,130.23 162.27,130.52 162.4,130.64 163.11,130.64 163.24,130.77 163.24,131.3 163.36,131.43 164,131.43 164.13,131.3 164.13,130.72 164.25,130.59 164.43,130.59 164.56,130.72 164.56,132.02 164.28,132.29 164.28,133.82 v6(163.64,134.45) 162.73,134.45 162.6,134.33 R334.1 R342.2 R335.2 159.32,134.33 159.15,134.15 v3(159.15,134.07) ; Q9.2 120.06,77.44 120.38,77.76 120.86,77.76 121.68,78.59 122.11,78.59 122.58,79.06 127.75,79.06
  IN2 w0.102: v2(131.82,75.5) 131.82,74.74 132.58,73.98 132.58,72.78 133.29,72.07 135.02,72.07 136.82,73.87 148.18,73.87 151.92,77.62 151.92,81.32 151.37,81.87 151.37,84.03 152.8,85.46 152.8,86.57 153.25,87.03 153.25,88.84 153.74,89.32 153.74,90.97 155.31,92.54 155.31,94.35 154.68,94.98 154.68,96.48 153.99,97.17 153.99,101.4 153.87,101.52 152.33,101.52 151.6,102.25 151.6,105.03 150.98,105.65 145.89,105.65 145.41,106.13 140.21,106.13 136.08,110.26 131.83,110.26 131.32,109.75 129.84,109.75 v3(125.34,114.25)
  IN3 w0.102: v3(125.34,114.25) 127.18,116.09 127.19,116.09 129.33,118.22 145.84,118.22 150.32,122.71 150.32,126.19 150.51,126.38 150.51,127.17 154.34,131 156.51,131 156.94,131.43 156.94,132.19 158.82,134.07 v3(159.15,134.07) ; v3(127.24,76.8) 128.59,78.14 v3(128.59,79.72)
PROCHOT_GATE: length 95.3
  TOP w0.102: v1(199.74,117.55) 199.74,119.39 R283.2 198.47,120.05 v2(198.34,119.92) 197.87,120.39 U37.A50
  TOP w0.254: PU405.2 127.84,134.44 v3(127.78,134.38)
  IN1 w0.097: v3(127.78,134.38) 131.35,130.81 131.35,127.66 136.14,122.87 141.04,122.87 150.05,113.86 150.05,112.95 154.61,108.39 164.02,108.39 164.28,108.14 170.9,108.14 171.38,108.62 178.14,108.62 182.48,112.95 189.22,112.95 190.33,114.06 190.33,114.3 190.61,114.58 192,114.58 192.65,115.23 194.16,115.23 195.61,116.67 196.55,116.67 196.83,116.95 196.83,117.36 197.04,117.58 197.16,117.58 197.99,118.4 197.99,119.57 v2(198.34,119.92)
PS2_CLK_TS: length 96.9
  TOP w0.102: v3(177.21,106.72) 177.49,107 178.81,107 179.57,106.23 179.57,104 180.13,103.44 181.14,102.42 182.11,102.42 184.22,104.53 202.1,104.53 204.45,106.89 204.98,106.89 204.99,106.87 205.01,106.87 205.25,106.63 205.25,106.28 205.03,106.06 205.03,105.51 204.64,105.12 JKB1.9 ; JTP1.2 130.9,107.07 131.03,107.2 131.03,107.33 129.4,108.96 129.4,111.21 129.69,111.49 130.32,111.49 v4(130.47,111.64)
  IN1 w0.097: v4(130.47,111.64) 130.24,111.42 129.95,111.42 129.66,111.13 129.66,110.43 130.25,109.84 131.25,109.84 131.74,110.33 143.17,110.33 145.74,110.33 146.99,111.57 148.64,111.57 151.6,108.61 152.12,108.61 152.53,108.2 152.54,108.2 153.43,107.3 153.43,106.46 154.3,105.59 160.13,105.59 160.69,106.15 161.99,106.15 162.46,105.68 165.83,105.68 165.84,105.69 168.57,105.69 168.57,105.69 170.45,105.69 170.62,105.86 170.62,105.86 171.07,106.31 171.99,107.23 175.87,107.23 176.15,106.95 176.98,106.95 v3(177.21,106.72)
PS2_DAT_TS: length 96.1
  TOP w0.102: JTP1.3 131.4,107.04 131.26,107.17 131.26,107.42 129.63,109.05 129.63,111.11 129.78,111.26 130.19,111.26 v3(130.45,111.01) ; JKB1.8 205.64,105.13 205.26,105.51 205.26,105.97 205.48,106.19 205.48,106.73 205.1,107.1 205.09,107.1 205.07,107.11 204.36,107.11 202.01,104.76 184.12,104.76 182.01,102.65 181.24,102.65 180.29,103.6 179.8,104.1 179.8,106.33 178.9,107.23 177.46,107.23 v4(177.24,107.45)
  IN1 w0.097: v4(177.24,107.45) 176.95,107.17 176.25,107.17 175.96,107.45 171.89,107.45 170.85,106.41 170.36,105.92 168.35,105.92 168.35,105.91 165.75,105.91 165.74,105.9 162.55,105.9 162.08,106.37 160.59,106.37 160.04,105.82 154.4,105.82 153.66,106.56 153.66,107.4 152.63,108.42 152.63,108.42 152.21,108.84 151.69,108.84 148.73,111.8 146.89,111.8 145.65,110.55 143.08,110.55 131.64,110.55 131.16,110.06 130.34,110.06 129.88,110.53 129.88,111.04 130.04,111.19 130.26,111.19 v3(130.45,111.01)
