# Allegro board Alpine15_LA-A101PR10-0826C.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PCH_GPIO85: length 11.9
  IN3 w0.076: v2(165.06,77.74) 165.41,77.38 167.84,77.38 168.42,77.96 168.8,77.96 169.38,78.55
  IN3 w0.102: v2(172.33,78.02) 171.8,78.55 169.38,78.55
  BOTTOM w0.076: UC1.N6 164.86,77.54 v2(165.06,77.74)
  BOTTOM w0.102: v2(172.33,78.02) 172.53,77.81 172.53,77.69 172.77,77.46 173.12,77.46 173.32,77.66 v1(173.6,77.66) 173.7,77.76 174.68,77.76 174.79,77.65 RP9.5
PCH_GPIO87: length 30.7
  TOP w0.102: v2(179.39,95.11) 179.54,95.26 v1(180.23,95.26)
  IN2 w0.076: 169.97,76.96 169.96,76.95 168.29,76.95 167.67,76.32 166.16,76.32 166.1,76.26 165.01,76.26 164.51,76.76 164.51,76.77 164.49,76.77 164.49,76.77 v2(164.51,76.77)
  IN2 w0.102: 169.97,76.96 170.14,76.96 170.65,77.48 170.65,78.03 171.62,78.99 171.62,79.32 171.95,79.65 171.95,80.36 171.59,80.72 171.59,87.24 175.15,90.79 176.47,90.79 179.39,93.71 v2(179.39,95.11)
  BOTTOM w0.076: UC1.R7 164.2,76.45 164.51,76.76 164.51,76.77 164.49,76.77 164.49,76.77 v2(164.51,76.77)
PCH_GPIO94: length 5
  BOTTOM w0.076: 170.77,80.95 169.71,80.95 169.1,80.33 UC1.G1
  BOTTOM w0.102: 170.77,80.95 171.14,81.32 172.38,81.32 v1(172.63,81.06)
PCH_INTVRMEN: length 30.9
  TOP w0.102: v3(167.4,55.87) 167.2,55.66 RC1.2 ; RC2.1 185.94,54.61 v3(185.94,54.89)
  BOTTOM w0.076: UC1.AV7 163.98,63.07 163.74,62.84 163.74,61.51 164.01,61.24 164.01,60.93 164.06,60.88 164.06,59.49 166.69,56.86 166.69,56.37 167.2,55.87 v3(167.4,55.87) 168.24,55.87 168.9,56.53 170.78,56.53
  BOTTOM w0.102: v3(185.94,54.89) 185.43,55.41 183.68,55.41 182.92,54.65 175.7,54.65 174.12,56.22 v1(173.49,56.22) 171.94,56.22 171.63,56.53 170.78,56.53
PCH_JTAG_JTAGX: length 65
  IN2 w0.102: v3(104.13,79.44) 103.6,79.44 102.49,80.56 99.97,80.56 99.39,79.98 v3(99.39,79.67)
  BOTTOM w0.076: UC1.AE63 128.67,70.63 127.73,69.68 126.84,69.68
  BOTTOM w0.102: v3(104.13,79.44) 104.13,78.99 104.27,78.84 105.65,77.46 105.65,73.04 106.59,72.1 v1(106.59,70.94) 106.59,68.07 105.68,67.16 105.68,63.16 107.82,61.03 107.82,60.24 112,56.06 116.38,56.06 122.05,61.73 122.05,68.79 122.94,69.68 126.84,69.68 ; RC97.2 RC10.1 99.85,81.53 RC123.2 99.42,81.04 99.42,79.69 v3(99.39,79.67)
PCH_JTAG_TCK: length 77.2
  TOP w0.102: RC142.1 104,53.1 107.35,56.45 v6(107.35,58.85) v3(107.35,60.92)
  IN2 w0.102: v3(97.55,81.84) 99.82,81.84 100.22,81.44 101.92,81.44 103.29,80.07 v3(104.13,80.07)
  BOTTOM w0.076: 126.84,69.46 127.75,69.46 128.59,70.29 129.83,70.29 UC1.AE62
  BOTTOM w0.102: v3(97.55,81.84) 97.56,81.84 97.79,82.07 RC124.2 RC22.1 ; 126.84,69.46 123.08,69.46 122.28,68.66 122.28,61.63 116.48,55.83 111.9,55.83 107.35,60.38 v3(107.35,60.92) 105.3,62.97 105.3,71.64 104.59,72.35 104.59,73.72 105.25,74.38 105.25,77.51 103.72,79.03 103.72,79.67 v3(104.13,80.07)
PCH_JTAG_TCK_R: length 6.9
  TOP w0.102: JXDP1.55 96.66,50.86 97.7,51.91 v1(97.7,51.9) 98.9,53.1 RC142.2
PCH_JTAG_TDI: length 63.5
  TOP w0.102: v6(108.26,72.48) 108.23,72.45 v2(107.66,72.45)
  BOTTOM w0.076: UC1.AD61 130.58,71.65 130.05,71.65 129.81,71.41 129.81,71.28 129.63,71.1 128.66,71.1 127.75,70.19 126.84,70.19
  BOTTOM w0.102: RC96.1 RC17.1 103.35,83.66 103.88,83.13 103.88,82.59 104.64,81.83 104.64,78.8 105.9,77.55 105.9,75.54 107.84,73.6 107.84,72.63 v2(107.66,72.45) 107.66,68.43 106.18,66.94 106.18,63.31 108.27,61.22 108.27,60.43 112.19,56.51 116.19,56.51 121.5,61.83 121.5,68.99 122.7,70.19 126.84,70.19
PCH_JTAG_TDO: length 73
  TOP w0.102: v3(117.9,69.66) v6(118.55,69.66)
  IN3 w0.076: 130.08,70.57 129.85,70.34 128.77,70.34 128.13,69.71 125.92,69.71
  IN3 w0.102: 125.92,69.71 117.95,69.71 v3(117.9,69.66) ; 130.08,70.57 v2(130.51,71)
  BOTTOM w0.076: UC1.AE61 130.81,70.7 130.55,70.97 v2(130.51,71)
  BOTTOM w0.102: RC104.2 RC95.1 RC18.1 100.99,82.75 101.31,83.07 101.31,83.96 101.67,84.31 103.02,84.31 104.11,83.23 104.11,82.69 104.89,81.9 104.89,78.88 106.12,77.65 106.12,75.63 108.07,73.69 108.07,68.51 106.4,66.85 106.4,63.41 108.5,61.31 108.5,60.52 112.28,56.74 116.1,56.74 121.28,61.92 121.28,66.28 v3(117.9,69.66)
PCH_JTAG_TMS: length 56.9
  TOP w0.102: v3(106.11,73.32) v6(106.11,73.93)
  IN3 w0.102: v3(106.11,73.32) 104.87,73.32 103.29,71.74 v3(101.46,71.74)
  BOTTOM w0.076: 126.84,69.94 127.75,69.94 128.75,70.94 129.72,70.94 UC1.AD62
  BOTTOM w0.102: RC101.1 RC20.1 101.53,71.81 v3(101.46,71.74) ; 126.84,69.94 122.77,69.94 121.73,68.9 121.73,61.73 116.29,56.29 112.09,56.29 108.04,60.33 108.04,61.12 105.91,63.26 105.91,67 107.08,68.17 107.08,72.35 v3(106.11,73.32)
PCH_JTAG_TRST#: length 48.1
  TOP w0.102: v3(104.41,71.61) v6(104.41,70.9)
  IN3 w0.102: v3(104.41,71.61) 104.11,71.31 100.17,71.31 v3(99.46,72.02)
  BOTTOM w0.076: UC1.AU62 130.16,63.95 129.81,64.3 129.3,64.3 129.18,64.17 129.18,64.1 126.89,61.81
  BOTTOM w0.102: v3(99.46,72.02) 99.56,72.12 RC135.2 ; v3(104.41,71.61) 104.41,62.98 111.79,55.6 116.68,55.6 122.1,61.02 126.1,61.02 126.89,61.81
PCH_OPI_COMP: length 5.4
  TOP w0.076: RC168.1 160.77,58.33 v2(161.03,58.59)
  BOTTOM w0.076: UC1.AW15 159.53,62.58
  BOTTOM w0.089: 159.53,62.58 159.57,62.58 159.82,62.33 159.82,61.74 160.26,61.3 160.26,60.3 161.03,59.54 v1(161.03,59.19) v2(161.03,58.59)
PCH_PCIE_IREF: length 10.2
  TOP w0.381: RC163.2 147.59,91.25 149.22,89.62 v1(149.22,88.14) 149.22,86.55 150.26,85.51 151.4,85.51 v2(151.55,85.36)
  BOTTOM w0.102: UC1.B27 151.9,84.31 151.9,84.98
  BOTTOM w0.305: v2(151.55,85.36) 151.55,85.33 151.9,84.98
PCH_PCIE_RCOMP: length 13.4
  TOP w0.127: v1(152.85,94.7) 152.85,95.19 v2(152.64,95.39)
  TOP w0.381: RC161.2 152.67,95.41 v2(152.64,95.39)
  IN2 w0.381: v2(152.64,95.39) 152.34,95.08 152.34,93.4 151.58,92.64 151.58,86.32 v2(151.98,85.91)
  BOTTOM w0.305: UC1.A27 152.3,85.6 v2(151.98,85.91)
PCH_PCIE_WAKE#: length 161.4
  TOP w0.102: v2(163.67,129.86) 164.04,129.86 164.44,129.47 U38.A44
  IN1 w0.076: v2(165.7,67.56) 165.93,67.33 166.78,67.33 168.07,66.05 168.07,66.01 169.1,64.98 169.21,64.98
  IN1 w0.097: v3(201.46,78.47) 201.46,75.58 201.7,75.35 201.7,75.35 203.77,73.28 203.77,70.4 204.04,70.13 204.04,64.94 204.82,64.17 204.82,63.05 203.69,61.93 203.69,61.74 203.69,61.74 203.69,61.69 203.41,61.41 203.02,61.41 202.77,61.66 198.34,61.66 198.01,61.99 198.01,62.43 197.19,63.25 195.49,64.95 194.08,64.95 193.95,64.83 193.95,64.83 193.22,64.1 190.61,64.1 190.51,64.2 184.86,64.2 182.77,66.29 182.77,69.51 182.03,70.24 v3(180.94,70.24) 181.27,69.91 181.27,69.13 180.76,68.61 180.21,68.61 179.98,68.38 179.98,67.55 181.47,66.06 181.47,65.97 181.47,64.82 180.97,64.32 180.97,63.85 180.78,63.65 180.78,63.16 178.49,60.88 178.47,60.88 173.17,60.88 171.4,62.65 171.4,63.4 171.4,63.42 169.84,64.98 169.21,64.98
  BOTTOM w0.076: v2(165.7,67.56) 165.7,68.43 165.51,68.63 UC1.AJ5
  BOTTOM w0.102: RP3.3 182.46,73.06 181.35,71.94 181.35,71.46 v1(180.94,71.06) v3(180.94,70.24) ; v2(163.67,129.86) 165.14,128.39 165.14,126.88 166.11,125.92 166.67,125.92 167.59,125.01 170.86,125.01 172.57,126.72 173.27,126.72 173.52,126.46 173.52,126.29 175.58,124.24 175.58,121.49 176.31,120.76 176.83,120.76 177.18,120.41 177.18,115.83 177.59,115.42 177.59,111.33 180.77,108.14 181.71,108.14 183.91,105.94 183.91,103.46 183.11,102.66 183.11,102.39 183.63,101.87 183.63,101.03 184.78,99.88 184.78,99.42 186.14,98.06 189.68,98.06 190.34,97.4 192.12,97.4 192.52,96.99 194.39,96.99 197.2,94.19 197.2,90.69 200.9,86.98 200.9,85.65 200.91,85.65 200.91,84.45 200.9,84.45 200.9,79.87 201.46,79.32 v3(201.46,78.47)
PCH_PLTRST#: length 53.1
  TOP w0.102: v3(191.46,65.14) 191.85,65.14 194.58,62.41 194.58,59.98 v6(194.26,59.66) 193.34,58.74 UC3.2 193.34,57.49 193.52,57.31 193.81,57.31 193.99,57.49 UC3.1 ; v3(192.62,72.09) 192.11,72.6 RC180.2 RC91.2 RC90.2 RC92.2 188.74,71.97 v3(188.76,71.94)
  IN2 w0.076: v2(164.51,70.22) 165.32,69.42 165.32,68.65 166.84,67.12 167.68,67.12 168.62,66.18 170.88,66.18
  IN2 w0.102: 170.88,66.18 171.75,66.18 172.3,66.74 172.3,67.47 174.51,69.68 175.15,69.68 175.33,69.86 175.68,69.86 176.69,70.86 178.49,70.86 178.97,71.35 180.03,71.35 180.62,71.94 v3(188.76,71.94)
  IN3 w0.102: v3(191.46,65.14) 192.8,66.48 192.8,71.91 v3(192.62,72.09)
  BOTTOM w0.076: v2(164.51,70.22) 164.2,69.92 UC1.AG7
PCH_PLTRST#_EC: length 571.4
  TOP w0.102: R241.1 v2(308.93,186.85) ; v2(193.36,53.34) 193.36,53.99 v1(193.02,54.32) 192.69,54.66 UC3.4 ; U38.B30 170.27,125.64 v2(170.02,125.39) ; R2699.2 215.33,49.06 v2(214.85,49.54) ; U25.16 178.1,135.44 176.41,133.75 176.41,132.87 178.86,130.41 178.86,128.5 178.93,128.42 178.93,127.27 v2(177.69,126.02) ; v3(102.86,55.61) 102.86,55.69 102.63,55.92 RC109.1 ; v3(77.74,22.9) 78.2,23.35 78.79,23.35 79.04,23.11 81.56,23.11 84.04,25.59 88.05,25.59 88.56,25.08 JEXP1.35 88.56,22.24 88,21.68 87.54,21.68 v3(86.86,20.99) ; v2(188.73,126.05) 188.32,125.64 U37.B22
  IN1 w0.097: v2(188.73,126.05) 188.62,125.94 188.62,125.85 188.34,125.58 185.97,125.58 185.72,125.82 183,125.82 182.6,126.22 178.12,126.22 177.92,126.02 v2(177.69,126.02) 174.68,126.02 174.05,125.39 v2(170.02,125.39) ; v3(86.86,20.99) 87.09,20.76 87.09,19.82 88.28,18.62 101.84,18.62 102.35,19.14 160.31,19.14 162.67,16.78 179.49,16.78 180.76,15.51 209.72,15.51 210.48,14.74 225.7,14.74 227.46,16.51 227.46,20.47 226.58,21.35 226.58,25.11 215.19,36.5 215.19,49.2 v2(214.85,49.54) ; v3(202.66,52.08) 202.66,52.37 208.79,58.5 208.79,74.71 206.92,76.59 206.92,85.06 207.12,85.26 207.12,98.5 v3(207.87,99.25)
  IN2 w0.102: v3(202.66,52.08) 201.56,53.18 193.52,53.18 v2(193.36,53.34)
  IN3 w0.102: v3(206.81,130.44) 207.2,130.83 207.2,133.34 211.24,137.37 217.47,137.37 219.12,139.03 227.14,139.03 229.01,140.9 231.78,140.9 235.06,144.17 244.14,144.17 246.19,146.23 246.19,150.07 v3(246.64,150.52) 247.67,151.55 247.67,154.57 251.07,157.97 259.76,157.97 260.67,158.89 263.01,158.89 273.02,168.9 276.29,168.9 280.79,173.39 288.42,173.39 302.22,187.19 307.94,187.19 308.27,186.85 v2(308.93,186.85) ; v3(102.86,55.61) 102.86,53.8 99.23,50.16 90.2,50.16 88.6,48.56 85.61,48.56 84.57,47.53 84.57,25.59 84.98,25.18 84.98,21.69 85.68,20.99 v3(86.86,20.99)
  BOTTOM w0.102: CE14.1 77.23,24.62 77.23,23.41 v3(77.74,22.9) ; v3(207.87,99.25) 207.03,99.25 206.04,100.24 206.04,106.13 199.18,112.99 188.94,112.99 184.37,117.56 184.37,119.67 183.58,120.46 183.58,124.85 184.49,125.76 185.94,125.76 186.03,125.67 188.34,125.67 188.72,126.05 v2(188.73,126.05) 189.27,126.05 190.22,125.1 191.15,125.1 192.84,126.8 192.84,127.47 193.75,128.38 197.82,128.38 198.31,128.88 198.31,129.55 198.52,129.75 199.71,129.75 200.17,129.3 205.67,129.3 v3(206.81,130.44) ; v3(246.64,150.52) U30.1 ; v3(202.66,52.08) 205.19,52.08 206.05,52.95 207.03,52.95 207.48,52.49 207.48,52.49 210.99,48.98 214.29,48.98 v2(214.85,49.54)
PCH_PWROK: length 24.1
  TOP w0.102: v3(180.86,55.41) RC88.2 180.11,53.72 180.11,53.03 v6(179.8,52.72)
  BOTTOM w0.089: UC1.AY7 164.02,61.48 164.18,61.31 164.18,61 164.23,60.95 164.23,59.75 165.7,58.28
  BOTTOM w0.102: v3(180.86,55.41) 179.94,55.41 179.72,55.63 179.72,56.12 179.14,56.7 172.14,56.7 171.75,57.09 166.89,57.09 165.7,58.28
PCH_RSMRST#: length 20.5
  TOP w0.102: RP16.8 162.69,132.19 163.72,133.21 v3(163.82,133.21) ; R414.1 164.4,137.76 v1(164.48,137.68) 164.81,137.68 165.22,138.09 v3(166.13,138.09) 166.83,138.78 U42.1 ; v2(164.63,127) 164.25,127.38 164.25,127.91 164.19,127.96 U38.B47
  IN1 w0.097: v2(164.63,127) 164.52,127 164.23,127.29 164.23,128.57 164.07,128.73 164.07,131.56 163.39,132.24 163.39,132.78 163.71,133.09 v3(163.82,133.21) 164.23,133.61 164.23,135.27 164.36,135.41 164.36,136.31 v3(166.13,138.09)
PCH_RSMRST#_Q: length 188
  TOP w0.102: v2(162.53,139.63) 163.35,139.63 R413.2 R414.2 ; v3(211.14,50.33) 211.14,49.83 207.92,46.62 171.88,46.62 v6(166.68,51.82) 166.68,52.87 164.52,55.03 RC93.1
  IN3 w0.102: v3(184.7,89.06) 184.7,88.48 186.38,86.81 186.38,85.41 187.1,84.68 188.84,84.68 191.54,81.98 191.54,77.33 192.96,75.91 192.96,75.14 196.84,71.26 196.84,70.02 199.06,67.81 199.06,63.31 201.25,61.12 201.54,61.12 201.68,60.97 201.98,60.97 204,58.95 204,58.38 204.75,57.63 205.69,57.63 208.63,54.7 208.63,53.71 210.18,52.16 210.18,51.85 211.14,50.89 v3(211.14,50.33)
  BOTTOM w0.102: v3(184.7,89.06) 182.87,89.06 180.38,91.55 177.99,91.55 176.34,93.2 174.8,93.2 172.63,95.37 172.63,96.11 169.01,99.73 167.22,99.73 167,99.96 166.89,100.06 162.43,100.06 157.37,105.12 153.44,105.12 152.4,106.15 152.4,108.29 151.7,108.99 151.7,110.35 151.7,115.43 151.81,115.53 151.81,116.78 151.55,117.03 151.55,118.76 150.74,119.57 150.74,129.2 154.05,132.52 154.05,133.66 160.02,139.63 v2(162.53,139.63)
PCH_RSMRST#_R: length 8.4
  TOP w0.076: 164.18,58.56 163.95,58.78 163.95,59.78 164.2,60.03 v2(164.79,60.03)
  TOP w0.102: RC136.2 164.01,57.01 RC93.2 164.52,57.81 164.35,57.97 RC79.2 164.18,58.56
  BOTTOM w0.076: UC1.AW6 164.48,62.29 164.48,61.49 164.52,61.45 164.52,61.14 164.79,60.87 v2(164.79,60.03)
PCH_RTCRST#: length 90.5
  TOP w0.102: v3(220.95,75.14) 222.24,75.14 223.69,76.59 JAPS1.9 ; v2(164.35,63.52) 164.71,63.52 165.04,63.18 167.81,63.18 169.35,61.64 169.68,61.64 170.17,61.15 171.22,61.15 171.62,61.15 175.23,57.54 175.23,54.9 178.65,51.47 194.35,51.47 199.16,56.29 199.16,58.33 200.84,60 v3(201.07,60)
  BOTTOM w0.076: UC1.AU7 163.99,63.88 v2(164.35,63.52)
  BOTTOM w0.102: v3(201.07,60) 201.29,60 201.68,59.61 RC6.2 CC4.2 204.17,59.12 CMOS1.2 205.45,58.41 207.06,58.41 207.26,58.61 207.94,58.61 209.01,58.61 210.52,57.1 210.8,57.1 210.87,57.03 214.84,57.03 215.12,57.31 216.58,57.31 217.11,57.85 217.11,59.31 218.15,60.34 218.15,64.2 217.21,65.14 217.21,67.54 217.77,68.1 217.77,68.11 221.05,71.39 v1(221.05,73.87) 221.05,75.04 v3(220.95,75.14)
PCH_RTCX1: length 19.2
  TOP w0.102: RC4.2 178.91,59.17 v3(177.82,58.08) 177.82,57.19 178.53,56.48 RC5.1
  BOTTOM w0.076: UC1.AW5 165.58,62.58 165.88,62.28 165.88,61.29 166.19,60.97 167.4,60.97
  BOTTOM w0.102: v3(177.82,58.08) 173.88,58.08 v1(173.57,58.38) 172.74,59.22 171.85,59.22 170.8,60.27 168.67,60.27 167.96,60.97 167.4,60.97
PCH_RTCX1_R: length 2.9
  TOP w0.102: YC1.1 180.97,58.25 CC1.2 RC4.1
PCH_RTCX2: length 19.4
  TOP w0.102: YC1.2 180.91,57.39 CC2.2 RC5.2 178.73,57.39 178.53,57.59 v3(178.53,58.08)
  BOTTOM w0.102: UC1.AY5 165.69,61.79 165.69,61.63 165.69,61.22 166.13,60.78 167.88,60.78 168.6,60.07 168.81,59.86 170.72,59.86 171.62,58.96 172.05,58.96 173.35,57.67 v1(176.13,57.67) 178.12,57.67 v3(178.53,58.08)
PCH_SMB_ALERT#: length 7
  BOTTOM w0.076: UC1.AN2 167.49,66.09 167.79,66.39 167.95,66.55 168.33,66.55 168.64,66.24 170.32,66.24 170.39,66.31 170.77,66.31
  BOTTOM w0.102: 170.77,66.31 171.88,66.31 v1(172.41,66.84) 172.41,67.38 172.11,67.68 RC27.2
PCH_SPI_CLK: length 86
  TOP w0.102: v3(203.2,62.85) 204.27,62.85 204.59,63.16 204.59,64.17 v6(203.44,65.32) 202.6,66.15 197.15,66.15 v3(196.66,65.67)
  IN1 w0.076: 169.21,71.22 168.46,71.22 168.15,71.53 168.15,71.8 167.49,72.46 v2(167.14,72.46)
  IN1 w0.097: v3(196.66,65.67) 196.72,65.73 196.72,66.7 196.36,67.06 196.36,67.06 195.79,67.64 195.79,67.87 196.15,68.24 197.21,68.24 197.32,68.35 197.32,68.61 197.21,68.72 196.69,68.72 196.34,69.07 196.2,69.07 195.41,68.28 195.25,68.28 195,68.53 195,68.69 195.79,69.48 195.79,69.62 195.52,69.89 195.38,69.89 194.54,69.04 194.38,69.04 194.13,69.3 194.13,69.45 194.97,70.3 194.97,70.43 194.58,70.82 193.52,70.82 193.41,70.71 193.41,69.49 193.3,69.38 192.96,69.38 192.85,69.49 192.85,70.71 192.74,70.82 192.43,70.82 192.32,70.71 192.32,69.34 192.21,69.23 191.92,69.23 191.81,69.34 191.81,69.94 191.91,70.04 191.91,70.6 191.51,71 189.52,71 189.34,70.82 182.92,70.82 182.64,71.1 182.44,71.3 179.99,71.3 179.39,70.7 177.09,70.7 176.32,71.47 170.97,71.47 170.87,71.57 170.33,71.57 170.09,71.33 169.36,71.33 169.24,71.22 169.21,71.22
  IN3 w0.102: v3(201.7,71.53) 201.46,71.29 201.46,62.59 201.74,62.31 202.03,62.31 202.06,62.28 202.63,62.28 v3(203.2,62.85)
  BOTTOM w0.076: v2(167.14,72.46) 166.84,72.76 UC1.AA3
  BOTTOM w0.102: R7.2 207.43,64.38 207.43,62.62 207.09,62.28 203.76,62.28 203.19,62.85 203.19,62.85 v3(203.2,62.85) ; R20.2 196.13,63.44 196.13,65.14 v3(196.66,65.67) ; R13.1 R18.1 204.61,73.14 203.32,71.84 202.02,71.84 v3(201.7,71.53)
PCH_SPI_CS0#: length 71.9
  TOP w0.102: v3(199.76,64.93) 199.76,65.13 199.65,65.24 198.98,65.24 198.87,65.13 198.87,64.61 198.76,64.5 198.55,64.5 198.44,64.39 198.44,63.44 198.55,63.33 199.2,63.33 199.3,63.44 v1(199.3,63.97) 199.3,64.34 199.41,64.45 199.7,64.45 199.81,64.34 199.81,63.44 199.92,63.33 200.19,63.33 200.3,63.44 200.3,64.65 200.4,64.76 200.74,64.76 200.85,64.65 200.85,64.41 200.96,64.3 201.23,64.3 201.34,64.41 201.34,64.65 201.51,64.83 201.51,65.18 201.62,65.29 201.99,65.29 202.1,65.18 202.1,64.81 202.21,64.71 202.71,64.71 203.22,64.2 v3(203.22,63.97)
  IN1 w0.076: 169.21,72.31 168.29,72.31 167.26,73.34 164.97,73.34 v2(164.38,73.93)
  IN1 w0.097: v3(199.76,64.93) 199.76,64.41 199.65,64.3 198.78,64.3 198.67,64.41 198.67,65.38 198.78,65.49 199.65,65.49 199.76,65.6 199.76,68.08 199.65,68.19 199.26,68.19 199.15,68.29 199.15,68.66 199.26,68.77 199.65,68.77 199.76,68.88 199.76,69.18 199.52,69.42 196.98,69.42 194.71,71.69 191.79,71.69 191.64,71.83 189.36,71.83 189.05,71.52 183.21,71.52 182.49,72.24 171.2,72.24 171.17,72.27 171.04,72.27 170.97,72.35 169.62,72.35 169.58,72.31 169.21,72.31
  IN3 w0.102: v3(202.84,72.33) 203.5,71.67 203.5,64.25 v3(203.22,63.97)
  BOTTOM w0.076: v2(164.38,73.93) 164.2,73.75 UC1.Y7
  BOTTOM w0.102: v3(203.22,63.97) 202.74,63.97 202.63,64.08 202.63,64.49 202.74,64.6 R3.1 ; v3(202.84,72.33) 203.72,73.21 R10.1
PCH_SPI_CS1#: length 56.7
  IN1 w0.097: v2(169.46,73.97) 169.9,73.53 172.89,73.53 173.51,72.91 176.26,72.91 177.88,74.52 186.82,74.52 187.51,73.83 193.55,73.83 193.88,74.17 197.42,74.17 197.58,74.01 197.58,74.01 197.86,73.73 197.91,73.68 198.26,73.68 198.42,73.52 198.42,73.24 198.57,73.09 198.99,73.09 199.08,73.17 199.08,73.7 199.18,73.8 199.41,73.8 200.04,73.16 200.04,72.94 201.2,71.78 201.2,70.74 202.19,69.75 202.19,69.59 201.83,69.24 201.68,69.24 200.24,70.68 200.24,70.82 200.7,71.29 200.7,71.46 200.45,71.71 200.31,71.71 199.83,71.23 199.69,71.23 199.42,71.5 199.42,71.64 199.9,72.12 199.9,72.26 199.63,72.53 199.49,72.53 199.01,72.05 198.87,72.05 v3(198.5,72.42)
  BOTTOM w0.076: v2(169.46,73.97) 169.04,73.55 168.52,73.55 168.26,73.3 167.95,73.3 167.79,73.13 167,73.13 166.96,73.17 166.57,73.17 UC1.Y4
  BOTTOM w0.102: v3(198.5,72.42) 198.5,72.37 R14.1 199.2,72.6 v1(199.53,72.94) 200.5,72.94 200.93,72.5 202.15,72.5 202.35,72.71 202.35,73.14 R17.1
PCH_SPI_DIN: length 81.9
  TOP w0.102: v3(204.11,63.97) 202.4,65.67 v6(200.5,65.67) 198.68,65.67 198.57,65.56 198.57,64.97 198.46,64.86 198.09,64.86 197.98,64.75 197.98,63.6 197.87,63.49 195.93,63.49 195.82,63.6 195.82,63.91 195.93,64.02 197.34,64.02 197.45,64.13 197.45,64.42 197.34,64.53 195.88,64.53 195.77,64.64 195.77,64.93 195.88,65.04 197.14,65.04 197.25,65.14 197.25,65.56 197.36,65.67 v3(197.98,65.67)
  IN1 w0.076: 169.21,72.09 168.27,72.09 167.54,72.82 166.88,72.82 v2(166.53,72.46)
  IN1 w0.097: v3(197.98,65.67) 197.98,65.42 197.87,65.32 197.31,65.32 197.2,65.42 197.2,66.53 197.31,66.64 198.43,66.64 198.54,66.53 198.54,66.11 198.65,66 199.14,66 199.25,66.11 199.25,67.03 199.14,67.14 196.95,67.14 196.84,67.25 196.84,67.54 196.95,67.65 198.86,67.65 198.97,67.76 198.97,68.05 198.86,68.16 198.09,68.16 197.98,68.27 197.98,68.56 198.09,68.67 198.31,68.67 198.42,68.78 198.42,69.08 198.31,69.19 196.89,69.19 194.61,71.47 191.66,71.47 191.52,71.61 189.46,71.61 189.15,71.3 183.11,71.3 182.4,72.01 171.11,72.01 171.07,72.05 170.95,72.05 170.87,72.12 169.71,72.12 169.67,72.09 169.21,72.09
  IN3 w0.102: v3(204.11,63.97) 204.11,71.82 202.99,72.94 v3(201.95,72.94)
  BOTTOM w0.076: v2(166.53,72.46) 166.19,72.8 UC1.AA4
  BOTTOM w0.102: R41.1 R22.1 v3(201.95,72.94) ; R4.1 v3(204.11,63.97) ; v3(197.98,65.67) 197.98,65.11 198.97,64.12 198.97,63.64 R15.1
PCH_SPI_DO: length 82.3
  TOP w0.102: v3(195.65,62.29) 196.31,62.95 v1(196.79,62.95) 200.73,62.95 202.02,64.25 v3(202.17,64.25)
  IN1 w0.097: v3(202.17,64.25) 201.55,64.25 201.44,64.36 201.44,65.13 201.55,65.24 201.95,65.24 202.12,65.41 202.12,65.65 201.95,65.82 201.65,65.82 201.54,65.92 201.54,66.29 201.65,66.39 202.98,66.39 203.09,66.5 203.09,66.86 202.98,66.97 201.62,66.97 201.51,67.08 201.51,67.44 201.62,67.55 202.93,67.55 203.04,67.66 203.04,68.03 202.93,68.13 202.82,68.13 202.71,68.24 202.71,68.56 202.82,68.67 202.93,68.67 203.04,68.78 203.04,69.5 202.93,69.61 202.61,69.61 202.5,69.5 202.5,69.18 202.4,69.07 202.33,69.07 202.23,68.97 202.23,68.24 202.12,68.13 201.74,68.13 201.64,68.23 201.64,68.71 198.02,72.33 198.02,73.06 197.13,73.95 195.35,73.95 195.01,73.61 187.37,73.61 186.68,74.3 178.01,74.3 176.4,72.68 171.41,72.68 171.37,72.72 171.25,72.72 170.94,73.04 v2(169.88,73.04)
  IN3 w0.102: v3(205.48,72.88) 205.25,72.88 205.02,72.66 205.02,63.7 204.25,62.93 203.88,62.93 203.29,63.51 202.91,63.51 v3(202.17,64.25)
  BOTTOM w0.076: v2(169.88,73.04) 169.53,73.38 168.59,73.38 168.33,73.13 168.02,73.13 167.73,72.84 UC1.AA2
  BOTTOM w0.102: v3(202.17,64.25) 202.17,64.15 202.91,63.41 203.34,63.41 203.98,62.78 205.25,62.78 205.88,63.41 R9.2 ; R21.2 195.6,62.34 v3(195.65,62.29) ; R11.1 R12.1 205.65,72.88 v3(205.48,72.88)
PCH_SPI_DO2: length 90.4
  TOP w0.102: v3(204.08,63.33) 203.9,63.51 203.04,63.51 202.66,63.13 202.66,61.87 202.5,61.71 v1(202,61.71) 200.91,61.71 200.8,61.82 200.8,62.18 200.91,62.29 201.44,62.29 201.63,62.48 201.63,63.41 201.7,63.48 201.99,63.48 v3(202.1,63.59)
  IN1 w0.097: v2(165.03,73.93) 165.45,73.52 167.4,73.52 168.38,72.53 169.49,72.53 169.52,72.57 171.06,72.57 171.13,72.5 171.26,72.5 171.29,72.46 176.73,72.46 v2(177.97,73.7) 178.34,74.08 182.84,74.08 183.05,73.86 186.69,73.86 187.51,73.05 195.07,73.05 195.75,73.72 196.79,73.72 197.58,72.94 197.58,72.05 201.05,68.57 201.05,68.24 200.94,68.13 200.53,68.13 200.42,68.03 200.42,67.61 200.53,67.5 200.94,67.5 201.05,67.39 201.05,67.05 200.94,66.94 200.53,66.94 200.42,66.83 200.42,66.49 200.53,66.38 200.94,66.38 201.05,66.27 201.05,65.92 200.6,65.47 200.6,63.97 201.06,63.51 202,63.51 202.07,63.59 v3(202.1,63.59)
  IN3 w0.102: v3(204.08,63.33) 204.77,64.02 204.77,73.87 202.66,75.98 202.66,86.29 v3(202.31,86.64)
  BOTTOM w0.076: UC1.Y6 164.86,73.75 v2(165.03,73.93)
  BOTTOM w0.102: v3(204.08,63.33) 205.37,63.33 205.48,63.44 205.48,63.73 205.37,63.84 205.1,63.84 204.99,63.95 R6.1 ; R58.2 R59.2 202.31,85.05 v3(202.31,86.64) ; v2(177.97,73.7) 177.98,73.71 177.98,73.96 R1.2 ; v3(202.1,63.59) 201.95,63.44 201.59,63.44 201.44,63.28 R19.1
PCH_SPI_DO3: length 89.7
  TOP w0.102: v6(203.79,62.33) 203.34,61.89 v3(203.22,61.89)
  IN1 w0.097: v3(203.22,61.89) 203.22,61.94 202.94,62.22 200.46,62.22 200.3,62.38 200.3,63.43 200.19,63.54 197.73,63.54 195.52,65.75 195.52,66.38 195.21,66.69 195.21,67.58 194.81,67.98 194.35,67.98 194.13,68.2 193.57,68.2 193.46,68.31 193.46,68.63 193.35,68.74 193.01,68.74 192.9,68.63 192.9,68.31 192.79,68.2 192.48,68.2 192.37,68.31 192.37,68.63 192.26,68.74 191.95,68.74 191.84,68.63 191.84,68.42 191.73,68.31 191.34,68.31 191.23,68.42 191.23,69.27 191.12,69.38 189.91,69.38 188.94,70.34 182.72,70.34 182.24,70.82 180.68,70.82 180.46,70.6 180.46,70.44 180.46,70.05 180.74,69.77 180.74,69.39 180.46,69.12 180.46,69.11 179.61,69.11 179.26,69.46 177.31,69.46 175.86,70.9 173.21,70.9 172.73,70.42 172.13,70.42 171.79,70.08 v2(170.31,70.08)
  IN3 w0.102: v3(205.16,85.67) 203.06,83.58 203.06,80.85 204.49,79.42 204.49,76.29 205.88,74.89 205.88,64.24 203.53,61.89 v3(203.22,61.89)
  BOTTOM w0.076: 170.78,70.08 v2(170.31,70.08) 170.05,70.08 169.32,70.82 168.84,70.82 168.61,70.59 UC1.AF1
  BOTTOM w0.102: 170.78,70.08 171.52,70.08 R2.2 ; v3(205.16,85.67) 204.67,85.18 R48.2 R43.2 ; R16.2 198.75,62.95 199.23,62.47 200.35,62.47 200.83,61.99 201.86,61.99 203.11,61.99 v3(203.22,61.89) 203.34,61.76 207.25,61.76 207.92,62.42 207.92,63.97 R5.2
PCH_TXCLK+: length 32.1
  TOP w0.089: v2(102.43,147.79) 102.29,147.65 100.77,147.65 100.42,147.99 99.81,147.99 99.77,147.95 JLVDS1.26 ; v3(116.66,128.64) 116.56,128.54 U52.35
  IN1 w0.089: v2(102.43,147.79) 102.51,147.71 103.07,147.71 104.54,146.25 104.54,144.31 106.01,142.84 106.01,137.37 112.38,131.01 114.79,131.01 116.6,129.2 116.6,128.7 v3(116.66,128.64)
PCH_TXCLK-: length 32
  TOP w0.089: U52.36 116.16,128.49 v4(116.02,128.64) ; v3(102.43,147.03) 102.2,147.26 100.6,147.26 100.26,147.6 100.11,147.6 99.96,147.45 JLVDS1.27
  IN1 w0.089: v4(116.02,128.64) 116.14,128.64 116.27,128.76 116.27,129.06 114.65,130.68 112.24,130.68 105.68,137.24 105.68,142.7 104.21,144.17 104.21,146.11 102.94,147.38 102.58,147.38 102.43,147.23 v3(102.43,147.03)
PCH_TXOUT0+: length 31.7
  TOP w0.089: JLVDS1.33 98.52,144.45 98.45,144.39 98.14,144.39 97.68,143.93 96.98,143.93 v3(96.89,144.01) ; v3(112.46,126.43) 112.35,126.31 112.35,126.14 113.08,125.4 113.54,125.4 114.39,124.55 115.38,124.55 U52.41
  IN1 w0.089: v3(112.46,126.43) 112.33,126.55 112.33,126.99 102.58,136.74 102.58,140.27 99.07,143.78 97.12,143.78 v3(96.89,144.01)
PCH_TXOUT0-: length 31.7
  TOP w0.089: U52.42 114.22,124.16 113.38,125.01 112.92,125.01 111.95,125.97 111.95,126.25 v4(111.8,126.4) ; JLVDS1.34 98.67,143.95 98.63,143.99 98.3,143.99 98.2,143.89 97.84,143.53 97.2,143.53 v3(96.99,143.33)
  IN1 w0.089: v3(96.99,143.33) 97.12,143.45 98.93,143.45 102.25,140.14 102.25,136.6 111.88,126.97 112,126.85 112,126.61 v4(111.8,126.4)
PCH_TXOUT1+: length 29
  TOP w0.089: v3(114.19,125.84) 114.19,125.77 114.6,125.35 115.38,125.35 U52.39 ; v2(101.36,145.2) 101.2,145.03 101.02,145.03 100.66,145.4 99.99,145.4 99.94,145.45 JLVDS1.31
  IN1 w0.089: v2(101.36,145.2) 101.36,145.07 101.44,144.99 102.07,144.99 102.42,144.65 102.42,142.32 103.6,141.14 103.6,137.12 108.02,132.7 113.43,127.29 113.99,126.73 113.99,126.05 114.1,125.93 v3(114.19,125.84)
PCH_TXOUT1-: length 29
  TOP w0.089: v3(101.36,144.56) 101.29,144.64 100.86,144.64 100.49,145 99.99,145 99.94,144.95 JLVDS1.32 ; v4(113.55,125.84) 113.71,125.68 113.71,125.68 113.95,125.44 113.95,125.44 114.44,124.96 U52.40
  IN1 w0.089: v3(101.36,144.56) 101.46,144.66 101.94,144.66 102.09,144.51 102.09,142.18 103.27,141.01 103.27,136.98 108.02,132.23 113.2,127.05 113.66,126.6 113.66,125.94 v4(113.55,125.84)
PCH_TXOUT2+: length 30.6
  TOP w0.089: JLVDS1.29 101.19,146.45 v2(101.26,146.52) ; U52.37 115.12,126.16 114.91,126.36 114.91,126.72 115.03,126.83 115.03,128.05 v3(115.15,128.18)
  IN1 w0.089: v2(101.26,146.52) 101.46,146.32 102.53,146.32 103.39,145.45 103.39,143.55 105.05,141.9 105.05,136.99 112.16,129.88 114.32,129.88 114.93,129.26 114.93,128.4 v3(115.15,128.18)
PCH_TXOUT2-: length 30.7
  TOP w0.089: v3(101.26,145.88) 101.09,146.06 99.93,146.06 99.83,145.95 JLVDS1.30 ; v4(114.52,128.18) 114.63,128.07 114.63,127 114.52,126.88 114.52,126.2 114.96,125.76 U52.38
  IN1 w0.089: v4(114.52,128.18) 114.6,128.26 114.6,129.13 114.18,129.55 112.02,129.55 104.71,136.86 104.71,141.76 103.06,143.41 103.06,145.32 102.39,145.99 101.36,145.99 v3(101.26,145.88)
PCH_TZCLK+: length 38.5
  TOP w0.089: U52.25 120.56,127.52 121.35,128.31 121.35,128.92 v4(121.45,129.02) ; JLVDS1.16 99.87,152.95 99.94,153.01 v3(101.29,153.01)
  IN1 w0.089: v3(101.29,153.01) 103.16,153.01 108.42,147.75 108.42,145.94 110.3,144.07 110.3,143.45 111.88,141.87 111.88,141.26 117.49,135.65 118.03,135.65 121.47,132.21 121.47,129.65 121.33,129.5 121.33,129.15 v4(121.45,129.02)
PCH_TZCLK-: length 38.4
  TOP w0.089: JLVDS1.17 99.96,152.45 100.14,152.62 101.05,152.62 101.26,152.41 v4(101.26,152.32) ; v3(120.82,129.04) 120.96,128.9 120.96,128.47 120.17,127.68 120.17,126.94 U52.26
  IN1 w0.089: v3(120.82,129.04) 121,129.22 121,129.64 121.14,129.79 121.14,132.07 117.9,135.32 117.35,135.32 111.55,141.12 111.55,141.73 109.97,143.31 109.97,143.93 108.09,145.81 108.09,147.62 103.02,152.68 101.53,152.68 101.26,152.41 v4(101.26,152.32)
PCH_TZOUT0+: length 33.4
  TOP w0.089: U52.31 118.16,127.94 117.77,128.33 117.77,129.42 v3(117.82,129.48) ; JLVDS1.23 100.42,149.45 v1(100.59,149.29) 101.07,149.29 v3(101.17,149.18)
  IN1 w0.089: v3(101.17,149.18) 101.25,149.11 101.82,149.11 102.25,148.68 103.43,148.68 105.63,146.48 105.63,144.74 107.03,143.34 107.03,140.07 110.18,136.92 110.18,136.1 110.76,135.52 111.35,135.52 114.88,131.99 115.77,131.99 116.86,130.9 117.77,129.99 117.77,129.53 v3(117.82,129.48)
PCH_TZOUT0-: length 33.3
  TOP w0.089: v3(101.17,148.55) 100.83,148.89 100.42,148.89 100.26,149.06 99.97,149.06 99.86,148.95 JLVDS1.24 ; U52.32 117.77,126.94 117.77,127.78 117.38,128.17 117.38,129.28 v4(117.19,129.48)
  IN1 w0.089: v4(117.19,129.48) 117.29,129.48 117.44,129.63 117.44,129.86 116.63,130.67 115.64,131.66 114.75,131.66 111.22,135.19 110.62,135.19 109.85,135.97 109.85,136.78 106.7,139.93 106.7,143.21 105.3,144.6 105.3,146.34 103.29,148.35 102.11,148.35 101.68,148.78 101.31,148.78 101.17,148.65 v3(101.17,148.55)
PCH_TZOUT1+: length 34.6
  TOP w0.089: v3(102.31,150.32) 102.26,150.28 100.63,150.28 100.45,150.45 JLVDS1.21 ; U52.29 118.96,128.03 118.89,128.1 118.89,128.79 v4(118.91,128.82)
  IN1 w0.089: v3(102.31,150.32) 102.35,150.28 103.27,150.28 106.57,146.98 106.57,145.18 108,143.74 108,140.99 109.59,139.41 109.59,138.93 110.79,137.73 111.34,137.73 115.28,133.79 115.64,133.79 118.04,131.39 118.04,131.39 118.86,130.56 118.86,128.87 v4(118.91,128.82)
PCH_TZOUT1-: length 34.6
  TOP w0.089: v2(102.31,149.69) 102.11,149.88 100.46,149.88 100.29,150.06 99.84,150.06 99.74,149.95 JLVDS1.22 ; v3(118.25,128.84) 118.35,128.84 118.49,128.7 118.49,127.94 118.57,127.87 118.57,126.94 U52.30
  IN1 w0.089: v3(118.25,128.84) 118.35,128.84 118.53,129.02 118.53,130.42 117.71,131.25 117.71,131.26 115.5,133.46 115.14,133.46 111.21,137.4 110.66,137.4 109.26,138.8 109.26,139.27 107.67,140.86 107.67,143.6 106.43,144.85 106.24,145.04 106.24,146.85 103.14,149.95 102.57,149.95 v2(102.31,149.69)
PCH_TZOUT2+: length 37.1
  TOP w0.089: U52.27 119.76,128.12 120.39,128.74 v3(120.39,129.73) ; JLVDS1.19 100.76,151.45 v4(100.81,151.5)
  IN1 w0.089: v3(120.39,129.73) 120.29,129.83 120.29,130.45 118.96,131.77 118.96,133.06 117.3,134.72 115.67,134.72 111.26,139.13 111.18,139.13 108.93,141.38 108.93,144.13 108.02,145.04 107.5,145.56 107.5,147.37 103.36,151.5 v4(100.81,151.5)
PCH_TZOUT2-: length 37.1
  TOP w0.089: v3(119.75,129.75) 119.81,129.75 119.99,129.58 119.99,128.9 119.37,128.28 119.37,126.94 U52.28 ; JLVDS1.20 99.85,150.95 99.96,151.06 100.62,151.06 v2(100.81,150.87)
  IN1 w0.089: v3(119.75,129.75) 119.88,129.75 119.95,129.83 119.95,130.31 118.63,131.63 118.63,132.92 117.16,134.39 115.53,134.39 111.12,138.8 111.05,138.8 108.6,141.24 108.6,143.99 108.02,144.57 107.17,145.42 107.17,147.23 103.22,151.17 101.05,151.17 100.81,150.93 v2(100.81,150.87)
PCI_5048: length 2.9
  TOP w0.102: UC5.3 212.61,57.19 RC61.1 CC57.2
PCI_CLK_LPC: length 84.2
  TOP w0.102: RC184.1 214.44,56.77 v3(215.7,58.03) ; v3(205.59,59.35) 204.71,60.22 202.72,60.22 201.37,58.88 201.37,58.11 201.92,57.57 RC187.1 ; RC65.2 170.45,52.91 v3(170.62,52.74) 174.04,49.31 v6(174.04,48.89) 174.87,48.07 207.32,48.07 208.68,49.42 208.68,50.73 v3(209.52,51.57) 209.71,51.76 211.64,51.76 212.25,52.37 RC202.2 RC182.1
  IN1 w0.097: v3(209.52,51.57) 209.67,51.73 209.67,52.97 209.12,53.52 209.12,54.86 210.98,56.72 213.04,56.72 214.34,58.03 v3(215.7,58.03)
  BOTTOM w0.102: v3(205.59,59.35) 206.05,58.89 206.86,58.89 207.06,59.09 207.46,59.09 209.21,59.09 210.72,57.58 210.98,57.58 211.05,57.51 214.64,57.51 214.95,57.82 215.5,57.82 v3(215.7,58.03)
PCI_CLK_LPC_0: length 16.8
  TOP w0.076: 169.54,58.56 169.54,58.81 CC15.2 169.05,59.98 168.19,60.84 164.43,60.84 163.85,61.43 163.62,61.43 v6(162.83,62.22) 162.33,62.71 162.33,62.94 161.43,63.84 v2(161.43,64.16)
  TOP w0.102: RC65.1 169.71,57.01 169.54,57.19 169.54,58.56
  BOTTOM w0.076: v2(161.43,64.16) 160.53,64.16 160.29,64.4 160.29,64.41 160.29,64.41 160.29,64.64 160.29,64.65 160.29,65.06 160.29,65.06 160.29,65.29 160.32,65.32 160.32,65.68 160,66 UC1.AN15
PCI_CLK_LPC_1: length 16.1
  TOP w0.076: v2(159.55,65.14) 159.71,65.14 v6(160.32,64.52) 160.39,64.52 161.99,62.93 161.99,62.5 163.4,61.09 163.81,61.09 164.33,60.57 168.09,60.57 168.57,60.08 168.57,58.79 168.34,58.56
  TOP w0.102: 168.34,58.56 CC14.2 RC66.1 RC64.1
  BOTTOM w0.076: UC1.AP15 159.92,65.5 v2(159.55,65.14)
PCI_FBIN: length 4.5
  TOP w0.102: UC5.7 205.17,55.92 205.04,55.79 CC80.2 203.04,54.9 RC100.1 v1(201.95,54.9)
PCI_MEC: length 2.3
  TOP w0.102: UC5.6 204.93,57.19 204.55,57.57 RC63.1
PCI_TPM_TCM: length 3.1
  TOP w0.102: UC5.2 212.14,55.92 CC25.2 RC58.1
PCIE_CLKRQ4#: length 115.6
  TOP w0.102: RC166.2 179.72,92.47 v2(179.31,92.06) ; RC196.1 RC162.1 v3(111.01,111.12)
  IN2 w0.076: v2(165.18,75.74) 165.18,75.74 165.35,75.91 166.21,75.91 166.3,75.99 168.05,75.99 168.65,76.59 170.27,76.59 170.88,77.2
  IN2 w0.102: v2(179.31,92.06) 179.31,91.83 177.56,90.08 175.45,90.08 172.56,87.18 172.56,83.55 172.63,83.48 172.63,79.64 172.08,79.08 172.08,78.65 171.62,78.19 171.62,77.94 170.88,77.2
  IN3 w0.102: v2(152.19,115.23) 149.01,115.23 147.92,116.32 130.72,116.32 127.37,112.97 118.62,112.97 117.54,111.89 115.45,111.89 115.06,111.49 114.25,111.49 113.79,111.04 111.1,111.04 v3(111.01,111.12)
  BOTTOM w0.076: UC1.U5 165.51,75.41 v2(165.18,75.74)
  BOTTOM w0.102: v2(152.19,115.23) 152.19,109.27 152.9,108.56 152.9,106.34 153.64,105.6 157.57,105.6 162.63,100.54 167.09,100.54 167.17,100.47 167.17,100.47 167.4,100.24 169.19,100.24 173.12,96.31 173.12,95.57 175,93.69 178.22,93.69 179.31,92.59 v2(179.31,92.06)
PCIE_LAN: length 13.6
  TOP w0.102: v2(143.04,87.9) 143.34,87.6 143.64,87.6 143.86,87.83 143.86,88.73 143.45,89.14 143.45,90.26 143.06,90.66 143.06,92.97 141.95,94.07 141.95,94.41 RC49.1
  BOTTOM w0.076: v2(143.04,87.9) 143.04,87.79 143.26,87.58 143.51,87.58 143.63,87.46 143.63,85.61 143.09,85.08 143.09,84.37 143.21,84.25 143.32,84.25 143.4,84.33 UC1.A41
PCIE_LAN#: length 13.6
  TOP w0.102: RC48.1 142.22,94.41 142.22,94.18 143.32,93.08 143.32,90.77 143.72,90.37 v3(143.72,89.78) 143.72,89.25 144.13,88.84 144.13,87.72 143.75,87.34 143.09,87.34 v2(143.04,87.29)
  BOTTOM w0.076: v2(143.04,87.29) 143.17,87.41 143.44,87.41 143.46,87.39 143.46,85.68 142.93,85.14 142.93,84.3 143.15,84.09 143.25,84.09 143.4,83.93 UC1.B41
PCIE_MCARD1_DET#: length 216.6
  IN3 w0.102: v2(171.26,80.16) 170.02,81.41 170.02,87.95 171.76,89.69 171.76,92.69 172.25,93.18 173.2,93.18 176.35,96.33 177.44,96.33 177.93,96.82 180.23,96.82 184.74,101.34 185.74,101.34 185.84,101.23 187.1,101.23 188.34,102.48 197.23,102.48 204.16,109.41 206.24,109.41 214.7,117.87 219.37,117.87 222.62,121.12 222.62,127.16 225.09,129.63 225.55,129.63 229.84,133.92 230.91,133.92 233.29,136.31 233.85,136.87 239.06,136.87 240.71,138.52 246.65,138.52 257.16,149.03 262.07,149.03 263.72,150.68 263.72,151.29 265.17,152.75 266.06,152.75 271.92,158.61 v3(272.28,158.61)
  BOTTOM w0.076: UC1.J1 168.16,79.6 168.9,79.6 169.76,80.47
  BOTTOM w0.102: v3(272.28,158.61) 272.65,158.98 v1(276.06,158.98) 277.07,158.98 281.47,163.38 281.47,166.65 281.47,167.86 284.83,171.21 284.83,173.76 284.83,174.16 292.38,181.71 292.8,182.13 302.45,182.13 304.38,184.06 318.91,184.06 319.6,184.75 319.6,185.61 319.5,185.71 JMINI1.37 ; 169.76,80.47 170.96,80.47 v2(171.26,80.16) 172.04,80.16 RC185.2
PCIE_MINI2: length 10.5
  TOP w0.102: v2(144.77,86.75) 144.88,86.87 145.32,86.87 145.63,87.18 145.63,88.34 145.01,88.96 v3(145.01,89.41) 145.01,90.25 144.48,90.78 144.48,91.16 RC60.1
  BOTTOM w0.076: UC1.A37 145.77,84.69 145.77,84.81 145.81,84.85 145.99,84.85 146.05,84.91 146.05,85.15 145.77,85.43 145.77,86.38 145.71,86.45 145.71,86.85 145.41,87.15 144.61,87.15 144.49,87.03 144.49,86.87 144.61,86.75 v2(144.77,86.75)
PCIE_MINI2#: length 10.5
  TOP w0.102: v2(144.8,87.51) 144.69,87.41 144.69,87.24 144.8,87.13 145.21,87.13 145.37,87.29 145.37,88.23 144.75,88.85 144.75,90.13 144.21,90.67 144.21,91.11 RC59.1
  BOTTOM w0.076: UC1.B37 145.91,83.93 146.22,84.24 146.22,85.23 145.94,85.51 145.94,86.45 145.88,86.51 145.88,86.92 145.48,87.31 145,87.31 v2(144.8,87.51)
PCIE_MMI: length 13.7
  TOP w0.102: v2(141.93,87.15) 141.9,87.18 141.42,87.18 141.1,87.5 141.1,89.92 140.72,90.3 140.72,93.11 141.05,93.44 141.86,93.44 142.32,92.99 142.32,92.51 RC54.1
  BOTTOM w0.076: v2(141.93,87.15) 141.96,87.18 142.23,87.18 142.38,87.03 142.38,85.34 142.55,85.16 142.55,84.19 142.94,83.8 142.94,83.69 UC1.B42
PCIE_MMI#: length 13.7
  TOP w0.102: v2(141.93,87.76) 141.93,87.74 141.65,87.45 141.53,87.45 141.37,87.61 v3(141.37,89.2) 141.37,90.03 140.99,90.41 140.99,93 141.16,93.18 141.75,93.18 142.05,92.88 142.05,92.39 141.98,92.32 RC53.1
  BOTTOM w0.076: UC1.C41 143.15,83.5 143.15,83.71 143.11,83.76 143.11,83.87 142.72,84.26 142.72,85.23 142.54,85.41 142.54,87.1 141.93,87.71 v2(141.93,87.76)
PCIE_PRX_EXPTX_N: length 45.1
  TOP w0.102: R97.1 80.92,35.01 80.65,35.28 80.45,35.28 v3(80.15,34.99) 79.84,35.3 79.63,35.3 79.54,35.21 79.54,32.6 80.18,31.97 80.18,31.19 80.19,31.18 80.19,30.64 80.18,30.63 80.18,26.02 77.26,23.1 77.26,22.5 75.02,20.27 75.02,17.31 78.13,14.2 82.73,14.2 v3(83.54,15) 84.57,16.04 84.57,17.34 85.43,18.2 86.52,18.2 87.29,18.97 91.55,18.97 91.77,18.74 91.77,18.69 91.78,18.69 91.78,18.55 91.84,18.49 92.01,18.49 92.06,18.44 JEXP1.22
  BOTTOM w0.102: R94.1 80.57,35.18 80.34,35.18 v3(80.15,34.99)
PCIE_PRX_EXPTX_N_M: length 151.9
  TOP w0.102: U91.21 187.1,99.2 186.96,99.34 186.96,99.58 v3(187.19,99.81)
  IN1 w0.097: v3(187.19,99.81) 187.04,99.66 187.04,99.3 184.34,96.61 166.7,96.61 166.01,95.91 161.4,95.91 160.67,96.65 158.22,96.65 156.71,95.13 156.71,91.99 155.4,90.68 148.14,90.68 145.72,93.1 140.3,93.1 139.52,92.31 139.16,92.31 137.16,90.31 137.16,89.36 133.66,85.86 126.85,85.86 124.6,83.6 123.74,83.6 122.54,82.4 118.05,82.4 117.54,81.9 117.46,81.9 112.2,76.64 105.69,76.64 101.01,71.96 101.01,71.49 99.69,70.17 99.69,67.8 94.99,63.1 94.99,62.39 v4(95.16,62.22)
  BOTTOM w0.102: R94.2 82.11,35.11 82.99,35.11 83.51,35.63 83.51,39.97 85.87,42.33 87.95,42.33 90.49,44.87 90.49,49.52 96.05,55.08 96.05,60.72 95.01,61.76 95.01,62.07 v4(95.16,62.22)
PCIE_PRX_EXPTX_P: length 45.1
  TOP w0.102: R96.1 80.56,35.5 80.28,35.5 v3(80.15,35.62) 80.05,35.52 79.54,35.52 79.33,35.3 79.33,32.51 79.96,31.88 v3(79.96,30.91) 79.96,26.11 77.04,23.19 77.04,22.59 74.81,20.36 74.81,17.22 78.04,13.98 82.82,13.98 83.49,14.65 83.52,14.65 83.89,15.02 83.89,15.05 84.79,15.95 84.79,17.25 85.52,17.98 86.61,17.98 87.38,18.76 91.46,18.76 91.56,18.66 91.56,18.48 91.56,18.48 JEXP1.24
  BOTTOM w0.102: v3(80.15,35.62) 80.38,35.39 80.58,35.39 R95.1
PCIE_PRX_EXPTX_P_M: length 151.9
  TOP w0.102: v3(186.5,99.78) 186.59,99.78 186.74,99.63 186.74,99.29 186.6,99.15 U91.22
  IN1 w0.097: v4(94.53,62.24) 94.78,62.5 94.78,63.18 99.48,67.89 99.48,70.26 100.8,71.58 100.8,72.05 105.6,76.85 112.11,76.85 117.37,82.11 117.46,82.11 117.96,82.61 122.45,82.61 123.65,83.81 124.51,83.81 126.76,86.07 133.57,86.07 136.95,89.45 136.95,90.4 139.08,92.52 139.43,92.52 140.22,93.31 145.81,93.31 148.23,90.89 155.31,90.89 156.5,92.08 156.5,95.22 158.14,96.86 160.75,96.86 161.49,96.13 165.92,96.13 166.62,96.82 184.26,96.82 186.83,99.39 186.83,99.63 186.67,99.78 v3(186.5,99.78)
  BOTTOM w0.102: R95.2 82.22,35.33 82.9,35.33 83.29,35.72 83.29,40.06 85.78,42.54 87.86,42.54 90.27,44.96 90.27,49.61 95.84,55.17 95.84,60.63 94.8,61.67 94.8,62.03 94.58,62.24 v4(94.53,62.24)
PCIE_PRX_GLANTX_N3: length 126.8
  TOP w0.102: v3(186.02,150.49) 185.59,150.93 185.59,151 185.65,151.07 186.53,151.07 186.95,150.65 v3(187.66,150.65) 190.68,150.65 191.44,151.41 192.55,151.41 192.75,151.21 C176.2
  IN1 w0.076: 161.59,83.3 161.59,83.29 161.56,83.27 161.56,82.91 161.9,82.57 161.9,81.31 161.69,81.09 161.51,81.09 v2(161.33,80.91)
  IN1 w0.097: v3(186.02,150.49) 185.8,150.28 185.8,148.49 187.77,146.53 187.77,141.19 189.63,139.33 190.31,139.33 194.78,134.86 201.95,134.86 204.32,132.49 204.32,126.23 205.11,125.44 205.11,121.87 204.77,121.54 204.7,121.47 204.7,119.2 200.86,115.36 200.86,114.71 197.85,111.7 197.46,111.7 196.53,111.7 195.33,110.49 194.08,110.49 193.83,110.24 193.83,109.62 193.33,109.12 193.33,107.91 192.23,106.82 190.82,105.41 190.82,99 190.23,98.41 190.23,93.36 190.57,93.01 190.57,91.9 189.29,90.61 189.29,90.61 188.75,90.07 183.86,90.07 182.74,91.2 172.31,91.2 172.18,91.07 165.72,91.07 163.21,88.56 163.21,86.78 161.59,85.15 161.59,83.3
  BOTTOM w0.089: UC1.G11 161.46,80.91 v2(161.33,80.91)
PCIE_PRX_GLANTX_N3_C: length 3
  TOP w0.102: C176.1 194,151.31 194.26,151.31 194.37,151.21 194.37,151.18 194.79,150.76 194.82,150.76 195.01,150.56 195.36,150.56 195.46,150.47 U21.39
PCIE_PRX_GLANTX_P3: length 126.7
  TOP w0.102: C179.2 192.51,151.62 191.35,151.62 190.59,150.86 187.94,150.86 187.93,150.87 187.39,150.87 187.38,150.86 187.04,150.86 186.62,151.28 185.56,151.28 185.37,151.09 v4(185.37,150.49)
  IN1 w0.076: 161.37,83.3 161.37,83.29 161.4,83.27 161.4,82.85 161.74,82.5 161.74,81.37 161.62,81.25 161.45,81.25 161.33,81.37 v2(161.33,81.61)
  IN1 w0.097: v4(185.37,150.49) 185.59,150.27 185.59,148.4 187.56,146.44 187.56,141.1 189.54,139.12 190.23,139.12 194.7,134.65 201.86,134.65 204.11,132.4 204.11,126.14 204.89,125.35 204.89,122.04 204.89,122.04 204.89,121.95 204.56,121.63 204.49,121.56 204.49,119.29 200.65,115.45 200.65,114.8 197.76,111.91 197.55,111.91 196.44,111.91 195.24,110.7 194,110.7 193.62,110.33 193.62,109.71 193.12,109.21 193.12,108 192.14,107.03 192.02,106.9 192.02,106.9 190.61,105.5 190.61,99.09 190.02,98.5 190.02,93.27 190.36,92.92 190.36,91.98 189.2,90.82 188.66,90.28 183.95,90.28 182.83,91.41 172.22,91.41 172.1,91.28 165.63,91.28 163,88.65 163,86.87 161.37,85.24 161.37,83.3
  BOTTOM w0.076: v2(161.33,81.61) 161.65,81.29 UC1.F11
PCIE_PRX_GLANTX_P3_C: length 3
  TOP w0.102: C179.1 194,151.53 194.35,151.53 v3(194.73,151.14) 195.1,150.78 195.36,150.78 195.46,150.87 U21.38
PCIE_PRX_MMITX_N1: length 216.6
  IN1 w0.076: v2(158.48,80.96) 158.48,81.08 158.37,81.18 158.21,81.18 158.11,81.08 158.11,79.41 157.73,79.04 157.22,79.04 156.51,78.33 155.64,78.33 155.08,78.89 155.08,79.21 154.82,79.48 154.07,79.48 154.05,79.45 154.04,79.45
  IN1 w0.097: 154.04,79.45 136.43,79.45 134.03,77.06 133.24,77.06 133.08,77.22 126.37,77.22 125.98,76.82 121.22,76.82 120.81,76.41 119.79,76.41 118.34,74.97 116.72,74.97 115.74,73.98 115.74,72.91 114.08,71.25 106.88,71.25 104.42,68.78 104.42,64.79 101.19,61.56 101.19,59.79 98.9,57.49 98.9,57.44 98.55,57.1 97.63,57.1 93.58,53.04 80.45,53.04 73.69,59.8 70.57,59.8 64.68,65.68 55.21,65.68 53.68,67.21 37.67,67.21 35.28,64.82 32,64.82 11.83,44.66 11.83,24.03 16.78,19.09 21.68,19.09 22.24,19.65 22.24,20.15 22.06,20.33 21.73,20.33 21.45,20.06 v2(21.45,19.98)
  BOTTOM w0.089: UC1.G17 158.55,80.96 v2(158.48,80.96)
  BOTTOM w0.102: v2(21.45,19.98) 21.76,19.98 21.99,20.21 21.99,20.33 C238.1
PCIE_PRX_MMITX_N1_C: length 2.3
  BOTTOM w0.102: U27.8 22.19,22.95 22.28,22.86 22.28,22.55 21.97,22.25 21.97,21.91 C238.2
PCIE_PRX_MMITX_P1: length 216.6
  IN1 w0.076: 154.04,79.66 154.05,79.66 154.07,79.64 154.88,79.64 155.25,79.28 155.25,78.96 155.71,78.5 156.44,78.5 157.15,79.2 157.67,79.2 157.94,79.48 157.94,81.15 158.14,81.34 158.36,81.34 158.48,81.46 v2(158.48,81.61)
  IN1 w0.097: 154.04,79.66 136.34,79.66 133.95,77.27 133.33,77.27 133.17,77.43 126.28,77.43 125.89,77.03 121.13,77.03 120.72,76.63 119.7,76.63 118.25,75.18 116.64,75.18 115.53,74.07 115.53,73 113.99,71.46 106.8,71.46 104.21,68.87 104.21,64.88 100.98,61.65 100.98,59.87 98.68,57.58 98.68,57.53 98.46,57.31 97.55,57.31 93.49,53.25 80.53,53.25 73.78,60.01 70.65,60.01 64.77,65.89 55.3,65.89 53.76,67.42 37.58,67.42 35.19,65.04 31.91,65.04 11.62,44.75 11.62,23.95 16.69,18.88 21.77,18.88 22.45,19.56 22.45,19.81 22.55,19.91 v2(22.75,19.98)
  BOTTOM w0.089: UC1.F17 158.8,81.29 v2(158.48,81.61)
  BOTTOM w0.102: C237.1 22.2,20.33 22.2,20.2 22.43,19.98 v2(22.75,19.98)
PCIE_PRX_MMITX_P1_C: length 2.3
  BOTTOM w0.102: C237.2 22.19,21.94 22.19,22.16 22.5,22.47 22.5,22.85 22.59,22.95 U27.7
PCIE_PRX_WLANTX_N4: length 224.3
  IN3 w0.076: v2(160.36,81.66) 160.36,81.43 160.48,81.3 160.81,81.3 160.97,81.15 160.97,79.45 161.18,79.23 161.87,79.23 162.26,78.84 163.32,78.84 163.66,79.18 164.79,79.18 164.87,79.11 165.29,79.11 165.49,79.31 167.37,79.31 167.97,79.91 167.97,83.68 167.97,83.69 167.97,83.7
  IN3 w0.086: 167.97,83.7 167.97,88.2 170.12,90.35 170.12,93.48 171.52,94.88 172.46,94.88 172.84,95.26 172.84,95.94 173.43,96.53 174.57,96.53 175.69,97.65 176.9,97.65 179.98,100.72 180.97,100.72 183.69,103.44 183.69,104.22 184.12,104.66 197.24,104.66 204.16,111.57 206.24,111.57 214.16,119.49 219.16,119.49 221.25,121.58 221.25,128.46 224.12,131.33 224.12,134.88 225.53,136.29 228.64,136.29 230.65,138.3 232.96,138.3 233.18,138.52 238.62,138.52 240.05,139.94 245.13,139.94 252.39,147.2 252.39,150.43 256.25,154.29 265.59,154.29 272.03,160.73 273.23,160.73 v4(273.24,160.74)
  BOTTOM w0.076: v2(160.36,81.66) 160.73,81.29 UC1.F13
  BOTTOM w0.102: v4(273.24,160.74) 273.47,160.51 274.13,160.51 274.86,159.79 276.71,159.79 280.77,163.85 280.77,166.36 280.77,168.15 284.04,171.41 284.04,174.36 291.68,182 292.51,182.83 302.14,182.83 304.73,185.42 313.38,185.42 314.48,186.52 314.48,186.82 314.3,186.99 314.1,186.99 313.9,187.19 JMINI1.23
PCIE_PRX_WLANTX_P4: length 224.2
  IN3 w0.076: v2(160.36,80.91) 160.58,81.14 160.74,81.14 160.8,81.08 160.8,79.38 161.11,79.07 161.8,79.07 162.19,78.68 163.39,78.68 163.73,79.02 164.72,79.02 164.8,78.94 165.36,78.94 165.56,79.14 167.44,79.14 168.14,79.84 168.14,83.69 168.14,83.69 168.14,83.79
  IN3 w0.086: 168.14,83.79 168.14,88.13 170.3,90.28 170.3,93.41 171.59,94.71 172.54,94.71 173.02,95.19 173.02,95.87 173.5,96.35 174.64,96.35 175.76,97.47 176.97,97.47 180.05,100.55 181.04,100.55 183.86,103.36 183.86,104.15 184.19,104.48 197.32,104.48 204.23,111.39 206.31,111.39 214.24,119.32 219.23,119.32 221.43,121.51 221.43,128.39 224.3,131.26 224.3,134.81 225.6,136.12 228.72,136.12 230.73,138.12 233.04,138.12 233.26,138.34 238.7,138.34 240.12,139.77 245.2,139.77 252.57,147.13 252.57,150.36 256.32,154.12 265.67,154.12 272.1,160.55 272.82,160.55 v4(273.27,160.11)
  BOTTOM w0.089: UC1.G13 160.63,80.64 v2(160.36,80.91)
  BOTTOM w0.102: JMINI1.25 314.7,187.09 314.7,187.08 314.7,186.43 313.46,185.2 304.82,185.2 302.23,182.61 292.6,182.61 291.9,181.91 284.25,174.27 284.25,171.32 280.99,168.06 280.99,166.45 280.99,163.76 276.8,159.57 274.77,159.57 274.04,160.3 273.46,160.3 v4(273.27,160.11)
PCIE_PTX_EXPRX_N: length 45.6
  TOP w0.102: R99.1 80.6,37.31 80.37,37.31 v3(80.15,37.52) 80.03,37.4 79.36,37.4 78.63,36.66 78.63,26.91 78.6,26.88 78.6,26.36 78.63,26.34 78.63,25.93 76.34,23.65 76.34,22.88 73.97,20.51 73.97,16.2 76.93,13.25 82.62,13.25 83.75,12.11 v3(87.62,12.11) 89.13,12.11 90.24,13.22 90.24,13.77 C647.1
  BOTTOM w0.102: R99.1 80.6,37.31 80.37,37.31 v3(80.15,37.52)
PCIE_PTX_EXPRX_N_C: length 3.3
  TOP w0.102: C647.2 90.08,15.32 90.08,15.63 90.1,15.65 90.1,16.11 90.42,16.44 90.42,17.23 90.56,17.37 JEXP1.28
PCIE_PTX_EXPRX_N_M: length 153.8
  TOP w0.102: v3(186.3,101.83) 186.1,101.62 186.1,100.51 185.96,100.37 185.96,99.5 186.1,99.37 U91.23
  IN1 w0.097: v4(94.91,64.83) 94.91,64.74 94.76,64.59 94.52,64.59 94.43,64.68 94.43,65.17 95.35,66.09 96.98,66.09 98.96,68.06 98.96,70.53 100.3,71.87 100.3,72.22 105.5,77.42 112,77.42 116.58,82 116.58,82.69 116.98,83.09 122.24,83.09 123.16,84.01 123.16,84.31 125.48,86.64 133.46,86.64 136.47,89.66 136.47,90.6 138.88,93 139.23,93 140.02,93.79 146.01,93.79 146.64,93.15 148.35,91.44 154.66,91.44 156,92.78 156,96.11 158.15,98.26 165.98,98.26 166.28,98.56 169.92,98.56 170.07,98.71 179.11,98.71 180.48,100.08 183.87,100.08 184.82,101.03 185.8,101.03 186.11,101.33 186.11,101.63 v3(186.3,101.83)
  BOTTOM w0.102: R93.2 81.83,37.3 81.93,37.2 82.31,37.2 82.5,37.39 82.5,41.78 88.88,48.16 88.88,49.22 95.05,55.4 95.05,60.07 95.05,60.41 93.39,62.08 93.39,63.95 93.98,64.55 94.69,64.55 94.91,64.77 v4(94.91,64.83)
PCIE_PTX_EXPRX_P: length 45.5
  TOP w0.102: R98.1 80.92,36.79 80.61,37.1 80.36,37.1 v3(80.15,36.89) 80.15,36.94 79.91,37.18 79.45,37.18 78.84,36.57 v3(78.84,26.63) 78.84,25.84 76.56,23.56 76.56,22.79 74.18,20.42 74.18,16.29 77.02,13.46 82.71,13.46 83.84,12.33 87.34,12.33 87.35,12.34 87.9,12.34 87.91,12.33 89.04,12.33 90.02,13.31 90.02,14.15 89.86,14.31 89.63,14.31 89.46,14.15 C648.1
  BOTTOM w0.102: v3(80.15,36.89) 80.36,37.1 80.61,37.1 80.92,36.79 R98.1
PCIE_PTX_EXPRX_P_C: length 3.3
  TOP w0.102: C648.2 89.87,15.33 v3(89.87,15.91) 89.87,16.19 90.2,16.52 90.2,17.19 90.06,17.33 JEXP1.30
PCIE_PTX_EXPRX_P_M: length 153.8
  TOP w0.102: v4(185.66,101.83) 185.88,101.61 185.88,100.6 185.75,100.46 185.75,99.5 185.6,99.35 U91.24
  IN1 w0.097: v3(94.91,64.2) 94.73,64.38 94.43,64.38 94.21,64.59 94.21,65.25 95.26,66.3 96.9,66.3 98.75,68.15 98.75,70.62 100.09,71.96 100.09,72.31 105.42,77.63 111.91,77.63 116.37,82.09 116.37,82.78 116.89,83.3 122.15,83.3 122.94,84.1 122.94,84.4 125.4,86.85 133.37,86.85 136.26,89.74 136.26,90.68 138.79,93.21 139.15,93.21 139.93,94 146.1,94 146.85,93.24 146.85,93.24 148.44,91.65 154.58,91.65 155.79,92.87 155.79,96.19 158.06,98.47 165.89,98.47 166.19,98.77 169.83,98.77 169.98,98.92 179.02,98.92 180.39,100.29 183.79,100.29 184.73,101.24 185.72,101.24 185.9,101.42 185.9,101.73 185.8,101.83 v4(185.66,101.83)
  BOTTOM w0.102: v3(94.91,64.2) 94.78,64.33 94.07,64.33 93.6,63.86 93.6,62.17 95.27,60.5 95.27,60.16 95.27,55.31 89.09,49.13 89.09,48.07 82.72,41.69 82.72,37.3 82.4,36.98 82.07,36.98 R71.2
PCIE_PTX_GLANRX_N3: length 114.1
  TOP w0.102: C181.1 192.75,149.22 192.38,149.58 189.39,149.58 189.37,149.57 188.83,149.57 188.81,149.58 184.03,149.58 183.84,149.39 183.84,149.18 184.14,148.88 v2(184.18,148.88)
  IN3 w0.086: v2(143.86,105.35) 143.65,105.55 143.65,105.7 143.99,106.04 144.87,106.04 145.83,105.08 151.67,105.08 151.79,104.95 170.08,104.95 174.54,109.41 175.18,109.41 181.13,115.35 181.13,122.79 180.58,123.33 180.58,137.81 183.63,140.86 183.63,145.41 184.31,146.09 184.31,148.15 183.94,148.52 183.94,148.64 v2(184.18,148.88)
  BOTTOM w0.076: 150.67,87.12 150.67,87.1 150.64,87.07 150.64,83.53 UC1.C29
  BOTTOM w0.102: v2(143.86,105.35) 143.73,105.22 143.73,103.39 146.85,100.27 146.85,98.36 146.32,97.83 146.32,93.59 147.26,92.65 147.72,92.65 150.67,89.7 150.67,87.12
PCIE_PTX_GLANRX_N3_C: length 2.7
  TOP w0.102: U21.42 195.54,149.27 195.43,149.38 v3(194.83,149.38) 194.47,149.38 194.4,149.44 193.97,149.44 C181.2
PCIE_PTX_GLANRX_P3: length 114.1
  TOP w0.102: v2(183.6,148.88) 183.62,148.91 183.62,149.48 183.94,149.8 v3(189.09,149.8) 192.52,149.8 C178.1
  IN3 w0.086: v2(143.27,105.35) 143.47,105.55 143.47,105.77 143.92,106.22 144.94,106.22 145.9,105.25 151.74,105.25 151.86,105.13 170.01,105.13 174.47,109.58 175.11,109.58 180.95,115.42 180.95,122.72 180.41,123.26 180.41,137.88 183.46,140.93 183.46,145.49 184.13,146.16 184.13,148.08 183.76,148.45 183.76,148.71 v2(183.6,148.88)
  BOTTOM w0.076: UC1.B30 150.31,83.58 150.16,83.73 150.16,83.83 150.25,83.93 150.42,83.93 150.48,83.98 150.48,87.07 150.45,87.1 150.45,87.12
  BOTTOM w0.102: 150.45,87.12 150.45,89.61 147.63,92.43 147.17,92.43 146.1,93.5 146.1,97.92 146.64,98.45 146.64,100.18 143.51,103.3 143.51,105.1 v2(143.27,105.35)
