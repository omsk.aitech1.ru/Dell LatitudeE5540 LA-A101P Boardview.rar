# Allegro board Alpine15_LA-A101PR10-0826C.brd (continued)
## Nets (continued)
IOR_DB_DET#: JIO1.80 R476.1 U37.B62
IRQ_SERIRQ: RP10.6 U25.27 U37.B21 U38.A28 UC1.T4
JTAG_CLK: JDEG1.4 RP2.3 U38.B56
JTAG_RST#: C362.1 JTAG1.1 R380.2 R384.1 U38.A57
JTAG_TDI: JDEG1.2 RP2.1 U38.A51
JTAG_TDO: JDEG1.5 RP2.4 U38.B55
JTAG_TMS: JDEG1.3 RP2.2 U38.A53
KB_DET#: JKB1.10 RP13.1 UC1.AT3
LAN_ACTLED_YEL#: JIO1.21 Q32.1
LAN_ACTLED_YEL#_Q: Q32.6 U23.17
LAN_DISABLE#_R: R180.2 U21.3 U37.B47
LAN_RST#: R331.1 U20.1 UC1.Y1
LAN_SMBCLK: RC186.1 U21.28 UC1.AN1
LAN_SMBDATA: RC192.1 U21.31 UC1.AK1
LAN_TEST_EN: R184.1 U21.30
LAN_TX0+: L27.1 U21.13
LAN_TX0+R: L27.2 U23.2
LAN_TX0-: L28.1 U21.14
LAN_TX0-R: L28.2 U23.3
LAN_TX1+: L29.1 U21.17
LAN_TX1+R: L29.2 U23.6
LAN_TX1-: L30.1 U21.18
LAN_TX1-R: L30.2 U23.7
LAN_TX2+: L31.1 U21.20
LAN_TX2+R: L31.2 U23.9
LAN_TX2-: L32.1 U21.21
LAN_TX2-R: L32.2 U23.10
LAN_TX3+: L33.1 U21.23
LAN_TX3+R: L33.2 U23.11
LAN_TX3-: L34.1 U21.24
LAN_TX3-R: L34.2 U23.12
LAN_WAKE#: R179.1 RC211.1 U38.B27
LAN_WAKE#_R: R176.1 R179.2 U21.2
LANCLK_REQ#: R169.1 RP10.8 UC1.AD1
LANCLK_REQ#_R: R169.2 U21.48
LCD_CBL_DET#: JLVDS1.14 RP9.8 UC1.J3
LCD_ENVDD_CVT: R110.1 U52.20 U86.1
LCD_TST: JLVDS1.37 R309.2 U37.A36
LCD_VCC_TEST_EN: D76.3 U37.A40
LED_10_GRN#: JIO1.25 Q22.4
LED_10_GRN#_Q: Q22.3 U23.41
LED_100_ORG#: JIO1.23 Q32.4
LED_100_ORG#_Q: Q32.3 U23.18
LED_DET#: JLED1.4 R478.1 U37.A34
LED_SATA_DIAG_OUT#: D24.1 U37.A10
LED_WWAN_OUT#: JMINI2.42 Q30.4 R226.1
LG_3V: PQ53.4 PU51.11
LG_5V: PQ54.4 PU51.15
LG_+VDDRP: PQ701.4 PU700.6
LID_CL#: JUDB1.19 R325.1 U47.2
LID_CL_SIO#: C337.1 R322.2 R325.2 U37.B54
LOM_ACTLED_YEL#: U21.26 U23.15
LOM_SPD10LED_GRN#: U21.25 U23.42 U24.2
LOM_SPD100LED_ORG#: U21.27 U23.16 U24.1
LP_CTL: R55.1 U6.B2
LPC_LAD0: R234.2 U25.26 U37.A27 U38.A30 UC1.AU14
LPC_LAD1: R236.2 U25.23 U37.A26 U38.B32 UC1.AW12
LPC_LAD2: R240.2 U25.20 U37.B26 U38.A31 UC1.AY12
LPC_LAD3: R239.2 U25.17 U37.B25 U38.B33 UC1.AW11
LPC_LFRAME#: R238.2 U25.22 U37.A21 U38.B31 UC1.AV12
LX_DGPU: PL300.1 PR324.2 PU301.4
M_CLK_DDR0: JDIMM1.101 UC1.AV37
M_CLK_DDR1: JDIMM1.102 UC1.AY36
M_CLK_DDR2: JDIMM2.101 UC1.AN38
M_CLK_DDR3: JDIMM2.102 UC1.AL38
M_CLK_DDR#0: JDIMM1.103 UC1.AU37
M_CLK_DDR#1: JDIMM1.104 UC1.AW36
M_CLK_DDR#2: JDIMM2.103 UC1.AM38
M_CLK_DDR#3: JDIMM2.104 UC1.AK38
M_ODT0: JDIMM1.116 R29.2
M_ODT1: JDIMM1.120 R30.2
M_ODT2: JDIMM2.116 R31.2
M_ODT3: JDIMM2.120 R33.2
MASK_BASE_LEDS#: Q22.5 Q28.2 Q32.2 Q32.5 U47.4
MASK_SATA_LED#: Q24.5 U37.B9
MCARD_PCIE_MSATA#: RC12.1 U37.B3 UC1.AC1
MCARD_WWAN_PWREN: RC191.1 U37.B42 U51.5
MCP_TESTLOW1: RC46.1 UC1.C35
MCP_TESTLOW2: RC47.1 UC1.C34
MCP_TESTLOW3: RC50.1 UC1.AK8
MCP_TESTLOW4: RC52.1 UC1.AL8
ME_FWP: R326.1 RC9.1 U37.A8
ME_RESET#: RC76.1 RC81.2 UC2.2
ME_SUS_PWR_ACK: RC70.2 RC94.1 U38.A8
ME_SUS_PWR_ACK_R: RC82.1 RC94.2 UC1.AV4
MEC_XTAL1: C364.1 U38.A61 Y4.1
MEC_XTAL2: C365.1 R378.1 Y4.2
MEC_XTAL2_R: R378.2 U38.A62
MED_DET#: JMED1.4 R477.1 U37.B53
MEDIACARD_IRQ#: RP12.8 U27.16 UC1.AB6
MEDIACARD_PWREN: RC181.1 U27.14
MEDIACARD_PWREN_R: RC175.1 RC181.2 UC1.AP1
MEDIACARD_RST#: T191.1(TP-1) UC1.AG6
MEM_SMBCLK: QC1.6 RC28.2 UC1.AP2
MEM_SMBDATA: QC1.3 RC30.2 UC1.AH1
MINI2CLK_REQ#: JMINI1.7 RP11.5 UC1.N1
MINI_CARD_RST#: JMINI1.22 JMINI2.22 R26.1 U30.4
MMICLK_REQ#: RC55.2 U27.17 UC1.U2
MODC_EN: U29.4 U37.B7
MPCIE_RST#: RC138.2 U30.2 UC1.V1
MPHYP_PWR_EN: Q143.2 RC169.1 RC170.1 U94.4 UC1.Y2
MPHYP_PWR_EN#: Q143.5 Q143.6 R108.2
MSATA_DEVSLP: JMINI2.44 R480.1 UC1.P2
MSCLK: JDEG1.6 R395.2 U38.B43
MSDATA: JDEG1.7 R366.2 R398.2 U38.A40
NB_PSID: PJPDC1.1 PL3.1
NB_PSID_TS5A63157: PD5.1 PR8.2 PR9.2 PU1.3
NVVDD_GND_SENSE: PR615.1 UV1.F1
NVVDD_SENSE: PR618.1 UV1.F2
O-USR: PR304.2 PR309.1 PU300.9
OCP-I: PR301.2 PR306.1 PU300.12
ODD_DA#: JSATA2.11 RC137.2 UC1.U6
P33ALW: PR553.1 PU701.18
P33ALW2: PR550.2 PU701.9
P50ALW: PR536.1 PU701.27
PANEL_BKEN_CVT: R2586.1 U52.44 U87.1
PANEL_BKEN_EC: D80.3 U37.A35
PANEL_BKLEN: U87.2 UC1.A9
PBAT_PRES#: PD4.1 PQ506.1 PR2.2 PR4.2 PU502.1 U37.B40
PBAT_SMBCLK: PR3.2 RP15.1 U38.A56
PBAT_SMBDAT: PR5.2 RP15.2 U38.B59
PBATT+_C: PBATT2.8 PBATT2.9 PC3.1 PL1.1 PL2.1
PC_BEEP: C143.1 R160.1 R353.1
PC_SPKR: C133.1 R167.1 R387.1
PCH_ALW_ON: R416.1 RP18.7 U38.A23
PCH_AUDIO_EN: RP3.4 UC1.P1
PCH_AZ_BITCLK: RC26.2 UC1.AW8
PCH_AZ_CODEC_BITCLK: CC5.1 R149.1 RC26.1 U17.6
PCH_AZ_CODEC_RST#: R142.1 RC25.1 U17.11
PCH_AZ_CODEC_SDIN0: R136.1 UC1.AY10
PCH_AZ_CODEC_SDOUT: R148.1 RC23.1 U17.5
PCH_AZ_CODEC_SYNC: RC24.1 U17.10
PCH_AZ_RST#: RC25.2 UC1.AU8
PCH_AZ_SDIN0_R: R136.2 U17.8
PCH_AZ_SDOUT: RC3.2 RC9.2 RC23.2 UC1.AU11
PCH_AZ_SYNC: RC24.2 UC1.AV11
PCH_BATLOW#: RP3.2 UC1.AN4
PCH_CL_CLK1: JMINI1.45 UC1.AF2
PCH_CL_DATA1: JMINI1.47 UC1.AD2
PCH_CL_RST1#: R223.1 UC1.AF4
PCH_CL_RST1#_R: JMINI1.49 R223.2
PCH_DPWROK: R319.1 RC79.1 UC1.AV5
PCH_GPIO0: UC1.K4
PCH_GPIO3: UC1.J4
PCH_GPIO9: RP14.5 UC1.AM3
PCH_GPIO10: UC1.AM2
PCH_GPIO14: UC1.AH4
PCH_GPIO15: RC190.2 UC1.AD6
PCH_GPIO24: UC1.AD5
PCH_GPIO26: UC1.AN3
PCH_GPIO28: UC1.AD7
PCH_GPIO36: RP10.7 UC1.V6
PCH_GPIO44: RP12.5 UC1.AK4
PCH_GPIO46: RC230.2 UC1.AG3
PCH_GPIO48: R76.2 RC286.2 UC1.U4
PCH_GPIO59: UC1.AT5
PCH_GPIO60: UC1.AL2
PCH_GPIO66: RC283.2 RC288.1 UC1.D3
PCH_GPIO70: UC1.C4
PCH_GPIO73: RP13.4 UC1.AU4
PCH_GPIO83: RC85.1 RC290.2 UC1.R6
PCH_GPIO84: RC291.2 UC1.L6
PCH_GPIO85: RP9.5 UC1.N6
PCH_GPIO87: UC1.R7
PCH_GPIO93: UC1.J2
PCH_GPIO94: UC1.G1
PCH_INTVRMEN: RC1.2 RC2.1 UC1.AV7
PCH_JTAG_JTAGX: RC10.1 RC97.2 RC123.2 UC1.AE63
PCH_JTAG_TCK: RC22.1 RC124.2 RC142.1 UC1.AE62
PCH_JTAG_TCK_R: JXDP1.55 RC142.2
PCH_JTAG_TDI: RC17.1 RC96.1 UC1.AD61
PCH_JTAG_TDO: RC18.1 RC95.1 RC104.2 UC1.AE61
PCH_JTAG_TMS: RC20.1 RC101.1 UC1.AD62
PCH_JTAG_TRST#: RC135.2 UC1.AU62
PCH_OPI_COMP: RC168.1 UC1.AW15
PCH_PCIE_IREF: RC163.2 UC1.B27
PCH_PCIE_RCOMP: RC161.2 UC1.A27
PCH_PCIE_WAKE#: RP3.3 U38.A44 UC1.AJ5
PCH_PLTRST#: RC90.2 RC91.2 RC92.2 RC180.2 UC1.AG7 UC3.1 UC3.2
PCH_PLTRST#_EC: CE14.1 JEXP1.35 R241.1 R2699.2 RC109.1 U25.16 U30.1 U37.B22 U38.B30 UC3.4
PCH_PWROK: RC88.2 UC1.AY7
PCH_RSMRST#: R414.1 RP16.8 U38.B47 U42.1
PCH_RSMRST#_Q: R413.2 R414.2 RC93.1
PCH_RSMRST#_R: RC79.2 RC93.2 RC136.2 UC1.AW6
PCH_RTCRST#: CC4.2 CMOS1.2 JAPS1.9 RC6.2 UC1.AU7
PCH_RTCX1: RC4.2 RC5.1 UC1.AW5
PCH_RTCX1_R: CC1.2 RC4.1 YC1.1
PCH_RTCX2: CC2.2 RC5.2 UC1.AY5 YC1.2
PCH_SMB_ALERT#: RC27.2 UC1.AN2
PCH_SPI_CLK: R7.2 R13.1 R18.1 R20.2 UC1.AA3
PCH_SPI_CS0#: R3.1 R10.1 UC1.Y7
PCH_SPI_CS1#: R14.1 R17.1 UC1.Y4
PCH_SPI_DIN: R4.1 R15.1 R22.1 R41.1 UC1.AA4
PCH_SPI_DO: R9.2 R11.1 R12.1 R21.2 UC1.AA2
PCH_SPI_DO2: R1.2 R6.1 R19.1 R58.2 R59.2 UC1.Y6
PCH_SPI_DO3: R2.2 R5.2 R16.2 R43.2 R48.2 UC1.AF1
PCH_TXCLK+: JLVDS1.26 U52.35
PCH_TXCLK-: JLVDS1.27 U52.36
PCH_TXOUT0+: JLVDS1.33 U52.41
PCH_TXOUT0-: JLVDS1.34 U52.42
PCH_TXOUT1+: JLVDS1.31 U52.39
PCH_TXOUT1-: JLVDS1.32 U52.40
PCH_TXOUT2+: JLVDS1.29 U52.37
PCH_TXOUT2-: JLVDS1.30 U52.38
PCH_TZCLK+: JLVDS1.16 U52.25
PCH_TZCLK-: JLVDS1.17 U52.26
PCH_TZOUT0+: JLVDS1.23 U52.31
PCH_TZOUT0-: JLVDS1.24 U52.32
PCH_TZOUT1+: JLVDS1.21 U52.29
PCH_TZOUT1-: JLVDS1.22 U52.30
PCH_TZOUT2+: JLVDS1.19 U52.27
PCH_TZOUT2-: JLVDS1.20 U52.28
PCI_5048: CC57.2 RC61.1 UC5.3
PCI_CLK_LPC: RC65.2 RC182.1 RC184.1 RC187.1 RC202.2
PCI_CLK_LPC_0: CC15.2 RC65.1 UC1.AN15
PCI_CLK_LPC_1: CC14.2 RC64.1 RC66.1 UC1.AP15
PCI_FBIN: CC80.2 RC100.1 UC5.7
PCI_MEC: RC63.1 UC5.6
PCI_TPM_TCM: CC25.2 RC58.1 UC5.2
PCIE_CLKRQ4#: RC162.1 RC166.2 RC196.1 UC1.U5
PCIE_LAN: RC49.1 UC1.A41
PCIE_LAN#: RC48.1 UC1.B41
PCIE_MCARD1_DET#: JMINI1.37 RC185.2 UC1.J1
PCIE_MINI2: RC60.1 UC1.A37
PCIE_MINI2#: RC59.1 UC1.B37
PCIE_MMI: RC54.1 UC1.B42
PCIE_MMI#: RC53.1 UC1.C41
PCIE_PRX_EXPTX_N: JEXP1.22 R94.1 R97.1
PCIE_PRX_EXPTX_N_M: R94.2 U91.21
PCIE_PRX_EXPTX_P: JEXP1.24 R95.1 R96.1
PCIE_PRX_EXPTX_P_M: R95.2 U91.22
PCIE_PRX_GLANTX_N3: C176.2 UC1.G11
PCIE_PRX_GLANTX_N3_C: C176.1 U21.39
PCIE_PRX_GLANTX_P3: C179.2 UC1.F11
PCIE_PRX_GLANTX_P3_C: C179.1 U21.38
PCIE_PRX_MMITX_N1: C238.1 UC1.G17
PCIE_PRX_MMITX_N1_C: C238.2 U27.8
PCIE_PRX_MMITX_P1: C237.1 UC1.F17
PCIE_PRX_MMITX_P1_C: C237.2 U27.7
PCIE_PRX_WLANTX_N4: JMINI1.23 UC1.F13
PCIE_PRX_WLANTX_P4: JMINI1.25 UC1.G13
PCIE_PTX_EXPRX_N: C647.1 R93.1 R99.1
PCIE_PTX_EXPRX_N_C: C647.2 JEXP1.28
PCIE_PTX_EXPRX_N_M: R93.2 U91.23
PCIE_PTX_EXPRX_P: C648.1 R71.1 R98.1
PCIE_PTX_EXPRX_P_C: C648.2 JEXP1.30
PCIE_PTX_EXPRX_P_M: R71.2 U91.24
PCIE_PTX_GLANRX_N3: C181.1 UC1.C29
PCIE_PTX_GLANRX_N3_C: C181.2 U21.42
PCIE_PTX_GLANRX_P3: C178.1 UC1.B30
PCIE_PTX_GLANRX_P3_C: C178.2 U21.41
PCIE_PTX_MMIRX_N1: C236.1 UC1.C30
PCIE_PTX_MMIRX_N1_C: C236.2 U27.5
PCIE_PTX_MMIRX_P1: C235.1 UC1.C31
PCIE_PTX_MMIRX_P1_C: C235.2 U27.6
PCIE_PTX_WLANRX_N4: C242.1 UC1.B29
PCIE_PTX_WLANRX_N4_C: C242.2 JMINI1.31
PCIE_PTX_WLANRX_P4: C243.1 UC1.A29
PCIE_PTX_WLANRX_P4_C: C243.2 JMINI1.33
PCIE_WAKE#: JEXP1.40 JMINI1.1 JMINI2.1 R340.2 U38.B38
PD#B: R2626.1 U83.5
PE_REXT: R205.2 U27.4
PE_RST#: R27.1 R443.2 U27.15
PECI_EC: R375.2 UC1.N62
PECI_EC_R: C395.1 R375.1 U38.A48
PEG_A_CLKRQ#: QC11.3 RC162.2
PEG_EXP: RC188.1 UC1.C42
PEG_EXP#: RC160.1 UC1.C43
PEG_GTX_C_HRX_N0: CV2403.1 R106.1
PEG_GTX_C_HRX_N0_M: R97.2 R101.1
PEG_GTX_C_HRX_N0_R: R101.2 R106.2 UC1.F10
PEG_GTX_C_HRX_N1: CV2405.1 UC1.F8
PEG_GTX_C_HRX_N2: CV2407.1 UC1.H10
PEG_GTX_C_HRX_N3: CV2401.1 UC1.E6
PEG_GTX_C_HRX_P0: CV2402.1 R105.1
PEG_GTX_C_HRX_P0_M: R96.2 R100.1
PEG_GTX_C_HRX_P0_R: R100.2 R105.2 UC1.E10
PEG_GTX_C_HRX_P1: CV2404.1 UC1.E8
PEG_GTX_C_HRX_P2: CV2406.1 UC1.G10
PEG_GTX_C_HRX_P3: CV2408.1 UC1.F6
PEG_GTX_HRX_N0: CV2403.2 UV1.AB9
PEG_GTX_HRX_N1: CV2405.2 UV1.AC10
PEG_GTX_HRX_N2: CV2407.2 UV1.AC11
PEG_GTX_HRX_N3: CV2401.2 UV1.AB12
PEG_GTX_HRX_P0: CV2402.2 UV1.AC9
PEG_GTX_HRX_P1: CV2404.2 UV1.AB10
PEG_GTX_HRX_P2: CV2406.2 UV1.AD11
PEG_GTX_HRX_P3: CV2408.2 UV1.AC12
PEG_HTX_C_GRX_N0: CU16.1 UV1.AG7
PEG_HTX_C_GRX_N1: CU18.1 UV1.AE7
PEG_HTX_C_GRX_N2: CU20.1 UV1.AF9
PEG_HTX_C_GRX_N3: CU22.1 UV1.AG10
PEG_HTX_C_GRX_P0: CU17.1 UV1.AG6
PEG_HTX_C_GRX_P1: CU19.1 UV1.AF7
PEG_HTX_C_GRX_P2: CU21.1 UV1.AE9
PEG_HTX_C_GRX_P3: CU23.1 UV1.AG9
PEG_HTX_GRX_N0: CU16.2 R102.2 UC1.C23
PEG_HTX_GRX_N0_M: R99.2 R102.1
PEG_HTX_GRX_N1: CU18.2 UC1.B23
PEG_HTX_GRX_N2: CU20.2 UC1.B21
PEG_HTX_GRX_N3: CU22.2 UC1.B22
PEG_HTX_GRX_P0: CU17.2 R104.2 UC1.C22
PEG_HTX_GRX_P0_M: R98.2 R104.1
PEG_HTX_GRX_P1: CU19.2 UC1.A23
PEG_HTX_GRX_P2: CU21.2 UC1.C21
PEG_HTX_GRX_P3: CU23.2 UC1.A21
PEG_VGA: RC179.1 RC201.1 UC1.B39
PEG_VGA#: RC157.1 RC165.1 UC1.A39
PEG_VGA_EXP: RC200.1 RC201.2
PEG_VGA_EXP#: RC164.1 RC165.2
PEX_PLL_CLK_OUT: RV2.2 UV1.AF22
PEX_PLL_CLK_OUT#: RV2.1 UV1.AE22
PEX_PLLVDD_GPU: CV97.1 CV227.1 CV3056.1 LV74.1 UV1.AA14 UV1.AA15
PEX_TERMP: RV2703.1 UV1.AF25
PGOOD_3V_5V: PR58.2 PR60.2 PU51.7
PIRQ#_TPM: R73.2 RC146.2 UC1.N4
PIRQD: R75.2 RC148.2 UC1.N2
PLT_LAN_RST#: R25.1 R201.1 U20.4 U21.36
PLTRST_GPU#: RC180.1 UV14.2
PLTRST_LAN#: R201.2 RC91.1 U20.2
PLTRST_MMI#: R443.1 RC90.1
PLTRST_VMM2320#: RC92.1 U6.A13
PM_APWROK: RC144.1 U38.A9 UC7.2
PM_APWROK_R: RC144.2 UC1.AB5 UC7.4
PM_LANPHY_ENABLE: R180.1 RC197.1 UC1.AM7
POA_WAKE#: RP17.3 U38.B68
POWER_SW#_MB: C340.1 D27.2 JPWR1.10 R329.2 SW5.1 SW6.1
POWER_SW_IN#: C343.1 R327.2 R329.1 U38.B67
PROC_OPI_RCOMP: RC237.1 UC1.AY15
PROCHOT#_EC: Q9.2 R334.1 R335.2 R342.2 U38.A46
PROCHOT_GATE: PU405.2 R283.2 U37.A50
PS2_CLK_TS: JKB1.9 JTP1.2
PS2_DAT_TS: JKB1.8 JTP1.3
PS_ID: PU1.4 U38.A55
PSID_DISABLE#: PR13.2 U37.A37
PWM1: PU300.6 PU301.8
PWR_DET#: JPWR1.5 R479.1 U37.B4
PWR_SRC_ON: C438.2 Q124.3 R2576.2 R2578.1
QSA0: UV1.E19 UV4.F3
QSA1: UV1.C15 UV5.F3
QSA2: UV1.B16 UV5.C7
QSA3: UV1.B22 UV4.C7
QSA4: UV1.R25 UV6.F3
QSA5: UV1.W23 UV7.C7
QSA6: UV1.AB26 UV7.F3
QSA7: UV1.T26 UV6.C7
QSA#0: UV1.F19 UV4.G3
QSA#1: UV1.C14 UV5.G3
QSA#2: UV1.A16 UV5.B7
QSA#3: UV1.A22 UV4.B7
QSA#4: UV1.P25 UV6.G3
QSA#5: UV1.W22 UV7.B7
QSA#6: UV1.AB27 UV7.G3
QSA#7: UV1.T27 UV6.B7
RED_CRT: JIO1.34 U39.27
RED_DOCK: L70.1 U39.26
RED_DOCK_PI: JDOCK1.53 L70.2
REF_+1.05V_MP: PC156.2 PU150.26
REGCTL_PNP10: L26.1 U21.7
REM_DIODE1_N: C358.1 C370.1 Q11.3 U38.B13
REM_DIODE1_P: C358.2 C370.2 Q11.1 Q11.2 U38.A13
REM_DIODE2_N: C359.1 C372.2 Q13.3 U38.B14
REM_DIODE2_P: C359.2 C372.1 Q13.1 Q13.2 U38.A14
REM_DIODE3_N: C382.1 C383.2 Q15.3 U38.A15
REM_DIODE3_P: C382.2 C383.1 Q15.1 Q15.2 U38.B16
REM_DIODE4_N: C361.1 C373.1 Q14.3 U38.A16
REM_DIODE4_P: C361.2 C373.2 Q14.1 Q14.2 U38.B17
RES_BIAS: R185.1 U21.12
RESET_OUT#: R373.2 RC84.1 RC88.1 RC263.2 U38.B39
REXTB: R2644.1 U83.7
RF_+VDDRP: PR705.1 PU700.5
RING2: D2.2 JIO1.75 JIO1.77 R187.1 U17.28
ROM_SCLK: RV89.2 UV1.C12
ROM_SI: RV90.2 UV1.B12
ROM_SO: RV92.2 UV1.A12
RSMRST#: R440.2 U41.3 U42.2
RTD2136_SCL: R2590.1 R2592.2 U52.48
RTD2136_SDA: R2591.1 R2593.2 U52.47
RUN_ON: PR206.1 Q5.2 R154.1 R303.2 R418.1 R426.1 U37.A11
RUN_ON#: Q5.5 Q5.6 R36.2
RUNPWROK: Q5.3 R35.2 U37.A4 U38.B26 UC6.1 UC6.4 UC6.10 UC6.13
S5_1.35V: PC115.1 PR107.2 PR108.2 PU100.8
SATA_ACT#: Q24.4 UC1.U3
SATA_COMP: RC19.1 UC1.C12
SATA_IREF: RC14.2 UC1.A12
SATA_ODD_PRX_DTX_N2: CS3.2 JSATA2.5
SATA_ODD_PRX_DTX_N2_C: CS3.1 UC1.J6
SATA_ODD_PRX_DTX_P2: CS4.2 JSATA2.6
SATA_ODD_PRX_DTX_P2_C: CS4.1 UC1.H6
SATA_ODD_PTX_DRX_N2: CS2.2 JSATA2.3
SATA_ODD_PTX_DRX_N2_C: CS2.1 UC1.B14
SATA_ODD_PTX_DRX_P2: CS1.2 JSATA2.2
SATA_ODD_PTX_DRX_P2_C: CS1.1 UC1.C15
SATA_PRX_DKTX_N0: C313.2 JDOCK1.56
SATA_PRX_DKTX_N0_C: C313.1 UC1.J5
SATA_PRX_DKTX_P0: C312.2 JDOCK1.54
SATA_PRX_DKTX_P0_C: C312.1 UC1.H5
SATA_PRX_DTX_N1: C109.1 JSATA1.5
SATA_PRX_DTX_N1_C: C109.2 UC1.J8
SATA_PRX_DTX_P1: C108.1 JSATA1.6
SATA_PRX_DTX_P1_C: C108.2 UC1.H8
SATA_PRX_MSATATX_N3: JMINI2.25 R67.1 R2663.1
SATA_PRX_MSATATX_N3_M: R67.2 U91.15
SATA_PRX_MSATATX_P3: JMINI2.23 R68.1 R2662.1
SATA_PRX_MSATATX_P3_M: R68.2 U91.16
SATA_PTX_DKRX_N0: C315.1 JDOCK1.62
SATA_PTX_DKRX_N0_C: C315.2 UC1.B15
SATA_PTX_DKRX_P0: C314.1 JDOCK1.60
SATA_PTX_DKRX_P0_C: C314.2 UC1.A15
SATA_PTX_DRX_N1: C106.1 JSATA1.3
SATA_PTX_DRX_N1_C: C106.2 UC1.A17
SATA_PTX_DRX_P1: C105.1 JSATA1.2
SATA_PTX_DRX_P1_C: C105.2 UC1.B17
SATA_PTX_MSATARX_N3: C280.1 R62.1 R2664.1
SATA_PTX_MSATARX_N3_C: C280.2 JMINI2.31
SATA_PTX_MSATARX_N3_M: R62.2 U91.17
SATA_PTX_MSATARX_P3: C256.1 R61.1 R2665.1
SATA_PTX_MSATARX_P3_C: C256.2 JMINI2.33
SATA_PTX_MSATARX_P3_M: R61.2 U91.18
SC48M_CLK_EN: JEXP1.39 UC1.T3
SD/MMCCD#: C273.1 JSD1.18 R53.1 U27.21
SD/MMCCLK: C255.1 JSD1.5 R230.2
SD/MMCCLK_R: R230.1 U27.43
SD/MMCCMD: JSD1.2 U27.45
SD/MMCDAT2: R341.1 U27.48
SD/MMCDAT2_R: JSD1.9 R341.2
SD/MMCDAT3: R410.1 U27.47
SD/MMCDAT3_R: JSD1.1 R410.2
SD_RCLK+: L46.4 R231.1 U27.30 U27.38
SD_RCLK+_D: JSD1.7 L46.3 R231.2
SD_RCLK-: L46.1 R297.1 U27.29 U27.37
SD_RCLK-_D: JSD1.8 L46.2 R297.2
SD_UHS2_D0N: L47.1 R315.1 U27.34
SD_UHS2_D0N_D: JSD1.12 L47.2 R315.2
SD_UHS2_D0P: L47.4 R306.1 U27.35
SD_UHS2_D0P_D: JSD1.11 L47.3 R306.2
SD_UHS2_D1N: L48.4 R337.1 U27.33
SD_UHS2_D1N_D: JSD1.15 L48.3 R337.2
SD_UHS2_D1P: L48.1 R333.1 U27.32
SD_UHS2_D1P_D: JSD1.16 L48.2 R333.2
SDWP: JSD1.19 U27.20
SIO_EXT_SCI#: RC199.1 U38.A33 UC1.N5
SIO_EXT_SMI#: RP12.7 U38.A6 UC1.AG5
SIO_EXT_WAKE#: R316.1 RP13.2 UC1.AU2
SIO_PWRBTN#: JAPS1.11 RC107.1 U38.B58 UC1.AL7
SIO_RCIN#: RP11.8 U38.A27 UC1.V4
SIO_SLP_A#: JAPS1.6 PR153.1 R423.1 U37.B63 UC1.AL5 UC7.1
SIO_SLP_LAN#: U22.4 U37.A5 UC1.AJ7
SIO_SLP_S0#: JAPS1.15 PR157.2 U38.A36 UC1.AF3
SIO_SLP_S3#: JAPS1.2 PR111.1 R417.1 R425.1 R734.2 U37.B65 UC1.AT4
SIO_SLP_S4#: JAPS1.5 PR107.1 PR203.1 R421.1 U37.A61 UC1.AJ6
SIO_SLP_S5#: JAPS1.4 U38.A18 UC1.AP5
SIO_SLP_SUS#: U37.B6 UC1.AP4
SIO_SLP_WLAN#: R318.1 UC1.AM5
SKIP#: PR315.1 PU300.7
SKIP#1: PR314.2 PR315.2 PU301.1
SL_BAT_PRES#: PR549.1 PU701.21
SLATE_MODE_R: RP12.6 UC1.AL4
SLEEVE: D2.3 JIO1.69 JIO1.71 Q123.3 R197.1 U17.29
SLEWA: PR300.2 PR310.1 PU300.15
SLICE_BAT_ON: PQ506.5 PQ508.2 PR543.2 PU500.2 PU505.1 R307.2 U37.A31
SLICE_BAT_PRES#: JDOCK1.141 JDOCK1.143 PC4.1 PD514.1 PQ1.2 PQ503.5 PR549.2 PR562.2 PR566.1 PU500.1 PU503.1 PU506.1 R285.2 U37.B33
SLICE_PERF_EN: PQ516.2 PQ523.5 PR561.2 PR563.2 U38.B37
SLP_ME_CSW_DEV#: RC289.2 U37.B58 UC1.E2
SM_RCOMP0: RC125.1 UC1.AU60
SM_RCOMP1: RC129.1 UC1.AV60
SM_RCOMP2: RC133.1 UC1.AU61
SMART_DET#: JEXP1.33 R484.2 U37.A15
SML1_SMBCLK: RC36.1 U38.B6 UC1.AU3
SML1_SMBDATA: RC37.1 U38.A5 UC1.AH3
SNN_FBA_CMD1: UV1.C26
SNN_FBA_CMD17: UV1.M23
SNN_FBA_CMD31: UV1.J26
SNN_FBA_WCK01: UV1.D18
SNN_FBA_WCK01#: UV1.C18
SNN_FBA_WCK23: UV1.D17
SNN_FBA_WCK23#: UV1.D16
SNN_FBA_WCK45: UV1.T24
SNN_FBA_WCK45#: UV1.U24
SNN_FBA_WCK67: UV1.V24
SNN_FBA_WCK67#: UV1.V25
SNUB_1.5VRUN: PC207.1 PR201.2
SNUB_1.35V: PC109.2 PR103.1
SOFT_START_GC: PR20.2 PU701.2
SP_TPM_LPC_EN: R193.1 R304.2 U37.B56
SP_TPM_LPC_EN_R: R193.2 U25.28
SPI_CLK32: R20.1 R45.2 U2.6
SPI_CLK64: R7.1 R57.2 U1.6
SPI_DIN32: R15.2 U2.2
SPI_DIN64: R4.2 U1.2
SPI_DO32: R21.1 U2.5
SPI_DO64: R9.1 U1.5
SPI_PCH_CS0#_R: R3.2 U1.1
SPI_PCH_CS1#_R: R14.2 U2.1
SPI_PCH_DO2_32: R19.2 R23.1 U2.3
SPI_PCH_DO2_64: R6.2 R8.1 U1.3
SPI_PCH_DO3_32: R16.1 U2.7
SPI_PCH_DO3_64: R5.1 U1.7
SPI_WP#_SEL: R8.2 R23.2 U37.A12
SPKR: R387.2 RC222.2 UC1.V2
SRCDET: R69.1 U6.C2
SRN_B: PC425.2 PC426.1 PR426.2 PU402.13
SRP_B: PC426.2 PC427.1 PR426.3 PU402.12
SRTCRST#: CC3.2 ME1.2 RC8.2 UC1.AV6
STRAP0: RV2653.2 RV2654.1 UV1.D1
STRAP1: RV2649.2 RV2650.1 UV1.D2
STRAP2: RV2647.2 RV2648.1 UV1.E4
STRAP3: RV2651.2 RV2652.1 UV1.E3
STRAP4: RV93.2 RV94.1 UV1.D3
STRAPREF0: RV2723.1 UV1.F6
STSTART_DCBLOCK_GC: PR513.2 PU701.16
SUS_ON: PR108.1 R308.2 R422.1 U37.B60
SUS_STAT#/LPCPD#: RC74.2 UC1.AG4
SUSACK#: RC86.1 RC98.2 U37.A58
SUSACK#_R: RC82.2 RC86.2 UC1.AK2
SW1: PC60.2 PC65.1 PL53.1 PQ52.1 PQ52.2 PQ52.3 PQ54.5 PU51.18
SW2: PC61.1 PC62.1 PL52.2 PQ51.1 PQ51.2 PQ51.3 PQ53.5 PU51.8
SW_1.35V: PC104.2 PC109.1 PL100.2 PQ100.1 PQ100.2 PQ100.3 PQ101.5 PQ101.6 PQ101.7 PQ101.8 PU100.16
SW_++VDDRP: PC704.2 PC705.1 PL700.1 PQ700.1 PQ700.2 PQ700.3 PQ701.5 PU700.8
SW_+V1.05SP: PC164.2 PL150.1 PR158.1 PU150.6 PU150.7 PU150.8 PU150.9
SW_DPB_AUX: C94.2 R47.1 U6.J13
SW_DPB_AUX#: C95.2 R44.1 U6.J14
SW_DPB_AUX#_C: C95.1 U11.5
SW_DPB_AUX_C: C94.1 U11.2
SW_DPC_AUX: C98.2 R92.1 U6.B11
SW_DPC_AUX#: C99.2 R91.1 U6.A11
SW_DPC_AUX#_C: C99.1 U13.5
SW_DPC_AUX_C: C98.1 U13.2
SW_LAN_TX0+: JIO1.31 U23.38
SW_LAN_TX0-: JIO1.29 U23.37
SW_LAN_TX1+: JIO1.37 U23.34
SW_LAN_TX1-: JIO1.35 U23.33
SW_LAN_TX2+: JIO1.43 U23.29
SW_LAN_TX2-: JIO1.41 U23.28
SW_LAN_TX3+: JIO1.49 U23.25
SW_LAN_TX3-: JIO1.47 U23.24
SWCLK_REQ#: R485.2 R488.2 RP11.7 U93.4 UC1.T2
SYS_LED_MASK#: Q24.2 Q28.5 R310.2 U37.B48 U47.1
SYS_PWROK: RC87.1 RC110.1 U37.B57
SYS_PWROK_R: RC84.2 RC87.2 UC1.AG2
SYS_PWROK_XDP: CC48.1 JXDP1.47 RC102.1 RC110.2
SYS_RESET#: JAPS1.13 RC72.2 UC1.AC3 UC2.4
SYSTEM_ID: C369.1 R386.2 U38.A10
TAA_CLK32: JTAA1.9 R18.2
TAA_CLK64: JTAA1.7 R13.2
TAA_CS0#_R: JTAA1.11 R10.2
TAA_CS1#_R: JTAA1.13 R17.2
TAA_DIN32: JTAA1.19 R41.2
TAA_DIN64: JTAA1.17 R22.2
TAA_DO2_32: JTAA1.14 R59.1
TAA_DO2_64: JTAA1.12 R58.1
TAA_DO3_32: JTAA1.10 R48.1
TAA_DO3_64: JTAA1.8 R43.1
TAA_DO32: JTAA1.3 R12.2
TAA_DO64: JTAA1.1 R11.2
TDI_IREF: RC236.2 UC1.B12
TDI_XDP: JXDP1.56 RC96.2 RC103.1
TDI_XDP_R: RC103.2 RC104.1 UC6.5
TDO_XDP: JXDP1.52 RC95.2 RC123.1 RC280.2 UC6.2
TESTB: R2633.2 U83.14
THERMATRIP2#: C371.1 Q12.1 R402.2 U38.B34
THERMATRIP3#: PD601.1 QC6.6 RP17.1 U38.A2
THSEL_STRAP: R383.1 U38.B29
TMDS_CLK: C103.2 UC1.B53
TMDS_CLK#: C191.2 UC1.A53
TMDS_DDC_SCL: Q122.1 RP1.6 UC1.D9
TMDS_DDC_SCL_R: JHDMI1.15 Q122.6 R471.1
TMDS_DDC_SDA: Q122.4 RP1.5 UC1.D11
TMDS_DDC_SDA_R: JHDMI1.16 Q122.3 R470.1
TMDS_HPD: QZ22.1 R475.1 UC1.A8
TMDS_N0: C209.2 UC1.C49
TMDS_N1: C270.2 UC1.C53
TMDS_N2: C272.2 UC1.C51
TMDS_P0: C199.2 UC1.B50
TMDS_P1: C269.2 UC1.B54
TMDS_P2: C271.2 UC1.C50
TMDS_RP_CLK: C103.1 L9.1 L10.1 R464.1
TMDS_RP_CLK#: C191.1 L10.4 L11.1 R466.1
TMDS_RP_N0: C209.1 L13.4 L14.1 R463.1
TMDS_RP_N1: C270.1 L16.4 L17.1 R469.1
TMDS_RP_N2: C272.1 L19.4 L20.1 R468.1
TMDS_RP_P0: C199.1 L12.1 L13.1 R462.1
TMDS_RP_P1: C269.1 L15.1 L16.1 R467.1
TMDS_RP_P2: C271.1 L18.1 L19.1 R465.1
TMDSB_CON_CLK: JHDMI1.10 L9.2 L10.2
TMDSB_CON_CLK#: JHDMI1.12 L10.3 L11.2
TMDSB_CON_N0: JHDMI1.9 L13.3 L14.2
TMDSB_CON_N1: JHDMI1.6 L16.3 L17.2
TMDSB_CON_N2: JHDMI1.3 L19.3 L20.2
TMDSB_CON_P0: JHDMI1.7 L12.2 L13.2
TMDSB_CON_P1: JHDMI1.4 L15.2 L16.2
TMDSB_CON_P2: JHDMI1.1 L18.2 L19.2
TMS_XDP: JXDP1.58 RC101.2 UC6.9
TOUCH_PANEL_INTR#: JTS1.6 RC315.1 RC324.2 UC1.P3
TOUCH_RST_N_GYRO_INT1: RP9.7 UC1.L1
TOUCHPAD_INTR#: RC140.2 UC1.U7
TP_CLK: C380.1 D22.2 JTP1.7 L45.1
TP_DATA: C379.1 D22.3 JTP1.6 L44.1
TP_DC_TEST_B2: RC139.1 UC1.B2
TP_LAN_JTAG_TCK: R172.2 U21.35
TP_LAN_JTAG_TDI: T92.1(TP-1) U21.32
TP_LAN_JTAG_TDO: T93.1(TP-1) U21.34
TP_LAN_JTAG_TMS: R171.2 U21.33
TPM_ID0: RC284.2 UC1.E4
TPM_ID1: RC285.2 UC1.C3
TRIP_+VDDRP: PR702.2 PU700.2
TRST#_XDP: JXDP1.54 UC6.12
U2_BOOT1: PR601.1 PU600.1
U2_BOOT2: PR631.1 PU600.18
U2_LGATE1: PQ601.4 PQ602.4 PR635.1 PU600.23
U2_LGATE2: PQ604.4 PQ605.4 PU600.20
U2_PHASE1: PC612.2 PL601.1 PL601.2 PQ600.1 PQ600.2 PQ600.3 PQ601.5 PQ602.5 PR606.1 PU600.24
U2_PHASE2: PC627.2 PL602.1 PL602.2 PQ603.1 PQ603.2 PQ603.3 PQ604.5 PQ605.5 PR632.1 PU600.19
U2_UGATE1: PQ600.4 PU600.2
U2_UGATE2: PQ603.4 PU600.17
UG_3V: PQ51.4 PU51.10
UG_5V: PQ52.4 PU51.16
UG_+VDDRP: PQ700.4 PU700.9
UIM_CLK: C264.1 JMINI2.12 JSIM1.5 U28.3
UIM_DATA: C267.1 JMINI2.10 JSIM1.6 U28.4
UIM_RESET: C265.1 JMINI2.14 JSIM1.3 U28.1
UIM_VPP: C266.1 JMINI2.16 JSIM1.4 U28.6
USB3RN0: L40.1 R246.1 UC1.G20
USB3RN0_D-: D17.1 D17.10 JUSB1.5 L40.2 R246.2
USB3RN1: C2966.1 R2647.2 UC1.E18
USB3RN1_C: C2966.2 U83.23
USB3RN1_R: JIO1.16 R2651.1 R2655.1
USB3RN1_R_CL: R2647.1 R2651.2
USB3RN1_RC: R2655.2 U83.8
USB3RN4: L55.4 R274.1 UC1.F15
USB3RN4_D-: JDOCK1.84 L55.3 R274.2
USB3RP0: L40.4 R247.1 UC1.H20
USB3RP0_D+: D17.2 D17.9 JUSB1.6 L40.3 R247.2
USB3RP1: C2967.1 R2646.2 UC1.F18
USB3RP1_C: C2967.2 U83.22
USB3RP1_R: JIO1.18 R2650.1 R2654.1
USB3RP1_R_CL: R2646.1 R2650.2
USB3RP1_RC: R2654.2 U83.9
USB3RP4: L55.1 R276.1 UC1.G15
USB3RP4_D+: JDOCK1.86 L55.2 R276.2
USB3TN0: C292.2 UC1.C33
USB3TN0_C: C292.1 L41.1 R248.1
USB3TN0_D-: D17.4 D17.7 JUSB1.8 L41.2 R248.2
USB3TN1: C2968.1 R2652.1 UC1.B33
USB3TN1_C: C2968.2 U83.20
USB3TN1_RP: JIO1.22 R2649.2 R2657.2
USB3TN1_RP_C: R2657.1 U83.11
USB3TN1_RP_CL: R2649.1 R2652.2
USB3TN4: L56.4 R275.1 UC1.B31
USB3TN4_D-: JDOCK1.90 L56.3 R275.2
USB3TP0: C293.2 UC1.B34
USB3TP0_C: C293.1 L41.4 R250.1
USB3TP0_D+: D17.5 D17.6 JUSB1.9 L41.3 R250.2
USB3TP1: C2969.1 R2653.1 UC1.A33
USB3TP1_C: C2969.2 U83.19
USB3TP1_RP: JIO1.24 R2648.2 R2656.2
USB3TP1_RP_C: R2656.1 U83.12
USB3TP1_RP_CL: R2648.1 R2653.2
USB3TP4: L56.1 R277.1 UC1.A31
USB3TP4_D+: JDOCK1.92 L56.2 R277.2
USB_DB_DET#: JUDB1.20 R490.1 U37.A2
USB_DB_PWR_EN#: JUDB1.8 R291.2 U37.B44
USB_MCARD1_DET#: JMINI1.40 R459.2 U37.A59 UC1.K3
USB_MCARD2_DET#: JMINI2.40 RP5.4 U37.A18
USB_OC0#: JIO1.59 RP14.6 UC1.AL3
USB_OC1#: RP3.1 UC1.AT1 US1.5
USB_OC2#: JUDB1.9 RP14.7 UC1.AH2
USB_OC3#: JIO1.58 RP13.3 UC1.AV3
USB_PWR_SHR_EN#: JIO1.60 R391.2 U37.B10
USB_PWR_SHR_VBUS_EN#: JIO1.62 R302.2 U37.B50
USB_SIDE_EN#: R288.2 U37.A33 US1.4
USB_SIDE_EN_IOR#: JIO1.61 R295.2 U37.B11
USBP0+: JIO1.28 UC1.AM8
USBP0-: JIO1.30 UC1.AN8
USBP1+: L42.4 R249.1 UC1.AT7
USBP1-: L42.1 R251.1 UC1.AR7
USBP1_R_D+: D18.2 JUSB1.3 L42.3 R249.2
USBP1_R_D-: D18.3 JUSB1.2 L42.2 R251.2
USBP2+: U4.1 UC1.AP8
USBP2-: U4.2 UC1.AR8
USBP4+: JIO1.52 UC1.AL15
USBP4-: JIO1.54 UC1.AM15
USBP5+: L52.1 R2579.1 UC1.AN13
USBP5-: L52.4 R2580.1 UC1.AM13
USBP5_D+: JLVDS1.7 L52.2 R2579.2
USBP5_D-: JLVDS1.6 L52.3 R2580.2
USBP6+: L58.4 R2594.1 UC1.AN11
USBP6-: L58.1 R2588.1 UC1.AP11
USBP6_D+: D88.2 JTS1.3 L58.3 R2594.2
USBP6_D-: D88.3 JTS1.2 L58.2 R2588.2
USBP7+: L72.1 R2694.1 UC1.AP13
USBP7+_D: L72.2 R2694.2 U90.31
USBP7-: L72.4 R2697.1 UC1.AR13
USBP7-_D: L72.3 R2697.2 U90.30
USBRBIAS: RC159.1 UC1.AJ10 UC1.AJ11
USH_SMBCLK: QC4.6 R491.2 U38.A50
USH_SMBDAT: QC4.3 R492.2 U38.B53
USX2064_RBIAS: R2689.1 U90.35
USX_SCL: QC4.1 R2692.1 R2696.2 U90.24
USX_SDA: QC4.4 R2693.1 R2698.2 U90.22
V_SYS: PC424.1 PU402.7 R381.2
VCI_IN2#: RP17.4 U38.B63
VCP: PR402.1 PR441.1 PU403.1 PU403.2 U38.A12
VCP_1: PR404.2 PR405.1 PU403.3
VCT_LAN_R1: R175.2 U21.6
VFB: PR334.2 PU300.24
VGA_DET: R74.2 U6.M3
VGA_ID: R317.1 R320.2 U37.B59
VGA_IREF: R2705.1 U6.M5
VID_PLLVDD: UV1.N6
VIDALERT_N: PU300.32 RC244.2 RC248.2
VIDSCLK: PR331.2 PU300.31 UC1.N63
VIDSOUT: PR330.2 PU300.1 RC249.2 UC1.L63
VMM2310_BLU: R351.1 U6.M8 U39.5
VMM2310_CLK_DDC2: U6.L4 U39.10
VMM2310_DAT_DDC2: U6.M4 U39.9
VMM2310_GRN: R312.1 U6.M7 U39.2
VMM2310_HSYNC: U6.M9 U39.6
VMM2310_RED: R311.1 U6.M6 U39.1
VMM2310_VSYNC: U6.L9 U39.7
VMM_DPB_CTRLCLK: RP6.1 U6.K13 U11.12
VMM_DPB_CTRLDAT: RP6.2 U6.L14 U11.9
VMM_DPC_CTRLCLK: R49.1 U6.B12 U13.12
VMM_DPC_CTRLDAT: R46.1 U6.A12 U13.9
VMM_GPIO6: RP6.3 U6.C1
VMM_GPIO7: RP6.4 U6.M12
VMM_GPIO8: R54.1 U6.M13
VMM_GPIO09: R232.1 U6.A5
VMM_GPIO10: U6.L3
VMM_MESCL: R40.1 U6.B5
VMM_MESDA: R42.1 U6.B6
VMM_SPI_CLK: U6.B3 U7.6
VMM_SPI_CS#: R64.2 U6.A4 U7.1
VMM_SPI_DIN: U6.B4 U7.2
VMM_SPI_DO: U6.A3 U7.5
VMM_SPI_HOLD: R65.2 U7.7
VMM_SPI_WP#: U6.B1 U7.3
VOL_DOWN#: JMED1.2 R349.2 R360.2
VOL_MUTE#: JMED1.3 R352.2 R358.2
VOL_UP#: JMED1.1 R338.2 R362.2
VR_EN: RC246.2 UC1.F60
VR_HOT#: PR326.1 PU300.30
VR_READY: RC247.2 UC1.C59
VREF: PC309.1 PH300.1 PR300.1 PR302.1 PR303.1 PR304.1 PR322.2 PU300.27
VSET_5075: C367.1 R394.1 U38.A17
VSYNC_BUF: JIO1.44 U39.18
VSYNC_DOCK: JDOCK1.67 U39.17
WIGIG60GHZ_DIS#: D13.1 R224.1 R289.2 U37.A1
WIGIG60GHZ_DIS#_R: D13.2 JMINI1.32 R224.2
WIRELESS_LED#: Q22.6 Q28.4 Q30.3 Q30.6 R432.2 U37.A47
WIRELESS_ON#_OFF: JUDB1.17 R293.2 U37.B13
WLAN_LAN_DISB#: U24.4 U37.A64
WLAN_LED: JLED1.9 R435.2
WLAN_LED#: JMINI1.44 Q22.1 R227.1
WLAN_RADIO_DIS#: D12.1 R215.1 U37.A48
WLAN_RADIO_DIS#_R: D12.2 JMINI1.20 R215.2
WWAN_RADIO_DIS#: JMINI2.20 R286.2 U37.A53
WWAN_SMBCLK: JMINI2.30 R216.2 R218.1
WWAN_SMBDAT: JMINI2.32 R217.2 R219.1
XDP_DBRESET#: CC68.1 JXDP1.48 RC72.1 RC116.2 UC2.1
XDP_OBS0_R: JXDP1.21 RC121.1 RC194.2
XDP_OBS1_R: JXDP1.23 RC121.2 RC204.2
XDP_RST#_R: JXDP1.46 RC109.2
XTAL24_IN: RC40.1 RC44.2 UC1.A25
XTAL24_IN_R: CC7.1 RC40.2 YC2.3
XTAL24_OUT: CC6.1 RC44.1 UC1.B25 YC2.1
XTAL24M_IN: CC85.1 RC297.2 U90.33 Y6.3
XTAL24M_OUT: CC86.1 RC297.1 U90.32 Y6.1
XTAL_OUT: CV105.1 UV1.B10 YV2401.3
XTALI: C190.1 R206.2 U21.10 Y3.1
XTALIN: CV104.1 UV1.C11 YV2401.1
XTALO: R183.2 R206.1 U21.9
XTALO_R: C189.1 R183.1 Y3.3
Z4012: RTCD1.2 RTCR1.2
Z4304: PBATT2.7 PD2.2 PR3.1
Z4305: PBATT2.6 PD2.3 PR5.1
Z4306: PBATT2.5 PD1.2 PR4.1
N07538: PR534.1 PU701.28
N07670: PQ501.4 PR502.2 PR507.1
N07710: PQ506.2 PQ506.3 PR508.2
N07778: PQ502.5 PQ502.6 PR504.2
N07808: PC505.2 PQ510.4 PR513.1
N07946: PC509.1 PQ511.1 PQ511.2 PQ511.3 PQ524.1 PQ524.2 PQ524.3 PR517.1
N07954: PC509.2 PD507.1 PD510.1 PD513.1 PQ511.4 PQ524.4 PR517.2 PR520.1
N07974: PQ525.1 PR520.2
N07998: PQ512.1 PR518.1 PU503.2
N08002: PU503.4 PU504.1
N08014: PD506.1 PD508.1 PD512.1 PQ525.2
N08016: PD506.2 PU504.4
N08030: PQ508.1 PR506.2 PR514.2 PU502.2
N08062: PD501.1 PQ500.3 PR503.1
N08064: PQ500.2 PR501.1 PR503.2
N08074: PQ503.6 PR501.2
N08082: PQ507.5 PU500.4
N08084: PD504.1 PQ502.2 PQ507.3 PQ507.6 PR500.1
N08086: PQ507.2 PU502.4
N08128: PR519.1 PU504.2
N08144: PD508.2 PU505.4
N08150: PR551.1 PU701.19
N08170: PQ503.2 PQ503.3 PR505.2
N08182: PQ514.2 PQ516.3 PQ516.6 PR522.2 PR562.1
N08184: PQ514.1 PR521.2 PR523.2
N08204: PR523.1 PU505.2
N08214: PQ515.2 PQ515.3 PR526.1
N08226: PQ517.2 PR524.2 PR528.1
N08230: PD507.2 PQ517.1
N08260: PQ520.2 PR535.2 PR544.1
N08264: PD510.2 PQ520.1
N08280: PQ522.3 PR551.2 PR554.1
N08282: PQ522.2 PR554.2 PR555.1
N08290: PQ523.6 PR555.2
N08296: PQ523.2 PQ523.3 PR557.2
N16958676: R417.2 R418.2 U43.5
N16958821: C391.1 U43.10
N17049026: C378.1 L45.2 R405.2 R444.2 R449.2
N17049030: C377.1 L44.2 R404.2 R441.2 R450.2
N17119989: R316.2 U37.B49
N17156946: PC5.2 PQ4.4 PQ5.4 PR14.2 PR20.1 PR21.1
N17156948: PQ5.1 PQ5.2
N17205976: JDEG1.1 R388.2
N17328413: PR402.2 PR404.1 PU401.6
N17352357: CC67.2 RC83.1
N17353670: CC69.2 RC128.1
N17353833: CC70.2 RC195.1
N17404646: C339.1 R324.2
N18063845: R413.1 U42.4
N18070155: R294.1 U37.B66
N18435663: RC263.1 UC4.2
N18502042: D23.2 D24.2 Q24.1 R428.2
N18502098: Q24.6 Q26.2
N18502175: Q26.1 R438.1
N18599297: C76.2 R57.1
N18599324: C85.2 R45.1
N18632981: Q126.2 R2601.1 R2602.1
N18633605: Q125.3 R2578.2
N18640439: R556.2 U39.8
N18768391: JSATA2.9 JSATA2.10 PJP803.2
N18782591: R2583.2 U52.12
N19641658: PR408.2 PR411.1 PU401.4
N19821558: PC704.1 PR701.2
N19821564: PC706.1 PR710.1 PR711.1 PU700.7
N19821679: PC705.2 PR706.1
N19844496: PD300.1 PR317.1 PR318.1 PR319.1 PU300.3
N19844507: PC305.2 PC308.2 PR322.1 PR323.2 PU300.26
N19844524: PC310.1 PR327.2 PU300.28
N19844548: PH301.2 PR329.1
N19844564: PC307.2 PR324.1
N19844606: PC301.1 PH300.2 PR305.1 PU300.14
N19844618: PC305.1 PR323.1 PR325.1 PU300.25
N19844649: PR311.2 PU300.16
N19844680: PC306.1 PR320.1 PU300.2
N19844689: PR312.1 PR313.1 PU300.8
N19844763: PC308.1 PR325.2
N19847729: PR51.2 PR53.2 PU51.4
N19847766: PR52.1 PR55.1 PU51.2
N19847771: PR56.2 PU51.5
N19847781: PC60.1 PR61.2
N19847797: PR57.2 PU51.1
N19847834: PC61.2 PR62.1
N19847903: PC65.2 PR64.1
N19847904: PC62.2 PR63.1
N19848836: PC104.1 PR100.1
N19848854: PR110.2 PR111.2 PU100.7
N19848898: PR106.2 PU100.9
N19849916: PC165.2 PR158.2
N19850625: PC417.2 PC418.1 PL401.1 PQ404.1 PQ404.2 PQ404.3 PQ406.5 PU402.19
N19850629: PC400.2 PQ401.2 PQ402.2 PR403.2
N19850655: PC418.2 PR433.1
N19850656: PC413.2 PR421.2 PR424.2 PU402.6
N19850732: PQ401.1 PR400.3
N19850733: PQ402.1 PR400.2
N19850816: PQ410.1 PR443.2
N19850828: PR447.2 PR448.2 PR450.1 PR453.1 PU404.7
N19850842: PC434.1 PR445.2 PR447.1 PR451.1 PU404.5
N19850846: PC435.1 PR446.2 PR452.1 PU404.6
N19850858: PC431.1 PR440.2 PR443.1 PR444.1 PU404.2
N19850879: PC432.1 PR437.1 PR441.2 PU404.3
N19850885: PC439.1 PQ409.2 PR435.2 PR437.2 PU404.1
N19850895: PR423.1 PU402.17
N19850900: PR432.1 PU402.11
N19850905: PC417.1 PD401.1 PR423.2
N19850931: PR422.2 PU402.3
N19905073: PC612.1 PR601.2
N20025090: PC614.1 PR603.2 PR634.2 PU600.4
N20054548: R39.1 U17.22
N20054658: C134.1 U17.37
N20054660: C134.2 U17.35
N20089981: C385.1 U17.31
N20133265: PR618.2 PR619.1 PR620.2 PR621.1
N20137396: PC620.1 PR619.2
N20143338: PC622.1 PR622.2
N20194225: PC617.1 PR604.2 PR607.2 PR608.1
N20340292: PR610.2 PR611.1
N20539095: C412.1 Q123.2 R142.2 R153.2
N20539102: Q123.5 Q123.6 R208.2
N21005554: C409.1 U51.12
N21082240: RC32.1 U52.2
N21162283: CC84.1 R290.2
N21214262: R2701.1 U90.28
N21386608: D76.2 R110.2 U86.4
N21466889: C427.1 U51.10
N21609269: RV2909.2 UV5.L8
N21618610: RV2906.2 UV4.L8
N21623176: RV2907.2 UV7.L8
N21628194: RV2908.2 UV6.L8
N21706833: PC304.2 PR321.1
N21706836: PC304.1 PU301.7
N21711362: PL300.2 PR328.1
N21720435: PC164.1 PR155.2
N21722925: PC150.2 PU150.21
N21726938: PR157.1 PU150.2
N21828358: JLVDS1.13 LE2.2
N22048929: JMINI1.24 R228.1 R233.1
N22150023: JDEG1.9 R406.1
N22201445: PR321.2 PU301.6
N22285464: R2627.2 U83.24
N22421033: R2699.1 U90.26
N22423064: R2700.1 U90.27
N22905003: RV2720.1 UV1.D22
N22905006: RV2721.1 UV1.C24
N22905009: RV2722.1 UV1.B25
N22916336: CV103.1 CV233.1 CV234.1 CV235.1 CV3061.1 RV2404.1 UV1.G8 UV1.G9 UV1.G10 UV1.G12
N23032286: CV239.1 CV240.1 CV3062.1 CV3063.1 LV80.2 UV1.M6
N23032504: RV2442.1 UV1.C10
N23032510: RV2441.2 UV1.A10
N23034682: RV2444.2 UV1.D11
N23437023: Q20.1 R152.2
N23621118: PC628.1 PR632.2
N23621189: PC627.1 PR631.2
N23656617: PQ515.6 PR524.1
N23693397: JDIMM1.197 RD5.2
N23693399: JDIMM1.201 RD6.2
N23699971: JDIMM2.201 RD10.1
N23699973: JDIMM2.197 RD11.1
N23709542: PC615.1 PR606.2
N23724597: C163.1 U19.10
N23724615: R155.2 U19.3
N23724651: C152.1 U19.12
N23729658: QZ5.6 RZ10.2
N23729757: QZ5.3 RZ11.2
N23729780: QZ21.3 RZ40.2
N23729789: QZ21.6 RZ41.2
N23819369: PC506.1 PQ505.4 PR510.1
N24106181: PQ519.5 PR560.1 PR561.1
N24276865: QC8.6 R344.1 R345.1
N24520734: PD503.2 PR507.2
N24520740: PD503.1 PQ506.6
N24520821: PQ515.5 PR563.1 PR564.1
N24568926: PR429.2 PU402.8
N24568942: PR430.2 PU402.9
N24568999: PR59.1 PU51.19
N24602247: PQ519.6 PQ528.1 PR535.1
N24704245: PR150.2 PU150.20
N24714082: R165.2 U19.5
N24760088: PQ2.3 PR9.1
N24760090: PL3.2 PQ2.1 PR10.1
N24760094: PQ2.2 PQ3.1 PR11.2 PR13.1
N24793632: PQ411.1 PR449.2 PU405.1
N24793658: PQ409.6 PQ702.3 PR442.1
N24793714: PQ702.5 PU405.4
N24837780: PBATT2.3 PD1.3
N24847666: PD509.2 PQ518.1
N24847670: PQ518.2 PQ529.1 PR527.2
N24847672: PQ518.3 PR527.1 PR567.1 PR568.1
N24847684: PD514.2 PQ529.2 PR525.2
N24856259: PD513.2 PQ526.1
N24856273: PQ526.2 PR540.1 PR565.2
N24856289: PQ527.1 PR540.2
N24856313: PQ527.2 PU506.4
N24865866: PQ519.2 PQ519.3 PR539.1
N24866547: PQ528.2 PR566.2
N24966871: PD4.2 PQ1.1
N25442948: D80.2 U87.4
N25461188: JMINI1.16 R234.1
N25461247: JMINI1.14 R236.1
N25461262: JMINI1.8 R238.1
N25461295: JMINI1.12 R240.1
N25461301: JMINI1.10 R239.1
N25462362: JMINI1.19 R244.2
N25462371: JMINI1.17 R241.2
N26045473: C319.1 R273.2
N26045635: CE8.1 RE4.2
N26045731: CE9.1 RE5.2
N26176018: QZ22.5 R460.2
N26268990: R421.2 R422.2 U45.5
N26269092: R423.2 R424.2 U45.3
N27140797: RV2436.1 UV1.F3
N27141414: RV2704.1 UV1.F22
N27141416: RV2705.1 UV1.J22
N27747674: JSATA1.10 R52.2
N28030709: R3000.2 U4.9
N28282435: CC22.1 RC38.1 UC5.5
N28305266: D23.1 Q24.3
N28834607: R154.2 U18.3 U18.5
N29162349: QC6.2 R346.2 R347.1
N29193033: R319.2 U37.B18
N29201344: RC202.1 UC5.1
N31283223: R323.1 U37.A62
N31479955: R321.1 U37.B19
N35502990: Q19.5 Q19.6 R126.2
N48705663: PQ3.2 PR10.2 PR12.1
N51701576: R77.2 U15.11
N53734664: R381.1 U38.B61
N53866851: C363.1 R382.2
N61090377: QD1.3 R29.1 R30.1 R31.1 R33.1
N61399843: R318.2 U37.A14
N61858263: R211.1 U27.26
N62014302: C401.1 U46.12
N62015979: C402.1 U46.10
N62018216: R425.2 R426.2 U46.3 U46.5
N62020898: C398.1 U45.10
N62020976: C397.1 U45.12
N62022297: C390.1 U43.12
N62022948: R416.2 U43.3
N62071680: R349.1 U38.B57
N62078629: C148.1 U18.10
N62078782: C147.1 U18.12
N62111964: Q12.2 R403.2
N63746311: R352.1 U38.B2
N63746359: R338.1 U38.B8
N64492809: Q21.3 R157.2
N64492816: Q21.6 R156.2
N64569940: C136.1 R149.2
N64569944: C135.1 R148.2
N70882705: Q16.1 R435.1
N70882773: Q16.2 Q28.3
N74832224: R367.1 R370.1 U38.A59

Pads without a net: D27 3; FD1 1; FD2 1; FD3 1; FD4 1; JAPS1 16 17 18; JDIMM1 77 122 125 198; JDIMM2 77 122 125 198; JHDMI1 14; JIO1 3 12 17; JLED1 3 11; JMED1 5; JMINI1 3 5 6 28 30 42 48; JMINI2 3 5 6 17 19 28 37 45 46 47 48 49; JPWR1 2; JSATA1 20 21 22; JSIM1 7 8; JTAA1 5 6 15 16; JTP1 1 5; JXDP1 40 42; PQ409 3 4 5; PQ702 1 2 6; PU150 3 4 27; PU200 1 4 7; PU300 4 5; PU402 4; PU403 5 6 7; PU701 20 30 31 36; Q125 1 2 6; Q140 3 4 5; QV2806 3 4 5; SW5 2 3; SW6 2 3; U5 1; U6 K2 L2 L5 L10 L11 L12 L13 M1 M2 M10 M11; U15 2 3; U17 19 20 30; U22 6; U23 5; U25 6 7 12 13 14; U27 19 39 40 44 46; U29 6; U33 6; U34 6; U37 A22 A23 A32 A42 A44 A46 A57 A60 B1 B14 B16 B32 B45 B61 B68; U38 A4 A7 A34 A45 B5 B7 B15 B36; U52 23 24 33 34; U90 12 13 16 17 18 19 20 21; U91 2 8; UC1 A5 A35 A43 A49 A51 AA23 AA59 AB21 AB23 AC2 AC4 AC20 AC58 AC59 AD4 AD23 AD59 AD60 AE6 AE59 AE60 AF20 AG58 AL1 AL11 AL32 AM10 AM11 AN10 AP7 AP32 AT2 AU10 AU12 AU15 AU44 AU63 AV2 AV10 AV44 AV50 AV62 AV63 AW10 AW14 AW49 AY8 AY14 AY42 AY43 B35 B43 B49 B51 C46 C47 C62 C63 D1 D15 D58 E1 E3 E13 E15 F22 H18 H22 H61 H62 H63 J20 J21 J58 J61 K10 K18 K21 K59 K60 L5 L11 L59 L60 M20 M21 N23 N58 N59 N60 N61 P20 P60 P61 R20 R23 T23 T59 U10 U59 V21 V59 W23 Y5 Y20 Y22; UC4 1; UV1 A3 A4 A7 AA1 AA2 AA3 AA4 AA5 AA6 AB1 AB2 AB3 AB4 AB5 AB6 AB13 AB15 AB16 AB18 AB19 AB21 AC3 AC4 AC13 AC14 AC15 AC16 AC17 AC18 AC19 AC20 AC21 AD1 AD2 AD3 AD4 AD5 AD7 AD10 AD14 AD17 AD20 AD23 AE1 AE3 AE4 AE10 AE12 AE13 AE15 AE16 AE18 AE19 AE21 AE23 AE24 AF2 AF3 AF4 AF10 AF12 AF13 AF15 AF16 AF18 AF19 AF21 AF24 AG3 AG12 AG13 AG15 AG16 AG18 AG19 AG21 AG22 AG24 AG25 B2 B3 B6 B7 B19 C1 C2 C3 C4 C5 C6 C7 C8 C9 D4 D5 D6 D10 D12 E6 E9 E10 E12 F4 F5 F7 F9 F10 F12 G1 G2 G3 G4 G5 G6 G7 H3 H4 J1 J2 J3 J4 J5 K1 K2 K3 K4 K5 K6 L3 L4 M1 M2 M3 M4 M5 N1 N2 N3 N4 N5 P3 P4 R1 R2 R3 R4 R5 T1 T2 T3 T4 T5 T6 U3 U4 U6 V1 V2 V3 V4 V5 V6 W1 W2 W3 W4 Y3 Y4; UV4 J1 J9 L1 L9; UV5 J1 J9 L1 L9; UV6 J1 J9 L1 L9; UV7 J1 J9 L1 L9; Y6 2 4; YC2 2 4

## Via types
v1: diameter 0.305, hole 0.152, TOP to BOTTOM, 1009 vias
v2: diameter 0.457, hole 0.203, TOP to BOTTOM, 5020 vias
v3: diameter 0.508, hole 0.254, TOP to BOTTOM, 2229 vias
v4: diameter 0.508, hole 0.203, TOP to BOTTOM, 76 vias
v5: diameter 0.432, hole 0.178, TOP to BOTTOM, 316 vias
v6: diameter 0.406, hole 0.203, TOP to BOTTOM, 202 vias

## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point)
0.675V_DDR_VTT_ON: length 244.1
  TOP w0.102: R32.2 R28.2 QD1.2 230.47,31.07 U5.4 230.69,29.03 230.83,29.17 230.83,29.91 v3(230.93,30.01)
  IN1 w0.097: v3(230.93,30.01) 230.09,29.17 230.09,18.46 224.88,13.25 152.16,13.25 150.38,11.47 140.32,11.47 138.54,13.25 116.52,13.25 114.47,15.3 99.2,15.3 98.24,14.34 95.04,14.34 94.35,13.65 94.09,13.65 93.15,12.71 88.81,12.71 87.29,14.24 83.73,14.24 81.98,15.99 81.98,19.14 80.2,20.92 80.2,23.89 79.87,24.22 78.26,24.22 75.9,21.86 73.98,21.86 70.42,18.3 65.75,18.3 64.99,17.54 63.85,17.54 62.22,19.17 57.71,19.17 56.47,20.41 56.47,21.76 55.61,22.62 47.94,22.62 46.67,23.89 40.76,23.89 35.7,18.83 34.2,18.83 33.9,18.53 33.9,13.18 33.25,12.53 v3(33.25,12.5)
  BOTTOM w0.102: v1(32.65,12.34) 33.1,12.34 v3(33.25,12.5)
  BOTTOM w0.203: v3(33.25,12.5) PR110.1
1.05V_A_PWRGD: length 170.9
  TOP w0.102: U38.B28 170.5,124.64 170.39,124.75 169.89,124.75 v2(169.51,124.37)
  IN1 w0.097: v3(71.75,79.67) 71.75,82.32 76.09,86.67 76.09,98.16 77.08,99.15 77.08,103.87 77.8,104.6 77.8,116.22 82.4,120.82 v3(83.17,120.82)
  IN3 w0.102: v2(169.51,124.37) 165.67,124.37 164.38,123.08 163.89,123.08 163.56,122.74 157.6,122.74 156.56,123.79 155.34,123.79 154.32,122.77 154.32,119.49 154.03,119.2 154.03,115.13 153.68,114.78 151.93,114.78 151.72,115 147.79,115 146.96,114.16 146.96,113.71 146.29,113.05 143.91,113.05 143.74,112.89 140.43,112.89 140.03,113.29 139.65,113.29 128.34,113.29 127.56,112.51 118.81,112.51 116.46,110.16 115.96,110.16 115.54,110.58 114.6,110.58 114.51,110.49 110.72,110.49 110.23,110.97 105.97,110.97 102.44,114.51 100.62,114.51 93.16,121.98 84.34,121.98 83.18,120.81 83.18,120.82 v3(83.17,120.82)
  BOTTOM w0.102: PR156.2 82.36,72.02 82.36,73.77 81.09,75.04 77.23,75.04 v1(74.98,77.29) 72.61,79.67 v3(71.75,79.67)
  BOTTOM w0.203: PR156.2 82.69,70.57 82.69,68.63 82.54,68.47 PU150.1
1.05V_MODPHY_EN: length 6.3
  TOP w0.102: Q143.3 160.28,108.1 C207.1 R109.2 158.93,107.77 158.93,107.26 159.02,107.17 v1(159.22,107.17) 159.88,107.17 160.09,107.38 160.7,107.38 160.86,107.21 Q142.3
1.5V_PWRGD: length 135.1
  IN1 w0.097: v3(27.6,55.92) 31.51,55.92 32.53,54.9 32.53,52.87 31.79,52.13 31.79,44.08 30.57,42.86 30.57,36.97 31.94,35.6 31.94,32.39 31.95,32.39 32.17,32.17 32.17,31.86 31.95,31.64 31.94,31.64 31.94,30.2 33.47,28.68 35.69,28.68 37.43,26.94 v3(37.43,26.93)
  IN2 w0.102: v3(27.6,55.92) 25.26,55.92 25.04,56.15 25.04,58.58 36.21,69.76 45.28,69.76 49.27,73.75 49.27,82.1 51.27,84.11 56.97,84.11 57.58,83.5 v2(57.6,83.5)
  BOTTOM w0.102: v2(57.6,83.5) v1(59.46,83.5) 63.6,83.5 65.28,81.83 72.89,81.83 78.73,75.98 85.04,75.98 86.2,77.14 86.2,78.67 86.5,78.97 86.5,80.57 87.37,81.44 90.26,81.44 R165.1
  BOTTOM w0.254: v3(37.43,26.93) PR709.2 37.2,27.8 36.01,27.8 35.83,27.98 PU700.1
1.5VRUN_FB:
  vias: v1(235.27,89.36)
1.5VRUN_LX:
  vias: v1(228.63,89.39)
1.5VRUN_VIN:
  vias: v6(232.86,83.81)
1.35V_B+: length 15.7
  IN2 w0.254: v2(45.25,20.43) 43.77,18.95 38.15,18.95 35.12,15.91 v3(33.14,15.91)
  BOTTOM w0.102: 47.64,21.74 47.64,22.2 v1(47.92,22.49)
  BOTTOM w0.508: v3(33.14,15.91) 33.28,16.06 PR106.1
1.35V_FB: length 10.3
  TOP w0.254: v3(34.64,10.61) 34.64,10.96 35.68,12 v1(36.68,12) 37.05,12 37.66,11.39 v3(37.66,11.31)
  BOTTOM w0.203: PU100.6 36.92,12.95 36.33,12.95 36.13,12.76 36.13,11.77 35.55,11.19 PR109.1
  BOTTOM w0.254: PR105.1 PC113.1 38.22,10.66 38.22,10.93 37.84,11.31 v3(37.66,11.31) ; v3(34.64,10.61) PR109.1
1.35V_SUS_PWRGD: length 328
  TOP w0.102: v2(166.27,119.7) 166.19,119.62 U38.B9 ; v2(32.45,17.69) v1(31.6,17.69)
  IN1 w0.097: v3(171.75,105.03) 170.46,105.03 170.46,105.04 170.31,105.19 168.4,105.19 168.39,105.2 161.69,105.2 161.69,105.21 161.15,105.21 160.78,104.83 154.34,104.83 151.67,107.5 151.37,107.5 150.2,108.68 142.88,108.68 142.07,107.86 125.92,107.86 123.56,110.22 119.08,110.22 116.02,107.16 116.02,106.59 114.96,105.54 108.77,105.54 106.06,108.24 106.06,118.77 102.14,122.69 82.19,122.69 80.16,120.67 74.08,120.67 71.91,122.83 37.62,122.83 33.06,118.27 26.2,118.27 21.33,113.4 21.33,111.95 20.23,110.86 20.23,108.44 19.4,107.61 18.56,107.61 17.67,106.72 17.67,101.48 13.58,97.4 13.58,89.7 14.54,88.73 14.54,86.47 15.23,85.79 15.23,58.86 8.53,52.16 8.53,18.2 10.52,16.2 28.96,16.2 30.45,17.69 v2(32.45,17.69)
  BOTTOM w0.102: v2(166.27,119.7) 166.27,119.13 167,118.4 167,115.33 168.67,113.65 168.67,112.76 171.75,109.69 v3(171.75,105.03) ; v2(32.45,17.69) 32.71,17.44 34.36,17.44 34.8,16.99 PR104.2
  BOTTOM w0.203: PR104.2 35.16,16.58 36.07,16.58 36.4,16.25 36.4,15.39 36.13,15.12 36.13,14.77 36.35,14.56 PU100.10
3.3V_CAM_EN#: length 203
  IN2 w0.102: v3(101.15,127.13) 101.2,127.08 107.69,127.08 111.73,131.12 121.13,131.12 121.47,130.78 125.6,130.78 128.04,128.33 128.04,126.96 129.09,125.92 129.7,125.92 133.05,129.27 147.16,129.27 151.32,125.11 151.32,118.45 154.09,115.68 154.09,114.21 154.71,113.59 157.11,113.59 158.26,114.74 165.07,114.74 166.51,113.3 166.51,113.03 167.71,111.84 167.71,110.96 168.72,109.94 171.59,109.94 175.85,105.69 178.1,105.69 178.95,104.84 178.95,102.97 182.42,99.5 182.42,98.51 182.76,98.17 182.76,90.43 185.27,87.92 188.33,87.92 188.89,87.36 188.89,86.07 189.32,85.64 189.32,77.02 188.49,76.19 187.18,76.19 186.67,76.69 186.67,76.91 186.22,77.35 185.94,77.35 185.66,77.08 185.66,75.98 185.11,75.42 v2(184.27,75.42) 183.17,75.42 179.67,71.92 175.94,71.92 174.54,70.52 174.3,70.52 171.43,67.65 170.83,67.65 v2(169.82,66.64)
  BOTTOM w0.076: v2(169.82,66.64) 169.74,66.71 169.74,66.71 169.09,67.36 168.33,67.36 168.26,67.3 167.95,67.3 167.8,67.15 166.98,67.15 166.98,67.16 166.47,67.16 UC1.AM4
  BOTTOM w0.102: R2602.2 87.04,153.49 86.78,153.24 86.78,150 87.63,149.15 87.63,146.82 88.97,145.49 88.97,139.81 92.22,136.56 92.22,128.18 v1(93.28,127.11) 94.25,126.15 100.17,126.15 v3(101.15,127.13) ; RC198.1 184.19,75.35 v2(184.27,75.42)
3.3V_HDD_EN: length 83.4
  TOP w0.102: v3(181.1,81.95) 181.39,81.66 182.57,81.66 182.72,81.81 RP10.5 ; v3(221.86,116.52) v1(221.86,117.11) 221.32,117.64 U34.4
  IN2 w0.102: v3(173.75,78.7) 174.67,78.7 175.76,79.79 178.27,79.79 180.43,81.95 v3(181.1,81.95)
  IN3 w0.102: v3(221.86,116.52) 219.54,114.21 215.61,114.21 209.11,107.71 209.11,106.65 207.11,104.65 204.6,104.65 201.87,101.92 201.87,98.69 196.84,93.66 188.3,93.66 188.25,93.61 187.62,93.61 186.76,92.75 183.78,92.75 181.58,90.54 181.58,85.62 182.19,85.01 182.19,83.81 181.1,82.72 v3(181.1,81.95)
  BOTTOM w0.076: UC1.K2 167.92,79.26 168.21,79.26 168.39,79.44 169.02,79.44 169.84,80.26 170.45,80.26 170.78,79.93
  BOTTOM w0.102: 170.78,79.93 171.01,79.71 171.55,79.71 172.05,79.21 173.24,79.21 v3(173.75,78.7)
3.3V_TS_EN: length 169.3
  TOP w0.102: v2(172.15,95.36) 173.19,95.36 173.32,95.49 173.32,96.18 RC282.2
  IN1 w0.097: v3(84.83,159.23) 94,150.06 94,143.34 98.49,138.85 98.49,133.45 107.83,124.11 114.61,124.11 117.02,121.7 124.48,121.7 125.5,120.68 126.49,120.68 127.86,119.31 142.81,119.31 148.11,114.01 v3(148.29,114.01)
  IN2 w0.076: 166.12,78.67 165.68,78.22 164.98,78.22 v2(164.47,77.72)
  IN2 w0.102: v2(172.15,95.36) 172.15,94.65 171.62,94.12 171.62,90.69 169.35,88.43 169.35,81.58 166.74,78.97 166.42,78.97 166.12,78.67
  BOTTOM w0.089: v2(164.47,77.72) 164.2,77.45 UC1.N7
  BOTTOM w0.102: v2(172.15,95.36) 171.8,95.72 171.8,96.11 171.8,96.11 171.8,96.26 171.8,96.27 169.22,98.84 167.11,98.84 166.93,99.02 163.95,99.02 163.62,99.35 162.13,99.35 157.08,104.41 152.82,104.41 152.54,104.13 147.13,104.13 146.87,104.39 146.87,106.07 150.03,109.23 150.03,110.06 150.03,111.45 150.03,113.3 149.32,114.01 v3(148.29,114.01) ; Q140.2 95.27,162.17 v1(94.44,161.34) 94.44,161.14 94,160.69 92.65,160.69 92,161.35 90.9,161.35 90.11,162.14 87.49,162.14 84.83,159.47 v3(84.83,159.23)
3.3V_TS_EN#: length 39.8
  IN2 w0.254: v2(85.3,144.09) 86.36,144.09 88.95,146.68 88.95,147.75 90.73,149.52 90.73,155.37 91.2,155.84 91.2,160.29 92.37,161.45 92.37,164.27 93.4,165.3 v2(94.45,165.3)
  BOTTOM w0.254: v2(85.3,144.09) 85.3,143.83 86.93,142.19 Q138.2 ; Q140.6 95.92,165.55 95.1,166.37 v1(94.61,166.37) 94.45,166.22 v2(94.45,165.3) 94.24,165.09 R2605.1 92.62,165.09 Q137.2
3.3VS_GFX_ON#: length 86
  TOP w0.254: QZ5.5 QZ5.2 27.8,117.51 v3(27.32,117.03) 26.08,115.78 26.08,111.01 23.36,108.29 23.36,86.3 27.93,81.72 v1(29.49,81.72) 48.15,81.72 50.71,79.16 55.13,79.16 61.26,85.28 61.59,85.28 61.74,85.43 61.74,86.09 61.38,86.45 61.28,86.45 QZ21.5 60.84,86.63 60.31,87.16 59.85,87.16 59.32,86.63 QZ21.2
  BOTTOM w0.254: RV2805.2 26.49,117.67 26.57,117.75 QV2806.6 26.95,117.4 v3(27.32,117.03)
+0.9V_LAN: length 20.1
  TOP w0.203: U21.22 202.97,150.47 203.29,150.79 204.13,150.79 C186.1 ; C185.1 203.96,148.15 203.72,147.92 203.24,147.92 203.09,148.07 U21.16
  TOP w0.254: v2(199.83,145.17) 199.71,145.29 U21.8 ; C183.1 195.21,151.27 U21.37 ; v2(195.2,150.07) U21.40 ; v2(195.13,148.79) 195.21,148.87 U21.43 ; U21.11 200.91,145.49 201.1,145.3 v2(201.1,145.11)
  TOP w0.508: v2(204.74,150) 204.74,150.05 204.23,150.56 C186.1 ; v2(204.61,147.43) 204.49,147.43 204.2,147.72 C185.1 ; v2(202.28,144.51) 202.28,144.39 202.49,144.17 C184.1 ; C183.1 193.99,152.79 v2(194.31,153.11)
  IN1 w0.508: v3(197.78,141.62) 197.89,141.73 198.92,141.73 199.83,142.64 v2(199.83,145.17)
  vias: v2(194.31,147.2) v6(193.54,147.17)
+0.675V_DDR_VTT: length 201.5
  IN2 w1.524: 70.83,29.55 70.83,30.77 71.39,31.33 87.7,31.33 88.1,30.92 107.04,30.92 111.67,26.29 147.63,26.29 148.56,25.36 148.56,23.78
  IN2 w2.032: 224.37,18.23 200.76,18.23 200.72,18.19 158.11,18.19 157.32,18.98 153.07,18.98
  IN3 w1.524: 71.11,25.21 71.11,11.76 69.27,9.92 49.5,9.92 48.76,10.65 47.06,10.65
  BOTTOM w0.356: v2(151.9,23.77) 151.9,24.35 150.98,25.28 JDIMM1.203 ; v2(225.65,24.63) 225.48,24.8 JDIMM2.203 ; JDIMM2.204 225.78,19.3 225.58,19.49 v2(225.58,19.68)
  BOTTOM w0.381: JDIMM1.204 151.28,19.65 v2(151.45,19.82)
  vias: v2(46.94,12.48) v2(46.93,11.85) v2(46.9,11.16) v2(152.04,19.82) v2(226.19,19.68) v3(71.16,27.44) v3(71.16,26.78) v3(71.16,26.1) v6(225.77,22.26)
+0.675V_P: length 5.9
  BOTTOM w0.102: 45.94,12.18 45.94,12.81 46.63,13.5 v1(46.9,13.5)
  BOTTOM w0.203: PC105.1 41.9,11.58 41.79,11.47 40.38,11.47 40.3,11.55 39.46,11.55 39.46,11.54 39.42,11.51 39.01,11.51 38.81,11.7 PU100.2
+1.2V_LDO: length 7
  BOTTOM w0.203: 21.08,22.46 21.08,22.65 21.39,22.96 U27.10
  BOTTOM w0.254: U27.41 26.44,27.2 26.51,27.27 26.97,27.27 27.42,27.72 C217.2 ; 21.08,22.46 20.7,22.08 20.7,21.75 C218.2 20.51,21.57 20.19,21.89 v2(20.19,22.27)
  BOTTOM w0.508: v2(29.4,27.92) C223.2 28.5,27.72 C217.2
  vias: v1(31.27,21.12) v2(30.75,21.5) v3(30.75,20.75)
+1.2V_LDO_AIN: length 12.9
  BOTTOM w0.203: U27.31 22.99,30.43 23.25,30.69 23.25,30.96 23.31,31.02 23.31,31.9 C233.2 ; U27.28 21.79,30.19 21.5,30.48 21.5,31.05 21.78,31.33 22.02,31.33 22.22,31.53 C232.2 ; U27.36 24.99,29.97 25.19,30.16 25.84,30.16
  BOTTOM w0.508: v2(24.26,32.3) 24.05,32.1 C233.2 C232.2 ; v3(28.77,30.57) C234.2 27.98,29.76 27.91,29.83 26.48,29.83 26.15,30.16 25.84,30.16
  vias: v1(30.34,23.58) v3(26.94,23.02) v3(26.94,22.26)
+1.05V_GPU: length 71.3
  TOP w0.508: v3(28.31,115.68) 28.36,115.73 RZ11.1 ; LV80.1 70.96,101.53 v3(70.96,100.08) ; LV74.2 v3(53.84,82.49) ; LV76.2 v3(55.14,83.1)
  IN2 w0.508: v2(49.61,89.3) 49.61,88.49 42.08,80.96 25.9,80.96 24.53,82.33 24.53,87.63 22.06,90.09 22.06,95.15 22.9,95.99 22.9,108.16 23.49,108.75 23.49,111.54 27.63,115.68 v3(28.31,115.68)
  vias: v2(50.75,91.14) v2(54.05,93.68) v2(54.87,92.72) v2(55.7,93.55) v2(61.46,91.15) v2(91.33,76.06) v2(91.38,75.42) v2(91.96,76.06) v2(91.96,75.42) v2(92.6,76.07) v2(92.6,75.45) v2(93.21,76.04) v2(93.21,75.42) v3(48.78,85.61) v3(48.78,84.97) v3(49.42,85.61) v3(49.42,84.97) v3(54.68,82.38) v3(56.89,87.9) v3(57.5,87.9) v3(58.13,87.87) v3(58.97,87.9) v3(62.35,94.37) v5(52.32,91.98) v5(54.05,94.44) v5(56.46,94.63) v5(57.61,94.91) v5(58.59,94.91) v5(59.83,95.06) v5(61.28,94.87) v5(61.95,94.95) v6(47.34,87.19)
+1.5V_GPU: length 69.7
  TOP w0.254: UV7.D9 v2(37.93,88.55) UV7.C9 ; v2(28.36,87.74) 28.73,88.12 UV7.R9 ; v2(36.33,103.39) 36.72,103.78 UV5.E9 ; v3(34.74,90.11) 34.78,90.11 UV7.G7 ; v2(36.36,110.76) 36.38,110.76 36.31,110.69 UV5.F1 ; UV5.C9 v2(37.92,104.3) UV5.D9 ; UV5.A1 40.03,110.3 v2(40.33,110) ; v2(37.09,87.71) 36.73,88.07 UV7.E9 ; v2(33.13,94.15) UV7.K2 ; v2(33.09,88.53) 32.73,88.89 UV7.K8 ; UV7.D2 v2(37.13,94.15) ; v2(29.96,94.14) 30.33,94.52 UV7.N1 ; v2(33.16,105.12) 32.74,104.7 UV5.K8 ; UV5.C1 38.32,110.71 v2(38.49,110.88) ; v2(33.12,109.9) UV5.K2 ; v2(29.17,103.52) 29.1,103.52 UV5.R9 ; UV7.A8 v2(40.33,88.55) ; UV7.R1 28.75,94.55 v2(29.14,94.16) ; UV5.R1 28.74,110.3 v2(29.13,109.91) ; UV5.N1 30.32,110.27 v2(29.94,109.89) ; UV5.D2 v2(37.12,109.9) ; v2(34.72,109.1) UV5.H2 ; v2(34.73,93.35) UV7.H2 ; UV5.A8 v2(40.32,104.3) ; UV5.G7 34.98,105.5 34.72,105.75 v3(34.72,105.86) ; UV5.N9 30.35,103.87 30.39,103.87 v2(30.79,103.47) ; v2(39.57,109.91) 39.16,109.5 UV5.B2 ; v2(29.96,87.74) 30.33,88.12 UV7.N9 ; UV5.H9 34.32,103.94 v2(33.92,104.34)
  TOP w0.305: UV7.H9 34.24,88.05 34.24,87.52 34.49,87.26 35.08,87.26 v2(35.33,87.51)
  TOP w0.508: CV100.1 54.42,97.37 v5(54.87,96.91) ; v3(24.3,93.66) 24.3,93.79 25.2,94.69 CV2921.1 ; v2(30.24,85.87) CV2967.1 ; v2(36.9,114.95) 36.72,114.76 36.72,114.71 36.47,114.46 CV2927.1 CV2935.1 ; RV2713.1 v3(32.09,82.66) ; v2(36.33,103.39) 36.33,102.9 35.4,101.97 CV2926.1
  BOTTOM w0.21: 50.31,104.78 49.01,104.78
  BOTTOM w0.215: UV1.H26 50.31,104.78 ; 49.01,104.78 v5(48.99,104.8)
  BOTTOM w0.25: UV1.E26 50.2,107.42 49.02,107.42 v5(48.9,107.3) ; v5(48.81,102.32) UV1.L26
  BOTTOM w0.254: v2(29.96,88.54) 30.33,88.17 UV7.N9 ; UV7.K2 v2(33.13,94.15) 33.13,94.72 33.36,94.95 33.74,94.95 34.03,94.66 34.23,94.66 UV6.H9 ; v2(29.17,103.52) 29.1,103.52 UV5.R9 ; UV5.N1 30.32,110.27 v2(29.94,109.89) ; UV4.F1 35.92,103.81 v2(36.33,103.39) ; UV4.H9 34.22,110.41 34.02,110.41 33.72,110.7 33.35,110.7 33.12,110.47 v2(33.12,109.9) UV5.K2 ; v2(34.73,93.35) UV6.G7 ; UV4.A1 v2(39.52,104.3) UV4.B2 ; UV6.E9 v2(37.13,94.15) UV6.D9 ; v2(38.47,95.04) 38.33,94.9 UV7.C1 ; v2(38.49,110.88) 38.32,110.71 UV5.C1 ; v2(33.88,89.34) 34.27,88.95 UV6.H2 ; UV5.C9 v2(37.92,104.3) UV4.D2 ; v2(29.96,94.14) 30.33,94.52 UV7.N1 ; UV6.B2 v2(39.53,88.55) UV6.A1 ; UV5.R1 29.11,109.91 v2(29.13,109.91) ; UV7.R9 28.73,88.12 v2(28.36,87.74) ; v2(33.09,88.53) 32.73,88.89 UV7.K8 ; v2(30.79,103.47) 30.36,103.9 UV5.N9 ; UV4.H2 34.27,104.7 v2(33.92,104.34) ; v2(40.33,110) 40.33,109.91 UV4.A8 ; v2(34.72,109.1) UV4.G7 ; UV7.R1 29.12,94.16 v2(29.14,94.16) ; v2(35.33,87.51) 35.33,87.51 35.93,88.11 UV6.F1 ; UV7.C9 v2(37.93,88.55) UV6.D2 ; v2(40.39,94.21) 40.39,94.2 UV6.A8 ; UV5.K8 32.74,104.7 v2(33.16,105.12) ; UV4.D9 v2(37.12,109.9) UV4.E9
  BOTTOM w0.3: UV1.C25 UV1.B26 v5(49.93,110.14) ; UV1.H24 52.33,104.4 v5(52.33,104.38) ; UV1.L24 51.52,101.91 v5(51.52,101.91) ; v5(52.35,107.72) UV1.E23
  BOTTOM w0.508: v2(36.9,114.95) 36.98,114.87 CV2940.1 ; v2(39.51,114.89) CV2919.1 ; CV2928.1 CV2956.1 37.21,85.84 v2(37.24,85.87) ; v2(39.44,85.9) CV2920.1 ; v2(30.24,85.87) 30.29,85.82 CV2955.1 ; v2(30.29,83.64) CV2951.1 ; v2(35.89,85.93) 35.89,85.68 35.58,85.37 CV2957.1 CV2953.1
  vias: v2(26.75,112.22) v2(27.57,85.87) v2(28.2,85.87) v2(28.71,114.76) v2(29.35,114.76) v2(29.99,98.53) v2(36.33,94.95) v2(37.16,99.2) v2(37.79,99.2) v2(37.92,62.39) v2(37.92,61.78) v2(38.56,62.39) v2(38.56,61.78) v2(39.19,62.39) v2(39.19,61.78) v2(39.53,94.15) v2(39.89,62.34) v2(39.93,61.73) v2(40.53,62.37) v2(40.55,61.76) v2(59.83,106.12) v3(39.94,115.89) v3(41.55,84.44) v3(41.67,85.76) v3(41.98,85.13) v3(42.05,86.37) v3(42.21,84.44) v3(42.33,85.76) v3(42.64,85.13) v3(42.71,86.37) v3(42.87,84.44) v3(42.99,85.76) v3(43.3,85.1) v3(43.37,86.37) v3(43.53,84.42) v3(43.65,85.74) v3(44.03,86.35) v3(43.96,85.1) v3(44.19,84.42) v3(44.31,85.74) v3(44.64,116.09) v3(44.59,85.08) v3(44.69,86.35) v3(45.08,116.62) v5(54.69,102.06) v5(54.85,106.08) v5(55.86,104.42) v6(38.19,116.95)
