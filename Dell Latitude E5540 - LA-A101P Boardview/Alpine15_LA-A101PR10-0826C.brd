# Allegro board Alpine15_LA-A101PR10-0826C.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SW_LAN_TX1+: length 156.6
  TOP w0.089: v2(194.4,173.28) 194.44,173.23 194.44,172.82 194.42,172.8 U23.34
  IN1 w0.089: v2(194.4,173.28) 194.4,174.18 195.95,175.74 200.9,175.74 201.78,174.87 203.33,174.87 204.17,174.03 210.16,174.03 213.74,177.61 220.13,177.61 225.99,183.46 232.41,183.46 240.62,175.25 258.94,175.25 260.22,173.98 265.41,173.98 266.39,173 275.23,173 275.92,173.69 326.44,173.69 327.55,172.58 v2(327.55,172.02)
  BOTTOM w0.089: v2(327.55,172.02) 327.55,172.45 327.73,172.63 328.21,172.63 328.44,172.4 328.44,171.46 329.2,170.7 331.72,170.7 v1(333,169.42) 333.41,169 334.92,169 334.97,168.95 JIO1.37
SW_LAN_TX1-: length 156.6
  TOP w0.089: v2(194.98,173.28) 194.97,173.28 194.84,173.15 194.84,172.86 194.92,172.78 U23.33
  IN1 w0.089: v2(326.96,172.02) 327.04,172.02 327.22,172.2 327.22,172.44 326.3,173.36 276.06,173.36 275.37,172.67 266.25,172.67 265.27,173.65 260.08,173.65 258.8,174.92 240.49,174.92 232.28,183.13 226.12,183.13 220.27,177.28 213.88,177.28 210.3,173.7 204.03,173.7 203.19,174.54 201.64,174.54 200.76,175.41 196.09,175.41 194.73,174.05 194.73,173.47 194.91,173.28 v2(194.98,173.28)
  BOTTOM w0.089: v2(326.96,172.02) 327.16,172.21 327.16,172.62 327.57,173.03 v1(327.89,173.03) 328.37,173.03 328.83,172.57 328.83,171.63 329.36,171.09 331.88,171.09 333.28,169.7 333.58,169.4 334.86,169.4 334.92,169.45 JIO1.35
SW_LAN_TX2+: length 149.4
  TOP w0.089: v2(196.95,173.28) 196.97,173.26 196.97,172.88 196.92,172.83 U23.29
  IN1 w0.089: v2(325.26,171.43) 325.26,171.01 325.05,170.8 324.07,170.8 322.31,172.56 277.77,172.56 276.39,171.18 266.61,171.18 265.01,172.78 259.81,172.78 259.04,173.55 258.8,173.79 237.94,173.79 237.08,172.93 227.55,172.93 224.01,176.48 223.86,176.48 214.21,176.48 210.63,172.9 202.9,172.9 202.1,173.7 201.19,173.7 200.5,174.38 197.62,174.38 196.99,173.75 196.99,173.32 v2(196.95,173.28)
  BOTTOM w0.089: v2(325.26,171.43) 325.26,170.38 v1(325.74,169.91) 326.33,169.32 331.32,169.32 333.19,167.45 JIO1.43
SW_LAN_TX2-: length 149.5
  TOP w0.089: v2(197.53,173.28) 197.47,173.28 197.36,173.18 197.36,172.82 197.42,172.77 U23.28
  IN1 w0.089: v2(325.95,171.46) 325.87,171.46 325.59,171.18 325.59,170.88 325.19,170.47 323.93,170.47 322.17,172.23 277.91,172.23 276.53,170.85 266.47,170.85 264.87,172.45 259.67,172.45 258.71,173.42 258.66,173.46 238.07,173.46 237.22,172.6 227.42,172.6 223.87,176.15 223.73,176.15 223.52,176.15 223.52,176.15 214.35,176.15 210.77,172.57 202.76,172.57 201.96,173.37 201.05,173.37 200.37,174.05 197.76,174.05 197.32,173.61 197.32,173.37 197.41,173.28 v2(197.53,173.28)
  BOTTOM w0.089: v2(325.95,171.46) 325.66,171.17 325.66,170.55 326.02,170.19 326.49,169.71 v1(330.75,169.71) 331.49,169.71 333.35,167.84 334.61,167.84 334.72,167.95 JIO1.41
SW_LAN_TX3+: length 145.9
  TOP w0.089: U23.25 198.92,172.78 198.92,172.78 198.92,173.25 v2(198.92,173.25)
  IN1 w0.089: v2(321.71,170.67) 309.64,170.67 309.21,171.1 283.79,171.1 282.98,170.29 277.57,170.29 277,169.72 263.93,169.72 262.52,171.13 259.4,171.13 258.2,172.33 257.7,172.33 238.54,172.33 237.61,171.4 227.03,171.4 223.79,174.63 223.4,175.02 214.82,175.02 211.24,171.44 202.29,171.44 201.82,171.91 199.59,171.91 199.49,172 198.92,172.58 v2(198.92,173.25)
  BOTTOM w0.089: v2(321.71,170.67) 323.06,170.67 325.77,167.96 v1(328.39,167.96) 330.65,167.96 332.6,166 334.84,166 334.89,165.95 JIO1.49
SW_LAN_TX3-: length 146
  TOP w0.089: v2(199.56,173.24) 199.43,173.24 199.31,173.13 199.31,172.89 199.42,172.78 U23.24
  IN1 w0.089: v2(199.56,173.24) 199.48,173.24 199.25,173 199.25,172.71 199.72,172.24 201.96,172.24 202.43,171.77 211.1,171.77 214.68,175.35 223.54,175.35 224.02,174.87 227.16,171.73 237.47,171.73 238.41,172.66 257.56,172.66 258.33,172.66 259.53,171.46 262.65,171.46 264.06,170.05 276.86,170.05 277.43,170.62 282.85,170.62 283.65,171.43 309.34,171.43 309.78,171 321.45,171 v2(321.71,171.25)
  BOTTOM w0.089: JIO1.47 334.89,166.45 334.84,166.4 332.76,166.4 330.81,168.35 325.94,168.35 323.22,171.06 v1(322.88,171.06) 321.9,171.06 v2(321.71,171.25)
SWCLK_REQ#: length 157.4
  TOP w0.102: R485.2 110.25,116.18 110.06,115.99 v3(110.06,115.2) 110.06,114.08 110.2,113.94 U93.4 110.83,113.43 R488.2 ; v3(183.51,76.92) 183.62,77.04 183.62,77.66 183.39,77.89 RP11.7
  IN2 w0.102: v3(175.3,74.83) 175.3,74.87 177.54,77.1 177.58,77.1 178.36,77.88 179.31,77.88 179.81,78.37 181.93,78.37 182.36,77.94 182.49,77.94 v3(183.51,76.92) 183.51,78.14 183.73,78.37 188.22,78.37 188.84,78.99 188.84,85.47 188.43,85.88 188.43,87.14 188.16,87.41 185.13,87.41 182.3,90.24 182.3,97.85 178.49,101.66 178.49,104.66 177.91,105.23 175.65,105.23 171.4,109.49 168.51,109.49 166.7,111.29 165.19,111.29 163.47,113.02 161.65,113.02 161.37,113.3 157.85,113.3 157.79,113.36 154.6,113.36 153.85,114.11 153.85,115.59 150.99,118.45 150.99,125.11 147.06,129.04 133.16,129.04 129.81,125.69 128.58,125.69 v3(128.4,125.87)
  IN3 w0.102: v3(128.4,125.87) 128.4,124.28 126.39,122.27 126.39,117.78 124.5,115.89 112.5,115.89 111.76,116.62 110.75,116.62 110.06,115.94 v3(110.06,115.2)
  BOTTOM w0.076: 170.78,75.63 170.56,75.63 169.97,76.22 168.43,76.22 168.33,76.13 168.02,76.13 167.73,75.84 UC1.T2
  BOTTOM w0.102: v3(175.3,74.83) 174.93,75.2 173.3,75.2 172.96,75.54 172.21,75.54 172.14,75.47 v1(171.91,75.47) 171.76,75.47 171.61,75.63 170.78,75.63
SYS_LED_MASK#: length 154.1
  TOP w0.102: U37.B48 194.59,119.75 v2(194.54,119.8) ; v3(207.94,140.04) 207.53,140.04 207.15,140.42 207.15,142.05 207.33,142.23 208.25,142.23 208.42,142.05 Q28.5 ; v1(219.9,37.48) 220.06,37.32 221.48,37.32 221.76,37.6 Q24.2 221.76,38.37 221.48,38.65 v3(221.48,40.45) ; v2(194.52,117.37) 194.52,116.51 R310.2 ; v3(208.68,152.54) 208.19,152.54 207.68,153.06 U47.1
  IN2 w0.102: v2(194.54,119.8) 194.54,117.35 v2(194.52,117.37) 194.52,115.54 196.54,113.52 196.54,112.79 198.01,111.31 198.01,106.84 200.51,104.33 200.64,104.2 200.78,104.07 200.8,104.04 200.8,102.91 201.23,102.48 201.23,100 202.75,98.49 204.21,98.49 204.49,98.21 204.49,97.27 203.95,96.73 203.95,95.9 205.32,94.53 205.32,87.82 206.45,86.69 206.45,84.22 206.45,83.95 208.99,81.41 208.99,59.68 211.32,57.35 211.32,53.58 214.24,50.66 214.24,48.07 217.15,45.16 218.84,45.16 219.93,44.07 219.93,41.74 221.22,40.45 v3(221.48,40.45)
  IN3 w0.102: v3(208.68,152.54) 207.99,152.54 207.76,152.31 207.76,150.46 209.67,148.55 209.67,141.77 v3(207.94,140.04) 207.92,140.04 207.46,139.58 207.46,138.54 202.02,133.1 202.02,130.06 202.84,129.25 202.84,123.58 201.78,122.53 201.78,119.15 200.45,117.82 196.52,117.82 v2(194.54,119.8)
SYS_PWROK: length 337.9
  TOP w0.102: U37.B57 196.1,122.14 v2(196.02,122.07) ; v3(187.9,57.34) 187.75,57.49 187.06,57.49 187.01,57.54 186.78,57.54 RC87.1 ; RC110.1 101.59,50.79 99.91,50.79 v1(99.63,50.51) 98.67,50.51 97.48,49.31 v3(96.79,49.31)
  IN1 w0.097: v3(204.74,114.23) 203.32,112.81 203.04,112.81 200.73,110.5 200.73,109.77 200.45,109.49 200.17,109.49 198.31,107.63 198.31,107.08 195.03,103.8 195.03,98.22 196.81,96.43 196.81,88.17 198.16,86.82 198.52,86.82 198.52,86.82 198.91,86.82 198.91,86.82 199.62,86.82 200.63,85.82 200.63,80.01 201.95,78.69 201.95,75.78 204.25,73.48 204.25,70.6 204.52,70.32 204.52,65.14 205.29,64.37 205.29,62.86 204.25,61.81 204.25,61.44 203.52,60.72 197.09,60.72 193.16,56.78 188.08,56.78 187.9,56.96 v3(187.9,57.34)
  IN3 w0.102: v3(96.79,49.31) 95.65,48.17 93.87,48.17 89.96,44.26 89.96,36.69 92.09,34.56 96.16,34.56 102.84,27.88 102.84,27.09 104.87,25.06 104.87,19.42 106.98,17.31 115.23,17.31 116.32,16.22 116.96,16.22 118.99,14.18 123.79,14.18 124.35,14.74 151.56,14.74 152.37,13.93 170.64,13.93 170.85,13.73 171.58,13.73 171.76,13.91 201.07,13.91 203.1,15.94 220.18,15.94 222.57,18.33 223.48,18.33 224.7,19.55 224.7,22.09 225.42,22.8 225.42,23.58 226.03,24.2 226.03,28.55 225.39,29.19 225.39,30.97 216.79,39.57 216.31,39.57 213.65,42.22 213.65,44.3 207.55,50.4 207.08,50.4 205.94,51.54 205.94,53.6 203.95,55.59 203.95,55.92 202.38,57.49 199.1,57.49 197.27,55.66 196.54,55.66 195.14,57.06 195.12,57.06 195.11,57.06 190.6,57.06 189.91,57.75 188.31,57.75 v3(187.9,57.34)
  BOTTOM w0.102: v3(204.74,114.23) 201.25,117.73 196.66,117.73 194.96,119.43 194.96,121.5 195.14,121.68 195.63,121.68 v2(196.02,122.07)
SYS_PWROK_R: length 41.6
  TOP w0.076: v6(168.82,69.06) 169.36,69.59 v2(169.36,69.63)
  TOP w0.102: v3(185.82,60.03) 185.82,59.88 186.33,59.37 RC87.2 185.74,58.33 185.74,57.87 185.39,57.52 184.49,57.52 184.27,57.75 183.05,57.75 182.84,57.54 182.84,55.97 182.74,55.87 182.06,55.87 181.63,55.43 181.63,54.72 RC84.2
  IN3 w0.076: v2(169.36,69.63) 169.36,69.81 169.13,70.04 168.21,70.04 168.06,69.89 168.06,66.51 168.34,66.24 168.34,63.41 169.99,61.76 171.03,61.76
  IN3 w0.102: 171.03,61.76 172.54,61.76 174.19,60.11 178.83,60.11 180.31,61.58 184.93,61.58 185.82,60.69 v3(185.82,60.03)
  BOTTOM w0.076: v2(169.36,69.63) 169.05,69.94 168.91,69.94 168.79,70.07 168.3,70.07 168.26,70.12 168.03,70.12 167.75,69.84 UC1.AG2
SYS_PWROK_XDP: length 8
  TOP w0.102: JXDP1.47 96.56,48.86 96.59,48.83 v1(98.43,48.83) 98.97,48.83 99.37,48.43 CC48.1 101.14,49.4 RC102.1 RC110.2
SYS_RESET#: length 75.3
  TOP w0.102: JAPS1.13 222.72,78.59 221.38,77.25 v1(220.97,77.25) v3(220.08,77.25)
  IN1 w0.076: 169.21,74.45 168.67,74.45 168.49,74.27 168.49,73.77 169.17,73.1 169.21,73.1
  IN1 w0.097: 169.21,74.45 169.26,74.45 169.26,74.45 171.65,74.45 172.1,74.01 173.08,74.01 173.71,73.38 176.07,73.38 177.68,75 184.45,75 184.78,75.32 v3(185.59,75.32) 187.7,75.32 188.71,74.31 191.99,74.31 192.8,75.12 197.15,75.12 198.11,74.15 v3(198.52,74.15) ; 169.21,73.1 v2(169.29,73.01)
  BOTTOM w0.076: v2(169.29,73.01) 168.83,72.55 168.01,72.55 167.85,72.39 167.85,72.03 167.61,71.8 167.1,71.8 UC1.AC3
  BOTTOM w0.102: v3(220.08,77.25) 218.38,77.25 214.42,73.29 210.89,73.29 208.87,75.31 207.19,75.31 206.75,75.75 206.75,77.1 206.39,77.46 201.59,77.46 201.03,76.9 201.03,75.71 201.03,75.3 199.89,74.15 v3(198.52,74.15) ; v3(185.59,75.32) 185.84,75.58 185.84,76.26 185.54,76.56 185.54,77.28 RC72.2 185.87,77.76 UC2.4
SYSTEM_ID: length 8.4
  TOP w0.102: 166.96,117.17 166.96,116.71 167.25,116.42 167.96,116.42 168.65,115.73 168.65,113.85 168.48,113.68 C369.1 R386.2 ; 166.96,117.17 166.94,117.19 U38.A10 ; 166.96,117.17 v1(166.96,117.17)
TAA_CLK32: length 1.9
  BOTTOM w0.102: JTAA1.9 204.01,75.14 R18.2
TAA_CLK64: length 2.4
  BOTTOM w0.102: R13.2 205.5,75.17 205.37,75.31 204.86,75.31 204.51,75.65 JTAA1.7
TAA_CS0#_R: length 1.8
  BOTTOM w0.102: R10.2 203.51,74.75 JTAA1.11
TAA_CS1#_R: length 1.8
  BOTTOM w0.102: R17.2 203.01,74.71 JTAA1.13
TAA_DIN32: length 1.9
  BOTTOM w0.102: R41.2 201.51,74.99 201.51,75.11 JTAA1.19
TAA_DIN64: length 1.7
  BOTTOM w0.102: R22.2 201.95,75.03 202.01,75.09 JTAA1.17
TAA_DO2_32: length 3.3
  BOTTOM w0.102: JTAA1.14 203.01,83.44 R59.1 201.79,84.66 v6(201.79,84.85)
TAA_DO2_64: length 1.7
  BOTTOM w0.102: JTAA1.12 203.51,83.55 R58.1
TAA_DO3_32: length 2
  BOTTOM w0.102: R48.1 204.49,83.69 204.01,83.21 JTAA1.10
TAA_DO3_64: length 3.7
  BOTTOM w0.102: v6(206.98,84.25) 206.18,84.25 205.62,83.69 R43.1 204.89,82.96 204.89,82.96 204.51,82.59 JTAA1.8
TAA_DO32: length 2.2
  BOTTOM w0.102: JTAA1.3 205.51,75.49 205.86,75.14 206.14,75.14 206.39,74.89 R12.2
TAA_DO64: length 3.6
  BOTTOM w0.102: JTAA1.1 206.01,75.68 206.56,75.13 206.68,75.13 207.27,74.54 R11.2 v6(208.55,74.54)
TDI_IREF: length 9.2
  TOP w0.102: v3(161.79,89.98) v1(162.64,89.98) 162.98,89.98 163.47,90.46 RC236.2
  BOTTOM w0.076: UC1.B12 160.67,86.42 160.8,86.55 160.8,87.34 160.87,87.41 160.87,89.17
  BOTTOM w0.102: 160.87,89.17 161.69,89.98 v3(161.79,89.98)
TDI_XDP: length 46.4
  TOP w0.102: v3(103.17,81.09) v1(103.17,79.87) 102.02,78.73 99.57,78.73 99.37,78.93 99.03,78.93 98.8,78.69 98.8,77.99 100.73,76.06 100.73,74.81 100.47,74.56 100.47,63.94 97.67,61.14 97.67,59.13 91.15,52.62 87.86,52.62 87.57,52.33 87.57,51.01 87.72,50.86 JXDP1.56
  BOTTOM w0.102: v3(103.17,81.09) 102.75,81.5 RC103.1 101.88,82.14 RC96.2
TDI_XDP_R: length 4.2
  BOTTOM w0.102: UC6.5 101.56,79.53 101.46,79.62 101.46,79.96 101.56,80.06 101.56,80.52 RC104.1 RC103.2 102.52,79.73 v1(102.45,79.67)
TDO_XDP: length 44.7
  TOP w0.102: JXDP1.52 87.37,49.86 86.58,50.66 RC280.2 86.58,51.98 87.67,53.07 90.41,53.07 96.78,59.43 96.78,62.23 v1(97.81,63.26) 99.89,65.34 99.89,73.6 v3(99.13,74.36) 99.13,74.74 98.09,75.78 98.09,78.3 98.94,79.16 99.58,79.16 100.06,79.63 v3(100.06,79.95)
  BOTTOM w0.102: UC6.2 v3(100.06,79.95) 99.85,80.15 RC123.1 RC95.2
TESTB: length 2.5
  TOP w0.102: R2633.2 300.42,169.01 v1(300.42,168.31) 300.42,167.93 300.15,167.66 U83.14
THERMATRIP2#: length 14.1
  TOP w0.102: Q12.1 174.01,135.2 174.07,135.14 175.07,135.14 175.4,134.81 175.4,132.9 v6(174.82,132.32) 174.29,131.79 R402.2 C371.1 172.26,131.57 172.26,130.69 171.83,130.25 171.83,128.93 170.79,127.88 U38.B34
THERMATRIP3#: length 241
  TOP w0.102: U38.A2 162.94,118 162.8,117.86 162.8,117.29 163.05,117.04 163.05,115.82 RP17.1 163.07,115.34 163.47,114.95 163.47,114.1 v2(163.35,113.99)
  IN1 w0.097: v3(82.11,49.85) 82.13,49.85 82.35,49.64 82.35,41.63 77.62,36.9 77.62,36.72 77.62,36.72 77.62,36.53 77.62,36.53 77.62,35.91 73.43,31.72 72.57,31.72 72.2,31.72 69.7,29.22 69.7,26.9 68.85,26.04 66.21,26.04 v3(66.06,26.2) ; v3(85.06,120.79) 84.53,121.31 82.57,121.31 77.57,116.32 77.57,104.77 v2(76.09,103.29) 76.71,102.67 76.71,99.19 75.87,98.34 75.87,86.76 69.13,80.02 60.94,80.02 59.46,81.49 58.7,81.49 v3(58.58,81.62)
  IN3 w0.102: v3(58.58,81.62) 58.28,81.62 57.8,81.14 57.8,80.28 59.83,78.24 59.83,76.23 65.49,70.57 71.75,70.57 73.91,68.41 73.91,65.94 73.91,65.94 73.91,64.28 75.63,62.56 75.63,57.6 80.66,52.57 80.66,51.3 v3(82.11,49.85) ; v3(85.06,120.79) 85.63,120.21 93.86,120.21 100.22,113.85 100.22,112.34 100.93,111.63 104.31,111.63 105.65,110.29 109.95,110.29 110.43,109.8 113.67,109.8 114.65,108.83 116.98,108.83 119.98,111.82 127.85,111.82 128.36,112.33 136.13,112.33 136.4,112.6 136.77,112.6 137.93,111.44 144.45,111.44 145.15,112.14 146.89,112.14 147.43,112.67 148.85,112.67 149.09,112.91 149.09,113.25 149.54,113.7 157.55,113.7 158.24,114.39 162.95,114.39 v2(163.35,113.99)
  BOTTOM w0.102: v1(76.69,103.29) v2(76.09,103.29) 75.68,102.88 QC6.6 ; v3(66.06,26.2) 66.06,31.63 66.69,32.27 PD601.1
THSEL_STRAP: length 11
  TOP w0.102: U38.B29 170.46,125.14 170.29,124.98 169.82,124.98 v2(169.41,125.39) ; R383.1 v3(174.06,130.59)
  IN3 w0.102: v3(174.06,130.59) 173.55,130.09 173.55,129.09 170.7,126.24 170.7,125.53 170.18,125.01 169.79,125.01 v2(169.41,125.39)
  BOTTOM w0.102: v3(174.06,130.59) v1(173.45,130.59)
TMDS_CLK: length 153.3
  IN1 w0.097: v2(21.13,103.49) 21.23,103.59 21.74,103.59 22.52,102.81 22.52,95.26 21.7,94.44 21.7,88.47 21.7,87.9 28.25,81.35 48.83,81.35 54.37,75.82 73.41,75.82 79.06,81.47 83.98,81.47 84.55,82.04 86.47,82.04 86.57,82.15 91.12,82.15 92.73,83.76 101.99,83.76 102.9,84.66 103.55,84.66 108.87,89.98 128.85,89.98 131.49,92.62 132.88,92.62 133.16,92.9 133.16,93.29 v2(133.26,93.38)
  BOTTOM w0.076: 134.78,87.79 134.78,87.78 134.76,87.76 134.76,87.42 136.36,85.82 136.36,84.42 136.29,84.35 136.29,84.31 135.88,83.9 UC1.B53
  BOTTOM w0.102: v2(133.26,93.38) 133.26,91.76 133.49,91.53 134,91.02 134,89.62 134.78,88.85 134.78,88.46 134.79,88.45 134.79,87.85 134.78,87.84 134.78,87.79 ; C103.2 20.58,103.75 20.88,103.75 v2(21.13,103.49)
TMDS_CLK#: length 153.3
  IN1 w0.097: v2(132.67,93.38) 132.71,93.38 132.95,93.14 132.95,92.99 132.8,92.83 131.4,92.83 128.76,90.19 108.78,90.19 103.46,84.88 102.81,84.88 101.9,83.97 92.64,83.97 91.03,82.36 86.49,82.36 86.38,82.25 84.46,82.25 83.89,81.68 78.98,81.68 73.33,76.03 54.45,76.03 48.92,81.56 28.33,81.56 21.91,87.99 21.91,88.39 21.91,88.39 21.91,94.35 22.73,95.17 22.73,102.9 21.83,103.8 21.37,103.8 21.13,104.04 v2(21.13,104.23)
  BOTTOM w0.076: UC1.A53 135.86,84.54 135.86,84.41 135.95,84.33 136.07,84.33 136.13,84.38 136.13,84.42 136.19,84.48 136.19,85.75 134.59,87.35 134.59,87.75 134.56,87.78 134.56,87.79
  BOTTOM w0.102: 134.56,87.79 134.56,87.93 134.58,87.94 134.58,88.36 134.56,88.37 134.56,88.76 133.79,89.53 133.79,90.93 133.04,91.67 133.04,93.06 132.88,93.22 132.88,93.34 132.83,93.38 v2(132.67,93.38) ; v2(21.13,104.23) 20.87,103.96 20.54,103.96 C191.2
TMDS_DDC_SCL: length 213.4
  TOP w0.102: v3(16.91,105.9) 16.66,106.15 Q122.1 ; v3(167.88,90.64) 167.5,90.26 167.19,90.26 167,90.44 167,92.17 166.81,92.37 v3(166.81,93.1) 166.81,93.76 166.78,93.78 166.78,93.79 165.48,95.08 165.48,98.52 165.76,98.79 RP1.6
  IN1 w0.076: v2(162.26,83.3) 162.26,83.3
  IN1 w0.097: 162.26,83.3 162.53,83.57 162.53,84.71 163.98,86.16 164.59,86.16 165.53,87.1 165.53,89.88 166.03,90.38 167.63,90.38 v3(167.88,90.64) ; v3(109.12,107.73) 108.93,107.54 108.93,107.2 108.71,106.98 108.06,106.98 106.6,108.44 106.6,119.43 102.2,123.83 101.76,123.83 101.76,123.83 82.52,123.83 79.84,121.14 74.67,121.14 72.43,123.38 36.64,123.38 33.36,120.11 25.1,120.11 21.68,116.68 21.68,114.88 20.4,113.61 19.95,113.61 19.62,113.28 19.62,111.79 19.73,111.68 19.73,109.27 19.01,108.55 18.31,108.55 16.65,106.89 16.65,106.16 v3(16.91,105.9)
  IN3 w0.102: v3(109.12,107.73) 108.94,107.56 108.94,105.59 110.87,103.66 125.58,103.66 126.44,102.8 130.75,98.48 143.93,98.48 144.62,99.17 145.58,99.17 146.45,100.04 153.48,100.04 156.35,97.17 157.14,97.17 158.66,95.64 163.95,95.64 166.77,92.82 166.77,90.63 167.02,90.37 167.62,90.37 v3(167.88,90.64)
  BOTTOM w0.076: UC1.D9 162.79,82.77 v2(162.26,83.3)
TMDS_DDC_SCL_R: length 9
  TOP w0.102: Q122.6 16.65,108.5 R471.1 15.08,107.99 v1(12.69,107.99) 11.11,107.99 10.72,107.6 10.72,106.02 JHDMI1.15
TMDS_DDC_SDA: length 211.2
  TOP w0.102: Q122.4 17.96,109.12 v2(17.77,109.31) ; v4(167.88,89.88) 167.73,90.03 167.09,90.03 166.77,90.35 166.77,92.07 166.58,92.27 166.58,93.66 166.55,93.69 166.55,93.69 165.25,94.99 165.25,95.18 165.26,95.18 RP1.5
  IN1 w0.076: 162.75,83.3 162.75,83.2 162.28,82.73 v2(162.28,82.28)
  IN1 w0.097: 162.75,83.3 162.75,83.47 162.75,83.47 162.75,84.62 164.07,85.94 164.68,85.94 165.75,87.01 165.75,89.79 166.12,90.16 167.6,90.16 v4(167.88,89.88) ; v2(17.77,109.31) 17.77,109.23 18.23,108.77 18.91,108.77 19.5,109.36 19.5,111.59 19.4,111.7 19.4,113.37 19.85,113.83 20.31,113.83 21.45,114.97 21.45,116.78 25.01,120.33 33.27,120.33 36.55,123.61 72.52,123.61 74.76,121.37 79.75,121.37 82.43,124.05 101.71,124.05 102.29,124.05 106.82,119.52 106.82,108.53 108.16,107.2 108.61,107.2 108.71,107.29 108.71,107.51 v3(108.49,107.73)
  IN3 w0.102: v4(167.88,89.88) 167.62,90.14 166.93,90.14 166.54,90.53 166.54,92.73 163.85,95.41 158.57,95.41 157.05,96.94 156.26,96.94 153.39,99.81 146.54,99.81 145.68,98.94 144.71,98.94 144.03,98.26 130.66,98.26 126.21,102.7 125.49,103.43 110.78,103.43 108.72,105.49 108.72,107.5 v3(108.49,107.73)
  BOTTOM w0.076: UC1.D11 162.29,82.28 v2(162.28,82.28)
TMDS_DDC_SDA_R: length 16.1
  TOP w0.102: v2(18.94,109.54) 18.94,106.97 R470.1 19.31,106.58 Q122.3
  IN1 w0.097: v2(18.94,109.54) 18.74,109.74 14.19,109.74 12.94,108.5 11.5,108.5 10.68,107.68 10.68,106.31 11.24,105.75 JHDMI1.16
TMDS_HPD: length 192.7
  IN3 w0.102: v3(20.72,112.18) 23.61,112.18 27.52,116.09 27.85,116.09 33.09,121.32 65.55,121.32 68.29,118.58 80.31,118.58 83.94,122.21 93.25,122.21 100.72,114.74 102.53,114.74 106.07,111.2 110.33,111.2 110.81,110.72 113.8,110.72 114.35,111.26 115.15,111.26 115.54,111.66 117.64,111.66 118.72,112.74 127.47,112.74 128.25,113.52 139.56,113.52 140.13,113.52 140.53,113.12 143.65,113.12 144.08,113.55 v3(146.21,113.55)
  BOTTOM w0.076: 165.11,89.36 165.02,89.36 165.01,89.36 164.9,89.36 v2(163.87,88.33) 164.23,87.97 164.23,87.51 163.72,87.01 163.72,85.99 163.85,85.86 163.85,85.1 163.6,84.86 UC1.A8
  BOTTOM w0.102: QZ22.1 17.8,112.23 v1(18,112.43) 18.93,112.43 R475.1 19.18,112.18 v3(20.72,112.18) ; v3(146.21,113.55) 146.21,112.85 146.8,112.25 146.8,109.29 145,107.49 145,103.62 146.36,102.26 151.26,102.26 151.55,101.97 155.94,101.97 159.37,98.54 160.28,98.54 162.92,95.9 165.83,95.9 166.39,96.46 167,96.46 167.39,96.06 167.39,93.9 166.19,92.7 166.06,92.57 166.06,90.3 165.11,89.36
TMDS_N0: length 159.4
  IN1 w0.097: v2(134.42,94.57) 134.23,94.38 133.51,94.38 133.16,94.74 131.83,94.74 128.01,90.92 107.87,90.92 102.08,85.13 92.79,85.13 90.79,83.13 86.16,83.13 85.97,82.94 84.18,82.94 83.61,82.37 78.69,82.37 73.04,76.72 54.74,76.72 49.2,82.25 28.62,82.25 22.6,88.28 22.6,93.84 23.42,94.67 23.42,104.53 22.47,105.48 22.47,106.78 21.97,107.27 21.34,107.27 v2(21.22,107.39)
  BOTTOM w0.076: UC1.C49 138.38,83.51 138.1,83.79 138.1,84.11 138.03,84.19 138.03,86.24 137.24,87.02 137.24,87.75 137.26,87.78 137.26,87.79
  BOTTOM w0.102: v2(21.22,107.39) 21.18,107.35 20.41,107.35 C209.2 ; 137.26,87.79 137.26,92.05 136.23,93.08 135.3,94.02 134.93,94.39 134.6,94.39 v2(134.42,94.57)
TMDS_N1: length 148.6
  IN1 w0.097: v2(132.23,91.31) 132.12,91.2 131.04,91.2 129.32,89.49 109.1,89.49 103.53,83.91 103.02,83.91 102.27,83.16 92.96,83.16 91.45,81.65 86.96,81.65 86.81,81.49 84.68,81.49 84.18,80.99 79.45,80.99 73.8,75.34 54.17,75.34 48.63,80.88 27.98,80.88 21.17,87.69 21.17,94.86 22.04,95.73 22.04,100.89 21.56,101.37 21.2,101.37 v2(21.06,101.51)
  BOTTOM w0.076: 133.77,87.79 133.77,87.78 133.75,87.75 133.75,87.41 134.98,86.18 134.98,85.55 135.58,84.94 135.58,84.72 135.58,84.72 135.58,83.72 135.88,83.43 UC1.C53
  BOTTOM w0.102: v2(132.23,91.31) 132.32,91.23 132.72,91.23 133.24,90.71 133.24,89.28 133.77,88.75 133.77,87.79 ; v2(21.06,101.51) 20.94,101.4 20.31,101.4 C270.2
TMDS_N2: length 152.5
  IN1 w0.097: v2(21.12,98.95) 20.84,98.67 20.5,98.67 20.28,98.44 20.28,87.89 20.27,87.88 20.27,87.31 27.61,79.98 48.26,79.98 53.79,74.44 74.3,74.44 79.26,79.4 85.78,79.4 86.97,80.6 87.18,80.6 87.29,80.71 91.8,80.71 93.35,82.26 107.84,82.26 108.99,81.11 112.33,81.11 114.76,83.54 114.76,86.9 116.31,88.45 116.31,88.45 116.43,88.57 131.85,88.57 134.16,90.88 134.16,90.98 134.32,91.15 134.44,91.15 v2(134.68,90.91)
  BOTTOM w0.076: 135.54,87.79 135.54,87.75 135.56,87.73 135.56,87.71 135.57,87.7 135.57,87.52 136.8,86.29 136.8,84.64 136.8,84.45 136.86,84.28 136.86,84.17 136.83,84.11 136.83,84.09 136.81,84.05 136.8,84.02 136.8,83.83 136.84,83.68 136.87,83.64 UC1.C51
  BOTTOM w0.102: v2(134.68,90.91) 134.82,91.05 135.12,91.05 135.29,90.89 135.54,90.63 135.54,87.79 ; C272.2 20.5,98.67 20.84,98.67 v2(21.12,98.95)
TMDS_P0: length 159.4
  IN1 w0.097: v2(134.43,93.98) 134.24,94.17 133.43,94.17 133.07,94.53 131.92,94.53 128.1,90.71 107.96,90.71 102.17,84.92 92.88,84.92 90.88,82.92 86.25,82.92 86.06,82.73 84.26,82.73 83.69,82.16 78.78,82.16 73.13,76.51 54.65,76.51 49.12,82.04 28.53,82.04 22.39,88.19 22.39,93.93 23.21,94.75 23.21,104.44 22.26,105.39 22.26,106.69 21.89,107.06 21.42,107.06 21.22,106.87 v2(21.22,106.72)
  BOTTOM w0.076: 137.05,87.79 137.05,87.78 137.07,87.75 137.07,86.95 137.86,86.17 137.86,84.12 137.94,84.05 137.94,83.7 UC1.B50
  BOTTOM w0.102: v2(21.22,106.72) 21.22,106.81 20.89,107.14 20.32,107.14 20.16,106.97 C199.2 ; 137.05,87.79 137.05,91.96 134.84,94.17 134.62,94.17 v2(134.43,93.98)
TMDS_P1: length 148.5
  IN1 w0.097: v2(132.23,90.73) 131.97,90.99 131.13,90.99 129.41,89.27 109.19,89.27 103.61,83.7 103.11,83.7 102.36,82.95 93.04,82.95 91.54,81.44 87.05,81.44 86.9,81.28 84.77,81.28 84.27,80.78 79.54,80.78 73.89,75.13 54.08,75.13 48.55,80.67 27.9,80.67 20.96,87.6 20.96,94.95 21.83,95.82 21.83,100.8 21.47,101.16 21.29,101.16 21.04,100.91 v2(21.04,100.81)
  BOTTOM w0.076: 133.56,87.79 133.56,87.7 133.58,87.68 133.58,87.34 134.81,86.11 134.81,85.48 135.42,84.87 135.42,84.72 135.41,84.72 135.41,83.68 UC1.B54
  BOTTOM w0.102: 133.56,87.79 133.56,88.66 133.33,88.88 133.02,89.19 133.02,90.62 132.63,91.01 132.51,91.01 v2(132.23,90.73) ; C269.2 20.06,101.06 20.18,101.18 20.67,101.18 v2(21.04,100.81)
TMDS_P2: length 152.5
  IN1 w0.097: v2(134.68,91.5) 134.53,91.35 134.53,91.36 134.24,91.36 133.95,91.07 133.95,90.96 131.77,88.78 116.34,88.78 116.1,88.53 114.55,86.98 114.55,83.62 112.24,81.32 109.08,81.32 107.93,82.47 93.27,82.47 91.72,80.92 87.2,80.92 87.09,80.81 86.88,80.81 85.69,79.62 79.17,79.62 74.21,74.65 53.88,74.65 48.35,80.19 27.7,80.19 20.49,87.4 20.49,87.8 20.49,98.35 20.59,98.45 21.03,98.45 v2(21.12,98.36)
  BOTTOM w0.076: UC1.C50 137.55,83.37 137.38,83.55 137.2,83.55 136.99,83.75 136.96,83.86 136.96,83.99 136.99,84.05 137,84.06 137.02,84.14 137.02,84.36 136.96,84.48 136.96,84.71 136.96,86.36 135.73,87.59 135.73,87.74 135.75,87.75 135.75,87.76 135.76,87.78 135.76,87.79
  BOTTOM w0.102: C271.2 20.36,98.45 21.03,98.45 v2(21.12,98.36) ; v2(134.68,91.5) 134.9,91.27 135.21,91.27 135.76,90.72 135.76,87.79
TMDS_RP_CLK: length 4.2
  BOTTOM w0.102: L9.1 15.61,103.39 L10.1 16.25,103.39 16.57,103.71 16.87,103.71 R464.1 17.5,103.75 17.95,103.75 17.96,103.74 18.49,103.74 18.51,103.75 18.89,103.75 C103.1
TMDS_RP_CLK#: length 4.2
  BOTTOM w0.102: L11.1 15.62,104.24 L10.4 16.23,104.24 16.55,103.93 16.78,103.93 R466.1 17.5,103.97 v3(18.23,103.97) 18.93,103.97 C191.1
TMDS_RP_N0: length 4.2
  BOTTOM w0.102: L14.1 15.68,107.62 L13.4 16.31,107.62 16.63,107.3 v3(17.16,107.3) 17.87,107.3 R463.1 18.56,107.23 18.86,107.23 19.24,107.6 C209.1
TMDS_RP_N1: length 4.1
  BOTTOM w0.102: C270.1 18.8,101.3 18.39,101.3 R469.1 17.74,101.32 v3(17.1,101.32) 16.64,101.32 16.32,101.64 L16.4 15.63,101.64 L17.1
TMDS_RP_N2: length 4.2
  BOTTOM w0.102: C272.1 18.74,98.7 v3(18.16,98.7) 17.56,98.7 R468.1 17.06,99 17.06,98.83 16.95,98.73 16.62,98.73 16.3,99.04 L19.4 15.67,99.04 L20.1
TMDS_RP_P0: length 4.2
  BOTTOM w0.102: L12.1 15.69,106.77 L13.1 16.32,106.77 16.64,107.08 16.88,107.08 16.9,107.07 17.43,107.07 17.44,107.08 17.81,107.08 R462.1 18.47,107.01 18.82,107.01 C199.1
TMDS_RP_P1: length 4.1
  BOTTOM w0.102: L15.1 15.63,100.79 L16.1 16.34,100.79 16.66,101.11 16.77,101.11 16.77,101.1 16.78,101.09 17.36,101.09 17.38,101.11 17.69,101.11 R467.1 18.39,101.08 18.76,101.08 C269.1
TMDS_RP_P2: length 4.2
  BOTTOM w0.102: L18.1 15.67,98.19 L19.1 16.33,98.19 16.65,98.51 16.95,98.51 17.06,98.4 17.06,98.18 R465.1 17.56,98.48 17.89,98.48 17.9,98.47 18.43,98.47 18.44,98.48 18.82,98.48 C271.1
TMDSB_CON_CLK: length 3.7
  BOTTOM w0.102: L9.2 14.69,103.39 L10.2 14.03,103.39 13.73,103.69 13.17,103.69 12.63,103.15 11.9,103.15 JHDMI1.10
TMDSB_CON_CLK#: length 3.7
  BOTTOM w0.102: JHDMI1.12 11.89,103.36 12.54,103.36 13.1,103.93 13.71,103.93 14.03,104.24 L10.3 14.69,104.24 L11.2
TMDSB_CON_N0: length 10.8
  BOTTOM w0.102: JHDMI1.9 10.31,101.89 10.53,101.89 10.67,102.03 10.67,107.11 11.36,107.8 12.73,107.8 13.29,107.24 13.72,107.24 14.1,107.62 L13.3 14.73,107.62 L14.2
TMDSB_CON_N1: length 3.9
  BOTTOM w0.102: L17.2 14.67,101.64 L16.3 14.01,101.64 13.7,101.32 13.19,101.32 12.2,100.33 11.92,100.33 JHDMI1.6
TMDSB_CON_N2: length 5.7
  BOTTOM w0.102: JHDMI1.3 10.36,98.84 10.55,98.84 11.34,98.06 12.61,98.06 13.28,98.73 13.77,98.73 14.08,99.04 L19.3 14.74,99.04 L20.2
TMDSB_CON_P0: length 10.7
  BOTTOM w0.102: JHDMI1.7 10.38,101.68 10.62,101.68 10.89,101.94 10.89,107.02 11.45,107.58 12.64,107.58 13.2,107.02 13.81,107.02 14.06,106.77 L13.2 14.72,106.77 L12.2
TMDSB_CON_P1: length 3.9
  BOTTOM w0.102: JHDMI1.4 11.87,100.12 12.29,100.12 13.28,101.11 13.73,101.11 14.05,100.79 L16.2 14.68,100.79 L15.2
TMDSB_CON_P2: length 5.7
  BOTTOM w0.102: L18.2 14.74,98.19 L19.2 14.05,98.19 13.73,98.51 13.37,98.51 12.7,97.84 11.25,97.84 10.46,98.63 10.33,98.63 JHDMI1.1
TMS_XDP: length 36.3
  TOP w0.102: JXDP1.58 87.96,51.36 87.8,51.52 87.8,52.23 87.95,52.39 91.46,52.39 93.41,54.34 94.25,54.34 98.06,58.15 98.06,60.88 v1(99.6,62.43) 100.7,63.52 100.7,74.13 v3(100.96,74.38)
  BOTTOM w0.102: RC101.2 100.58,74 v3(100.96,74.38) 101.97,74.38 102.25,74.66 102.25,75.25 102.06,75.44 UC6.9
TOUCH_PANEL_INTR#: length 202.4
  TOP w0.102: v3(99.56,130.39) 98.96,130.99 98.96,139.22 98.86,139.32 98.73,139.32 97.43,140.63 97.43,141.73 95.77,143.38 95.77,143.88 95.19,144.46 90.52,144.46 90.14,144.84 90.14,152.84 91.66,154.37 91.66,156.07 91.15,156.58 91.15,165.82 96.42,171.09 JTS1.6
  IN2 w0.102: v3(171.11,76.52) 171.17,76.52 171.87,77.21 171.87,78.12 172.3,78.55 172.3,78.98 172.86,79.54 172.86,84.43 172.79,84.5 172.79,87.07 175.57,89.85 177.82,89.85 180,92.04 180,96.56 179.44,97.12 177.41,97.12 175.56,98.97 175.56,101.1 174.39,102.27 174.39,105.14 170.91,108.62 168.13,108.62 167.14,109.61 158.96,109.61 158.49,110.08 158.49,111.96 157.32,113.13 155.08,113.13 154.5,112.55 154.18,112.55 153.62,113.11 153.62,115.48 150.74,118.36 150.74,125.02 146.94,128.82 133.26,128.82 129.91,125.46 128.17,125.46 127.4,126.24 127.4,128.04 124.88,130.55 121.37,130.55 121.04,130.89 112.51,130.89 110.04,128.41 109.36,128.41 106.99,126.03 100.83,126.03 100.09,126.77 100.09,129.86 v3(99.56,130.39)
  BOTTOM w0.076: 170.78,76.52 170.42,76.52 170.17,76.77 168.35,76.77 168.26,76.86 168.03,76.86 167.87,76.7 167.87,76.68 167.77,76.58 167.77,76.47 167.61,76.31 167.38,76.31 167.14,76.55 UC1.P3
  BOTTOM w0.102: v3(99.56,130.39) 99.57,130.39 v1(100.12,130.94) 100.87,130.94 102.16,129.64 RC315.1 RC324.2 ; 170.78,76.52 v3(171.11,76.52)
TOUCH_RST_N_GYRO_INT1: length 7.6
  BOTTOM w0.076: 170.78,78.65 v1(170.43,78.3) 170.21,78.08 UC1.L1
  BOTTOM w0.102: RP9.7 174.32,78.65 173.94,78.27 172.77,78.27 172.77,78.26 172.63,78.4 171.95,78.4 171.59,78.75 170.88,78.75 170.78,78.65
TOUCHPAD_INTR#: length 30.2
  TOP w0.102: v2(176.57,95.34) 176.24,95.34 v1(175.99,95.59) 175.66,95.92 RC140.2
  IN2 w0.076: v2(163.78,75.86) 163.56,76.09 163.56,76.96 163.9,77.3 165.87,77.3 166.14,77.58 166.96,77.58
  IN2 w0.102: 166.96,77.58 168.56,77.58 170.49,79.51 170.49,88.24 174.06,91.81 174.06,92.82 v2(176.57,95.34)
  BOTTOM w0.076: UC1.U7 163.88,75.68 163.88,75.77 v2(163.78,75.86)
TP_CLK: length 16
  TOP w0.102: L45.1 146.26,104.82 C380.1 145.06,104.82 144.8,104.56 143.86,104.56 143.55,104.86 142.46,104.86 142.22,105.1 D22.2 140.95,104.39 140.86,104.3 140.12,104.3 139.84,104.58 v3(137.73,104.58) 133.57,104.58 133.26,104.89 133.26,105.44 133.4,105.58 JTP1.7
TP_DATA: length 16.5
  TOP w0.102: L44.1 146.2,103.96 C379.1 145.08,103.87 144.29,103.87 143.59,103.17 D22.3 140.95,103.92 140.8,104.08 140.02,104.08 139.74,104.35 v3(139.08,104.35) 133.47,104.35 133.03,104.8 133.03,105.44 132.9,105.58 JTP1.6
TP_DC_TEST_B2: length 12.5
  TOP w0.254: v3(174.77,92.65) 174.77,92.92 RC139.1
  BOTTOM w0.254: UC1.B2 169,85.41 169,86.83 v1(172.18,90.01) 174.77,92.6 v3(174.77,92.65)
TP_LAN_JTAG_TCK: length 3.2
  TOP w0.102: R172.2 196.47,153.88 196.31,153.72 v1(196.31,153.5) 196.79,153.02 197.07,153.02 197.31,152.78 U21.35
TP_LAN_JTAG_TDI: length 2.7
  TOP w0.102: T92.1 198.51,154.6 U21.32
TP_LAN_JTAG_TDO: length 1.5
  TOP w0.102: U21.34 197.71,153.51 T93.1
TP_LAN_JTAG_TMS: length 4.7
  TOP w0.102: v1(198.36,156.02) 198.36,155.56 R171.2 198.11,153.93 U21.33
TPM_ID0: length 17.1
  TOP w0.102: RC284.2 v1(170.32,95.82) 170.33,95.82 170,95.49 v3(169.84,95.49)
  IN2 w0.102: v2(166.37,82.32) 166.37,82.94 168.55,85.12 168.55,88.97 169.79,90.22 169.79,94.3 169.41,94.68 169.41,95.21 169.69,95.49 v3(169.84,95.49)
  BOTTOM w0.076: 166.19,82.14 v2(166.37,82.32)
  BOTTOM w0.089: UC1.E4 166.19,82.14
TPM_ID1: length 16
  TOP w0.102: RC285.2 176.24,93.31 176.65,92.9 v1(176.65,92.39) 176.42,92.16 175.89,92.16 v3(175.4,92.65)
  BOTTOM w0.076: 170.54,87.3 169.84,86.6 169.84,85.72 167.77,83.65 167.38,83.65 167.35,83.63 166.98,83.25 UC1.C3
  BOTTOM w0.102: v3(175.4,92.65) 175.4,92.16 170.54,87.3
TRIP_+VDDRP: length 3.5
  BOTTOM w0.102: v1(37.76,26.38) 36.69,26.38 PR702.2
  BOTTOM w0.254: PU700.2 35.33,27.89 36.41,26.81 36.41,26.66 PR702.2
TRST#_XDP: length 34.9
  TOP w0.102: JXDP1.54 87.48,50.36 87.34,50.51 87.34,52.42 87.76,52.84 90.82,52.84 v1(96.42,58.44) 97.22,59.24 97.22,61.66 100.17,64.61 v3(100.17,74.97)
  BOTTOM w0.102: UC6.12 100.56,75.33 100.19,74.97 v3(100.17,74.97)
U2_BOOT1: length 5.9
  BOTTOM w0.102: PR601.1 61.16,33.61 v1(62.46,33.61)
  BOTTOM w0.254: 59.75,31.48 59.75,30.23 59.61,30.09 PU600.1
  BOTTOM w0.508: PR601.1 61.15,32.87 59.75,31.48
U2_BOOT2: length 4.4
  BOTTOM w0.254: 54.74,30.74 54.74,30.27 54.92,30.09 PU600.18
  BOTTOM w0.508: PR631.1 53.78,32.91 v1(54.29,32.41) 54.74,31.96 54.74,30.74
U2_LGATE1: length 11.4
  IN1 w1.016: 58.23,33.03 63.31,38.11
  BOTTOM w0.102: PR635.1 59.15,34.2 59.15,35.18 v1(58.41,35.92)
  BOTTOM w0.254: 58.1,32.45 v3(58.1,32.46) 58.1,32.57 58.69,33.16 PR635.1
  vias: v2(58.1,31.82) v2(63.82,40.14) v2(63.82,39.5) v2(69.4,40.14) v2(69.4,39.5)
U2_LGATE2: length 8.2
  IN1 w1.016: 56.45,33.28 56.45,33.29 56.36,33.29 55.34,34.31 55.34,34.4 52.13,37.6 52.13,38.68
  BOTTOM w0.254: v2(56.39,31.76) 56.46,31.68 PU600.20
  vias: v2(47.08,40.3) v2(47.05,39.63) v2(52.8,40.27) v2(52.77,39.63) v2(56.39,32.39)
U2_PHASE1: length 20.4
  IN1 w1.016: 70.55,42.43 71.59,41.38 71.59,36.79 67.93,33.13 62.71,33.13 61.68,32.1 61.68,32.09 60.97,32.09 60.69,32.37
  BOTTOM w0.254: v2(59.07,31.9) 58.46,31.29 PU600.24
  vias: v1(59.6,32.53) v2(59.07,32.53) v2(69.41,43.06) v2(69.41,42.3)
U2_PHASE2: length 14.5
  IN1 w1.016: 54.72,32.24 50.89,36.08 49.52,36.08 48.83,36.76 48.83,42.43
  BOTTOM w0.254: v2(55.69,31.76) 55.69,31.5 55.96,31.23 PU600.19
  vias: v1(49.14,48.34) v2(47.37,42.87) v2(47.37,42.24) v2(55.69,32.39)
U2_UGATE1: length 30.4
  IN1 w1.016: 61.71,30.49 68.29,30.49 74.51,36.71 74.51,48.18 72.83,49.86
  BOTTOM w0.254: PU600.2 59.93,29.59 v2(60.26,29.92)
  vias: v2(60.26,30.55) v2(71.97,51.52) v2(72.43,51.07)
U2_UGATE2: length 34.1
  IN1 w1.016: 53,31.4 50.86,33.54 48.2,33.54 46.1,35.63 46.1,45.23 51.17,50.3 58.1,50.3
  BOTTOM w0.254: v2(54.04,30.49) 54.23,30.3 54.23,29.92 54.56,29.59 PU600.17
  vias: v2(54.04,31.12) v2(57.83,51.27) v2(58.48,51.21)
UG_3V: length 12.6
  TOP w0.102: v2(226.88,155.46) 227.62,155.46 v1(227.96,155.12)
  IN2 w1.016: 216.21,153.63 216.33,153.76 223.66,153.76 224.5,154.59 226.7,154.59 ; 216.03,153.45 215.64,153.07
  vias: v2(214.65,153.45) v2(214.66,154.09) v2(226.25,155.46)
UG_5V: length 13.7
  TOP w0.102: v1(215.99,159.22) 215.61,158.84 v2(214.57,158.84)
  IN2 w1.016: 225.28,158.81 221.37,162.72 218.74,162.72 215.95,159.93
  vias: v2(214.6,158.25) v2(226.25,159.01) v2(226.88,159.01)
UG_+VDDRP: length 10.5
  IN2 w1.016: 36.47,32.55 38.5,32.55 42.76,36.8 42.76,39.28
  vias: v2(35.41,32.83) v2(35.4,32.23) v2(42.41,42.61) v2(42.41,41.95)
UIM_CLK: length 50.4
  TOP w0.102: v2(244.06,145.61) 244.06,145.77 243.58,146.25 243.58,149.37 244.41,150.21 244.41,157.46 246.75,159.8 246.75,163.22 246.4,163.58 246.4,164.77 246.65,165.02 v1(246.65,171.92) 246.65,176.1 248.64,178.09 250.97,180.42 250.97,183.66 251.54,184.23 252.56,184.23 C264.1 253.71,184.3 253.84,184.43 U28.3 253.84,185.64 253.38,186.09 v3(252.75,186.09)
  BOTTOM w0.102: JMINI2.12 243.46,145.7 243.55,145.61 v2(244.06,145.61) ; v3(252.75,186.09) 253.14,186.49 JSIM1.5
UIM_DATA: length 51.2
  TOP w0.102: v2(253.93,181.05) 253.93,181.48 253.84,181.57 U28.4 253.84,183.1 253.5,183.43 C267.1 252.31,183.75 251.74,183.75 251.45,183.46 251.45,180.22 248.98,177.74 247.13,175.9 247.13,164.82 246.88,164.57 246.88,163.78 247.23,163.42 247.23,159.6 244.9,157.26 244.9,150.01 244.06,149.17 244.06,146.46 244.54,145.97 244.54,145.71 v2(244.64,145.61)
  BOTTOM w0.102: JSIM1.6 v2(253.93,181.05) ; v2(244.64,145.61) 244.64,145.51 244.25,145.12 243.53,145.12 243.3,144.9 JMINI2.10
UIM_RESET: length 53.2
  TOP w0.102: v3(247.13,147.43) 247.93,147.43 252.9,152.4 252.9,166.79 257.83,171.72 257.83,183.98 257.58,184.23 C265.1 255.96,184.23 255.74,184.46 U28.1 255.74,185.65 256.18,186.09 v3(257.45,186.09)
  BOTTOM w0.102: JMINI2.14 243.52,146.5 244.07,147.05 v1(246.35,147.05) 246.75,147.05 v3(247.13,147.43) ; v3(257.45,186.09) 257.05,186.49 JSIM1.3
UIM_VPP: length 48.2
  TOP w0.381: C266.1 256.55,183.37 U28.6 255.74,181.27 v2(255.99,181.01) 255.99,177.3 249.42,170.73 249.42,167.22 251.19,165.45 251.19,158.15 246.85,153.81 246.85,152.36 247.34,151.88 247.34,150.23 v2(245.63,148.53)
  BOTTOM w0.381: v2(245.63,148.53) v1(244.77,148.53) 244.42,148.53 243.2,147.3 JMINI2.16 ; JSIM1.4 256.45,180.55 v2(255.99,181.01)
USB3RN0: length 171.1
  IN1 w0.076: v2(156.61,80.96) 156.61,80.77 156.76,80.62 156.85,80.62 157,80.77 157,82.57 156.7,82.87 156.23,82.87 155.97,83.13 155.93,83.13 155.92,83.15
  IN1 w0.097: 155.92,83.15 155.21,83.86 154.63,83.86 149.06,89.42 148.43,89.42 145.44,92.41 140.59,92.41 139.8,91.62 139.58,91.62 138.21,90.26 138.21,89.37 134.01,85.17 131.22,85.17 129.3,83.25 127.3,83.25 125.53,81.47 118.09,81.47 117.78,81.16 117.73,81.16 111.91,75.34 105.44,75.34 102.33,72.23 102.33,71.56 100.53,69.77 100.53,67.58 95.98,63.03 95.98,60.14 94.52,58.68 81.56,58.68 75.9,64.34 70.77,64.34 66.63,68.48 57.64,68.48 55.1,71.02 54.01,71.02 46.92,78.11 46.91,78.11 46.39,78.63 46.39,78.64 45.74,79.29 25.11,79.29 23.58,77.76 23.1,77.76 22.85,77.51 v2(22.85,77.02)
  BOTTOM w0.076: v2(156.61,80.96) 156.61,80.89 156.86,80.64 UC1.G20
  BOTTOM w0.102: R246.1 21.19,77.27 L40.1 21.8,77.27 22.12,77.59 22.38,77.59 22.85,77.13 v2(22.85,77.02)
USB3RN0_D-: length 8.5
  BOTTOM w0.102: JUSB1.5 12.81,76.79 13.59,77.57 13.72,77.57 14.16,78.01 15.95,78.01 16.09,77.86 D17.1 D17.10 18,77.86 18.15,78.01 18.38,78.01 18.72,77.67 18.9,77.67 19.3,77.27 L40.2 19.88,77.19 R246.2
USB3RN1: length 190.7
  TOP w0.102: v2(293.19,163.74) 293.55,164.1 293.87,164.1 293.93,164.04 C2966.1
  IN3 w0.076: v2(157.52,81.61) 157.52,81.46 157.88,81.11 157.88,80.84 158.04,80.67 158.04,79.53 158.48,79.09 160.05,79.09 160.61,78.54 161.53,78.54 161.55,78.51 161.76,78.31 165.97,78.31 166.25,78.03 166.98,78.03 168.9,79.95 168.9,80.15
  IN3 w0.086: 168.9,80.15 168.9,87.77 171.06,89.93 171.06,93 172.08,94.01 173.11,94.01 176.09,96.99 177.18,96.99 177.66,97.47 179.96,97.47 183.2,100.72 183.2,101.05 184.7,102.55 187.34,102.55 188.44,103.64 197.47,103.64 202.71,108.87 204.43,110.6 206.51,110.6 214.43,118.52 219.1,118.52 221.91,121.33 221.91,127.39 224.86,130.34 225.29,130.34 229.53,134.57 230.33,134.57 233.32,137.55 238.78,137.55 240.43,139.2 246.4,139.2 255.98,148.78 255.98,151.35 258.03,153.4 265.79,153.4 271.74,159.34 274.19,159.34 276.45,161.6 288.16,161.6 289.82,163.27 293.53,163.27 293.94,163.68 293.94,164.1 293.84,164.2 293.28,164.2 293.19,164.1 v2(293.19,163.74)
  BOTTOM w0.076: v2(157.52,81.61) 157.85,81.94 UC1.E18
  BOTTOM w0.102: R2647.2 294.18,164.04 294.14,164.08 293.54,164.08 v2(293.19,163.74)
USB3RN1_C: length 2.9
  TOP w0.102: U83.23 296.9,164.27 296.73,164.44 296.37,164.44 296.36,164.43 295.75,164.43 295.43,164.11 295.21,164.11 C2966.2
USB3RN1_R: length 46.1
  TOP w0.102: R2655.1 304.96,164.31 305.31,164.31 305.4,164.22 v3(305.4,163.99)
  IN3 w0.086: v2(341.1,174.54) 341.1,174.54 341.28,174.36 341.6,174.36 341.98,173.98 341.98,173.14 339.11,170.27 336.18,170.27 334.84,168.92 311.16,168.92 306.54,164.3 305.71,164.3 v3(305.4,163.99)
  BOTTOM w0.102: v3(305.4,163.99) 305.4,164.24 305.3,164.34 304.98,164.34 R2655.1 ; v2(341.1,174.54) 341.01,174.45 JIO1.16
USB3RN1_R_CL: length 9.2
  BOTTOM w0.102: R2647.1 295.49,164.13 296.24,164.13 296.52,164.41 297.01,164.41 297.02,164.4 297.55,164.4 297.56,164.41 297.91,164.41 298,164.5 301.11,164.5 301.28,164.32 v3(302.01,164.32) 303.39,164.32 R2651.2
USB3RN1_RC: length 2.6
  TOP w0.102: R2655.2 303.33,164.39 302.92,164.39 302.91,164.38 302.35,164.38 302.34,164.39 302.01,164.39 301.89,164.27 U83.8
USB3RN4: length 168.1
  TOP w0.102: v2(177.19,172.6) 177.46,172.87 177.46,173.04 177.71,173.29 179.78,173.29 180.03,173.53 180.86,173.53 180.88,173.54 181.44,173.54 181.45,173.53 184.92,173.53 186.33,174.94 186.62,174.94 187.8,176.13 187.8,178.29 187.23,178.86 187.23,179.63 187.04,179.82 L55.4 186.77,179.82 R274.1
  IN1 w0.076: v2(159.43,81.61) 159.67,81.37 159.76,81.37 159.82,81.44 159.82,82.93 160.1,83.21 160.1,83.22 160.12,83.24 160.12,83.29 160.12,83.3
  IN1 w0.097: v2(177.19,172.6) 177.44,172.36 177.44,172.2 177.1,171.87 176.07,171.87 171.85,167.65 171.85,164.36 170.95,163.46 170.95,153.87 177.26,147.56 182.21,147.56 182.74,147.03 184.22,147.03 186.32,144.92 186.32,141.36 187.31,140.37 189.27,138.42 189.56,138.13 190.24,138.13 194.44,133.94 201.55,133.94 203.42,132.07 203.42,125.85 204.21,125.06 204.21,122.33 203.8,121.93 203.8,119.57 199.96,115.74 199.96,115.18 197.39,112.6 196.52,112.6 196.07,112.6 195.24,111.77 194,111.77 192.93,110.7 192.93,109.99 192.58,109.64 192.2,109.64 191.8,109.24 191.8,107.66 191.33,107.19 189.92,105.78 189.92,99.38 189.33,98.78 189.33,94.2 188.43,93.3 188.11,93.3 186.81,92 186.78,91.99 185.82,91.99 185.82,92 184.6,92 183.92,92.68 178.45,92.68 178.3,92.52 177.92,92.15 171.99,92.15 171.91,92.06 165.21,92.06 161.55,88.4 161.55,87.41 160.33,86.19 160.33,83.51 160.12,83.3
  BOTTOM w0.089: UC1.F15 159.5,81.61 v2(159.43,81.61)
USB3RN4_D-: length 5.4
  TOP w0.102: v2(188.41,183.2) 188.61,183 188.61,182.87 188.37,182.62 188.12,182.62 187.88,182.86 187.32,182.86 187.09,182.62 187.09,182.36 186.77,182.04 L55.3 186.77,181.51 R274.2
  BOTTOM w0.102: JDOCK1.84 188.45,183.74 188.59,183.6 188.59,183.39 v2(188.41,183.2)
USB3RP0: length 171.1
  IN1 w0.076: v2(156.57,80.31) 156.71,80.45 156.92,80.45 157.17,80.7 157.17,82.64 156.77,83.03 156.3,83.03 156.08,83.26 156.08,83.29 156.07,83.29
  IN1 w0.097: v2(22.84,78.3) 23.16,77.97 23.49,77.97 25.02,79.5 45.83,79.5 46.6,78.72 46.6,78.72 47,78.32 47,78.32 54.09,71.23 55.18,71.23 57.72,68.69 66.72,68.69 70.86,64.55 75.99,64.55 81.65,58.89 94.43,58.89 95.77,60.23 95.77,63.12 100.32,67.67 100.32,69.86 102.12,71.65 102.12,72.32 105.35,75.55 111.83,75.55 117.64,81.37 117.69,81.37 118.01,81.68 125.44,81.68 127.22,83.46 129.21,83.46 131.13,85.38 133.92,85.38 138,89.46 138,90.35 139.49,91.84 139.72,91.84 140.5,92.62 145.53,92.62 148.52,89.63 149.15,89.63 154.71,84.07 155.3,84.07 156.07,83.29
  BOTTOM w0.076: UC1.H20 156.64,80.31 v2(156.57,80.31)
  BOTTOM w0.102: R247.1 21.19,78.12 L40.4 21.78,78.12 22.09,77.81 22.52,77.81 22.84,78.13 v2(22.84,78.3)
USB3RP0_D+: length 8.5
  BOTTOM w0.102: R247.2 19.88,78.21 L40.3 19.23,78.12 18.99,77.89 18.81,77.89 18.47,78.23 18.15,78.23 18.01,78.36 D17.9 D17.2 16.15,78.36 16.02,78.23 14.07,78.23 13.63,77.79 13.17,77.79 12.81,78.15 JUSB1.6
USB3RP1: length 190.8
  TOP w0.102: v2(293.19,164.69) 293.57,164.31 293.85,164.31 293.93,164.38 C2967.1
  IN3 w0.076: 169.08,80.15 169.08,80.13 169.07,80.13 169.07,80.08 169.07,80.07 169.07,79.88 167.05,77.86 166.18,77.86 165.9,78.14 161.69,78.14 161.48,78.35 161.48,78.35 161.46,78.37 160.54,78.37 159.99,78.93 158.41,78.93 157.88,79.46 157.88,80.6 v2(157.52,80.96)
  IN3 w0.086: v2(293.19,164.69) 293.19,164.44 293.26,164.37 293.92,164.37 294.12,164.17 294.12,163.61 293.6,163.09 289.89,163.09 288.23,161.43 276.52,161.43 274.26,159.17 271.81,159.17 265.87,153.22 258.11,153.22 256.16,151.28 256.16,148.71 246.47,139.03 240.5,139.03 238.85,137.38 233.39,137.38 230.41,134.4 229.6,134.4 225.37,130.16 224.93,130.16 222.09,127.32 222.09,121.26 219.17,118.34 214.5,118.34 206.59,110.43 204.51,110.43 202.88,108.8 197.55,103.47 188.51,103.47 187.42,102.37 184.78,102.37 183.38,100.98 183.38,100.65 180.03,97.3 177.74,97.3 177.25,96.81 176.16,96.81 173.19,93.84 172.15,93.84 171.24,92.92 171.24,89.86 169.08,87.7 169.08,80.15
  BOTTOM w0.076: UC1.F18 157.85,81.29 v2(157.52,80.96)
  BOTTOM w0.102: v2(293.19,164.69) 293.58,164.3 294.1,164.3 294.18,164.38 R2646.2
USB3RP1_C: length 2.9
  TOP w0.102: C2967.2 295.21,164.32 295.33,164.32 295.66,164.65 v3(296.08,164.65) 296.82,164.65 296.93,164.77 U83.22
USB3RP1_R: length 46
  TOP w0.102: R2654.1 304.99,164.53 305.27,164.53 305.4,164.65 v3(305.4,164.88)
  IN3 w0.086: v3(305.4,164.88) 305.4,164.81 305.73,164.47 306.46,164.47 311.09,169.1 334.76,169.1 336.11,170.45 339.04,170.45 341.8,173.21 341.8,173.9 341.52,174.18 341.29,174.18 341.09,173.98 v2(341.09,173.85)
  BOTTOM w0.102: v3(305.4,164.88) 305.4,164.68 305.27,164.55 304.97,164.55 R2654.1 ; v2(341.09,173.85) 341.09,173.95 340.8,174.23 340.59,174.23 340.3,173.95 JIO1.18
USB3RP1_R_CL: length 9.2
  BOTTOM w0.102: R2650.2 303.38,164.54 302.33,164.54 302.3,164.57 301.73,164.57 301.7,164.54 301.37,164.54 301.2,164.72 297.91,164.72 297.82,164.63 v3(297.28,164.63) 296.43,164.63 296.15,164.35 295.43,164.35 R2646.1
USB3RP1_RC: length 2.5
  TOP w0.102: R2654.2 303.44,164.6 v3(302.63,164.6) 302.07,164.6 301.91,164.77 U83.9
USB3RP4: length 168.1
  TOP w0.102: v3(177.87,172.6) 177.68,172.8 177.68,172.95 177.8,173.07 179.87,173.07 180.12,173.32 v3(181.17,173.32) 185,173.32 186.41,174.73 186.71,174.73 188.02,176.04 188.02,178.38 187.44,178.95 187.44,179.38 187.62,179.55 L55.1 187.68,179.88 R276.1
  IN1 w0.076: 160.27,83.15 159.99,82.87 159.99,81.37 159.83,81.2 159.67,81.2 v2(159.43,80.96)
  IN1 w0.097: 160.27,83.15 160.54,83.42 160.54,86.1 161.76,87.32 161.76,88.31 165.3,91.85 171.99,91.85 172.07,91.93 178,91.93 178.38,92.31 178.38,92.31 178.54,92.47 183.83,92.47 184.51,91.78 185.73,91.78 186.87,91.78 186.9,91.78 188.2,93.09 188.52,93.09 189.54,94.11 189.54,98.7 190.14,99.29 190.14,105.69 191.54,107.1 191.54,107.1 191.95,107.5 192.01,107.57 192.01,109.16 192.29,109.43 192.67,109.43 193.14,109.9 193.14,110.61 194.09,111.56 195.33,111.56 196.16,112.38 196.61,112.38 196.61,112.39 197.47,112.39 200.18,115.09 200.18,115.65 204.01,119.49 204.01,121.84 204.42,122.24 204.42,125.15 203.63,125.94 203.63,132.16 201.64,134.15 194.52,134.15 190.33,138.34 189.64,138.34 189.42,138.56 187.61,140.37 186.53,141.45 186.53,145.01 184.3,147.24 182.83,147.24 182.3,147.77 177.34,147.77 171.16,153.96 171.16,163.37 172.06,164.27 172.06,167.56 176.16,171.66 177.19,171.66 177.65,172.11 177.65,172.38 v3(177.87,172.6)
  BOTTOM w0.089: v2(159.43,80.96) 159.75,80.64 UC1.G15
USB3RP4_D+: length 5.4
  TOP w0.102: v2(188.99,183.2) 188.83,183.04 188.83,182.78 188.46,182.41 188.28,182.41 188.03,182.41 187.79,182.64 187.41,182.64 187.3,182.53 187.3,182.37 187.62,182.05 L55.2 187.68,181.45 R276.2
  BOTTOM w0.102: v2(188.99,183.2) 188.81,183.39 188.81,183.58 188.95,183.72 JDOCK1.86
USB3TN0: length 163.7
  IN1 w0.097: v2(146.77,89.84) 146.56,89.62 146.32,89.62 144.01,91.93 140.79,91.93 140,91.15 139.78,91.15 138.69,90.06 138.69,89.16 134.18,84.64 131.54,84.64 129.16,82.26 128.18,82.26 127.82,81.9 126.72,81.9 125.71,80.89 119.31,80.89 116.88,78.45 115.72,78.45 112.13,74.86 105.64,74.86 102.81,72.04 102.81,71.3 101.03,69.52 101.03,67.29 96.56,62.81 96.56,60 94.68,58.13 81.32,58.13 76.09,63.36 70.98,63.36 66.34,68 57.19,68 54.65,70.54 53.43,70.54 45.17,78.81 27.31,78.81 26.09,77.59 24.5,77.59 v2(24.31,77.78)
  BOTTOM w0.076: 147.49,87.11 147.49,87.09 147.46,87.06 147.46,85.89 148.12,85.23 148.12,83.68 148.41,83.39 UC1.C33
  BOTTOM w0.102: v2(24.31,77.78) 24.31,77.78 24.64,77.44 24.97,77.44 25.44,77.91 25.44,78.65 25.22,78.87 24.42,79.67 23.16,79.67 23.03,79.54 23.03,79.39 C292.2 ; v2(146.77,89.84) 146.81,89.8 147.26,89.8 147.49,89.57 147.49,87.11
USB3TN0_C: length 1.9
  BOTTOM w0.102: C292.1 21.94,79.56 21.6,79.56 21.28,79.24 L41.1 20.89,79.24 R248.1
USB3TN0_D-: length 11.1
  BOTTOM w0.102: JUSB1.8 12.81,83.27 13.02,83.48 13.48,83.48 14.05,82.9 14.5,82.9 15.08,82.33 15.08,80.02 15.59,79.5 16.02,79.5 16.16,79.36 D17.4 D17.7 18.04,79.36 18.18,79.5 18.72,79.5 18.98,79.24 L41.2 19.72,79.24 R248.2
USB3TN1: length 206.7
  TOP w0.102: C2968.1 293.77,166.05 293.61,166.05 293.55,165.98 v3(293.55,165.64)
  IN3 w0.086: v2(145.3,99.76) 145.19,99.76 145.03,99.91 145.03,100.15 145.52,100.64 149.82,100.64 151.1,101.92 155.82,101.92 156.04,102.15 162.94,102.15 163.32,101.77 170.6,101.77 174.67,105.83 175.02,105.83 175.03,105.83 177.34,105.83 182.95,111.44 188.28,111.44 188.87,112.03 190.59,112.03 192.15,110.48 195.53,110.48 197.13,112.08 199.12,112.08 207.66,120.61 207.66,128.46 211.32,132.12 211.32,133.49 213.32,135.5 218.99,135.5 220.89,137.4 228.18,137.4 230.19,139.41 232.5,139.41 235.4,142.31 244.9,142.31 250.43,147.84 250.43,150.56 250.43,150.83 255.49,155.89 264.55,155.89 271.44,162.78 288.44,162.78 291.69,166.03 293.15,166.03 293.54,165.64 v3(293.55,165.64)
  BOTTOM w0.076: 148.03,87.11 148.03,85.8 148.41,85.42 148.5,85.42 148.76,85.17 148.76,84.49 148.41,84.14 UC1.B33
  BOTTOM w0.102: 148.03,87.11 148.03,90.28 147.21,91.1 146.57,91.1 144,93.67 144,96.85 144.01,96.86 144.01,97.4 144,97.41 144,98.4 144.56,98.96 145.05,98.96 145.3,99.21 v2(145.3,99.76) ; v3(293.55,165.64) 293.55,165.86 293.67,165.98 293.84,165.98 294.18,165.64 C2968.1
USB3TN1_C: length 2.5
  TOP w0.102: C2968.2 295.4,165.95 295.8,165.95 295.81,165.94 296.36,165.94 296.37,165.95 296.59,165.95 296.77,165.77 U83.20
USB3TN1_RP: length 42.9
  TOP w0.102: R2657.2 304.96,166.47 305.39,166.47 v3(305.63,166.23)
  IN3 w0.086: v2(337.96,173.01) 338.01,172.96 338.97,172.96 339.48,172.45 339.48,171.77 339,171.28 335.96,171.28 334.28,169.61 310.94,169.61 307.76,166.43 305.83,166.43 v3(305.63,166.23)
  BOTTOM w0.102: R2657.2 304.98,166.5 305.36,166.5 v3(305.63,166.23) ; v2(337.96,173.01) 338.05,172.92 338.77,172.92 338.8,172.95 JIO1.22
USB3TN1_RP_C: length 2.8
  TOP w0.102: U83.11 302.04,165.77 302.19,165.91 302.52,165.91 302.63,166.03 302.66,166.03 303.03,166.39 303.03,166.42 303.14,166.53 303.34,166.53 R2657.1
USB3TN1_RP_CL: length 9.5
  BOTTOM w0.102: R2652.2 295.46,166 296.84,166 297.46,166.62 v3(297.68,166.62) 300.61,166.62 300.63,166.61 301.16,166.61 301.17,166.62 301.48,166.62 301.92,166.18 302.5,166.18 302.82,166.49 303.39,166.49 R2649.1
USB3TN4: length 135.3
  TOP w0.102: v4(189.68,166.38) 189.93,166.13 190.24,166.13 190.34,166.23 190.34,167.75 189.44,168.65 189.44,173.63 190.53,174.73 190.53,175.59 190.25,175.87 190.25,177.8 189.35,178.69 189.35,179.04 189.28,179.12 189.12,179.12 188.99,179.24 L56.4 189,179.83 R275.1
  BOTTOM w0.076: UC1.B31 149.92,84.03 150.07,84.03 150.27,84.23 150.27,85.19 149.81,85.65 149.81,87.07 149.84,87.1 149.84,87.12
  BOTTOM w0.102: v4(189.68,166.38) 189.84,166.22 190.2,166.22 190.7,165.72 190.77,165.65 190.77,161.94 190.16,161.33 190.16,161.33 190.01,161.17 190.01,158.29 189.02,157.3 186.77,157.3 184.2,154.74 182.86,154.74 180.01,151.89 177.31,151.89 175.39,149.97 169.84,149.97 168.99,150.82 163.81,150.82 161.27,148.28 160.47,147.48 160.47,145.48 159.69,144.7 159.69,141.83 145.62,127.76 145.62,125.45 145.43,125.26 145.43,110.45 143.91,108.93 143.91,106.89 142.65,105.64 142.65,103.28 145.96,99.96 145.96,98.84 145.43,98.31 145.43,93.31 146.98,91.76 147.44,91.76 149.84,89.36 149.84,87.12
USB3TN4_D-: length 4.5
  TOP w0.102: v2(190.11,182.96) 190.21,182.86 190.21,182.79 190.06,182.64 189.6,182.64 189.31,182.35 189.31,182.05 188.99,181.74 L56.3 189,181.5 R275.2
  BOTTOM w0.102: JDOCK1.90 189.95,183.69 190.27,183.37 190.27,183.12 v2(190.11,182.96)
