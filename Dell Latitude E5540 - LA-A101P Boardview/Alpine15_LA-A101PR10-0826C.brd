# Allegro board Alpine15_LA-A101PR10-0826C.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
VSET_5075: length 5.9
  TOP w0.102: C367.1 R394.1 174.17,116.62 v1(173.35,117.44) 172.91,117.87 172.91,118.05 172.43,118.53 172.43,119.42 171.96,119.89 U38.A17
VSYNC_BUF: length 165.5
  IN1 w0.097: v2(338.59,167.83) 338.9,168.14 338.9,169.46 337.49,170.87 330.6,170.87 329.54,169.81 318.17,169.81 317.93,170.05 309.4,170.05 308.96,170.5 284.04,170.5 283.23,169.69 277.82,169.69 277.25,169.12 263.63,169.12 262.67,170.08 259.6,170.08 258.88,170.8 226.72,170.8 223.75,173.76 223.42,173.76 223.42,173.76 214.74,173.76 211.81,170.84 202.04,170.84 201.7,171.18 197.73,171.18 196.61,172.3 192.55,172.3 191.4,173.46 186.27,173.46 v2(184.77,171.95)
  BOTTOM w0.102: JIO1.44 338.97,167.45 v2(338.59,167.83) ; U39.18 184.73,170.85 184.53,171.05 184.53,171.72 v2(184.77,171.95)
VSYNC_DOCK: length 6.4
  IN1 w0.097: v3(184.47,175.25) 184.47,173.77 183.96,173.27 v2(183.96,172.48)
  BOTTOM w0.102: JDOCK1.67 184.45,175.27 v3(184.47,175.25) ; v2(183.96,172.48) 184.33,172.12 U39.17
WIGIG60GHZ_DIS#: length 154.1
  TOP w0.102: U37.A1 195.84,130.36 R289.2 197.1,131.25 198.14,130.21 203.14,130.21 208.37,135.44 210.15,135.44 212.79,138.09 234.46,138.09 235.19,137.35 255.31,137.35 280.91,162.95 280.91,164.29 285.7,169.07 290.27,169.07 293.28,172.09 304.98,172.09 306.36,173.47 317.79,173.47 320.36,176.04 320.36,180.35 v1(320.21,180.5) 320.21,181.6 R224.1 320.39,182.72 D13.1
WIGIG60GHZ_DIS#_R: length 6.2
  TOP w0.102: v1(319.19,184.22) D13.2 319.47,182.64 R224.2 318.91,181.77 318.66,182.03 v2(318.28,182.03)
  BOTTOM w0.102: v2(318.28,182.03) 317.5,181.25 JMINI1.32
WIRELESS_LED#: length 106.2
  TOP w0.102: v3(195.75,117.17) 195.33,117.59 U37.A47 ; Q28.4 207.77,140.9 R432.2 209.24,139.43 v3(209.52,139.43)
  IN1 w0.097: v2(249.84,164.72) 249.59,164.47 v2(249.59,163.25)
  IN3 w0.102: v3(195.75,117.17) 196.48,116.45 197.61,116.45 198.51,117.35 200.64,117.35 202.25,118.96 202.25,121.51 203.94,123.2 203.94,133.86 v3(209.52,139.43) 216.37,139.43 217.64,140.7 225.49,140.7 232.15,147.36 234.31,147.36 234.79,147.84 234.79,151.08 234.25,151.61 234.25,166 236.16,167.91 247.44,167.91 249.84,165.51 v2(249.84,164.72)
  BOTTOM w0.102: Q30.6 v2(249.59,163.25) 250.03,162.81 Q30.3 ; v2(249.84,164.72) 249.84,165.05 250.07,165.28 Q22.6
WIRELESS_ON#_OFF: length 186.9
  TOP w0.102: JUDB1.17 107.65,126.26 107.5,126.11 105.79,126.11 104.37,127.53 103.51,127.53 96.08,120.1 v3(96.08,117.41) ; U37.B13 190.08,127.77 190.52,127.33 190.52,127.09 v2(190.34,126.91) ; v3(187,130.2) 185.99,131.2 R293.2
  IN1 w0.097: v3(96.08,117.41) 96.16,117.33 96.16,116.74 96.57,116.32 97.37,116.32 99.37,114.32 99.37,112.09 107.57,103.88 116.69,103.88 119.1,106.3 120.59,106.3 121.68,107.39 123.88,107.39 126.5,104.77 130.31,104.77 131.72,106.18 150.48,106.18 150.73,105.94 150.96,105.94 152.01,104.89 152.01,103.62 153.05,102.58 160.75,102.58 161.81,103.64 165.22,103.64 165.87,102.99 173.76,102.99 174.51,103.75 174.87,103.75 175.62,102.99 179.15,102.99 181.78,105.62 185.95,105.62 188.48,108.15 188.48,108.71 190.02,110.25 190.24,110.25 191.35,111.37 191.35,111.61 192.68,112.94 194.76,112.94 195.65,113.83 196.18,113.83 198.84,116.49 198.84,117 200.22,118.39 200.54,118.39 201.25,119.1 201.25,122 202.82,123.57 202.82,124.66 202.25,125.23 202.25,129.65 200.37,131.53 192.48,131.53 189.81,134.2 187.11,134.2 186.68,133.77 186.68,130.51 v3(187,130.2)
  BOTTOM w0.102: v2(190.34,126.91) 190.34,128.71 189.68,129.37 187.82,129.37 v3(187,130.2) ; v3(96.08,117.41) v1(96.08,118.2)
WLAN_LAN_DISB#: length 47.2
  TOP w0.102: v3(202.5,156.28) 202.82,156.28 203.09,156.55 U24.4 203.09,157.32 203.27,157.5 203.27,158.77 202.56,159.49 v1(201.46,159.49) ; U37.A64 198.21,127.39 v3(198.28,127.47)
  IN3 w0.102: v3(202.5,156.28) 202.5,153.68 202.35,153.53 201.76,153.53 201.05,154.24 198.09,154.24 193.11,149.26 193.11,144.28 193.24,144.15 193.93,143.46 193.93,140.81 192.6,139.48 192.6,132.55 192.95,132.19 192.95,129.64 194.18,128.41 197.34,128.41 v3(198.28,127.47)
WLAN_LED: length 8
  TOP w0.102: R435.2 224.98,33.69 v1(223.97,33.69) 221.91,33.69 221.66,33.95 221.5,33.95 221.05,34.4 220.52,34.4 219.93,34.99 219.62,34.99 219.36,34.73 JLED1.9
WLAN_LED#: length 105.1
  TOP w0.102: v3(320.28,165.26) 320.28,165.34 322.85,167.91 322.85,177.38 v1(322.47,177.76) v3(322.47,178.35)
  IN3 w0.102: v3(281.27,154.6) 281.27,155.15 281.85,155.74 290.34,155.74 293.16,158.56 297.16,158.56 298.74,160.13 301.23,160.13 302.28,159.09 306.05,159.09 306.05,159.09 306.24,159.09 306.65,159.5 311.48,159.5 313.99,162.01 317.35,162.01 320.28,164.95 v3(320.28,165.26)
  BOTTOM w0.102: v3(322.47,178.35) 322.3,178.51 JMINI1.44 ; R227.1 247.9,165.28 Q22.1 248.73,165.04 249.44,164.32 250.13,164.32 250.54,164.73 250.92,164.73 252.82,166.64 261.93,166.64 262.12,166.64 267.83,160.92 267.83,155.93 269.06,154.7 269.06,154.7 270.59,153.17 271.45,153.17 279.85,153.17 v3(281.27,154.6)
WLAN_RADIO_DIS#: length 164.5
  TOP w0.102: U37.A48 195.84,117.78 v3(196.41,117.21)
  IN3 w0.102: v3(196.41,117.21) 196.78,117.58 200.54,117.58 202.02,119.06 202.02,121.6 203.72,123.3 203.72,134.09 208.88,139.25 208.88,139.51 209.21,139.84 209.68,139.84 209.71,139.81 209.86,139.66 216.28,139.66 217.68,141.06 225.29,141.06 231.84,147.61 234.08,147.61 234.56,148.09 234.56,150.98 234.03,151.52 234.03,152.06 234.03,166.1 234.52,166.58 236.07,168.13 247.83,168.13 251.08,164.88 254.47,164.88 255.13,165.54 265.92,165.54 270.06,169.68 276.06,169.68 280.48,174.1 287.52,174.1 v3(288.64,175.22)
  BOTTOM w0.102: R215.1 311.42,176.44 D12.1 310.2,175.22 v1(309.59,175.22) 308.25,175.22 307.76,174.74 296.59,174.74 295.7,175.63 289.04,175.63 v3(288.64,175.22)
WLAN_RADIO_DIS#_R: length 4.1
  BOTTOM w0.102: JMINI1.20 312.7,178.79 v1(312.33,178.42) R215.2 312.57,177.13 D12.2
WWAN_RADIO_DIS#: length 71.3
  TOP w0.102: U37.A53 198.49,121.89 198.55,121.83 R286.2 199.58,122.34 200.7,122.34 201.03,122.67 201.03,123.3 201.26,123.53 202.48,123.53 202.71,123.76 203.86,123.76 204.28,124.18 v1(204.28,126.25) 204.28,127.16 213.69,136.57 221.41,136.57 v3(221.77,136.93)
  IN1 w0.097: v3(221.77,136.93) 222.06,136.93 225.42,133.57 225.42,131.48 225.85,131.05 227.19,131.05 228.06,131.91 228.06,141.79 231.42,145.16 232.01,145.16 238.11,151.26 v2(239.97,151.26)
  BOTTOM w0.102: JMINI2.20 240.8,152.1 v2(239.97,151.26)
WWAN_SMBCLK: length 3.9
  BOTTOM w0.102: R216.2 R218.1 244.29,156.39 243.77,156.39 243.48,156.1 JMINI2.30
WWAN_SMBDAT: length 3.6
  BOTTOM w0.102: JMINI2.32 243.49,156.9 243.77,156.62 244.87,156.62 R219.1 R217.2
XDP_DBRESET#: length 144.8
  TOP w0.076: v2(147.51,85.05) 147.74,84.82 151.17,84.82 151.6,84.39 153.31,84.39 153.71,83.98 153.71,81.04 155.39,79.36 155.39,77 155.74,76.64 156.58,76.64 157.24,75.98 158.95,75.98 159.01,76.05 160.46,76.05 160.67,75.83 163.08,75.83 163.57,76.31 163.57,77.1 163.72,77.25 165.71,77.25 166.08,77.62 166.08,78 166.03,78.05 166.03,78.78 166.44,79.18 168.11,79.18 170.7,81.77 171.21,81.77
  TOP w0.102: CC68.1 100.07,55.71 97.65,55.71 v3(97.04,55.1) 95.24,53.3 93.42,53.3 92,51.88 92,49.11 91.62,48.73 90.77,48.73 90.63,48.86 JXDP1.48 ; 171.21,81.77 v1(171.77,81.77) 173.85,81.77 174.56,81.07 178.28,81.07 180.71,83.5 184.75,83.5 185.13,83.12 RC116.2 187.09,82.61 187.09,81.57 185.84,80.33 v3(185.51,80.33)
  IN3 w0.102: v2(147.51,85.05) 147.29,84.82 146.37,84.82 145.62,85.57 145,85.57 144.79,85.78 132.95,85.78 128.51,81.33 126.02,81.33 123.79,79.1 122.09,79.1 118.36,75.37 113.11,75.37 109.08,71.33 107.05,71.33 97.04,61.33 v3(97.04,55.1)
  BOTTOM w0.102: UC2.1 182.88,78.92 183.12,78.68 184.9,78.68 184.98,78.6 RC72.1 185.94,79.64 185.51,80.07 v3(185.51,80.33)
XDP_OBS0_R: length 55.6
  TOP w0.102: v2(93.01,41.87) 93.5,42.36 JXDP1.21
  IN3 w0.102: v2(93.01,41.87) 93.39,41.48 93.99,41.48 106.39,53.89 106.39,53.94 106.39,54.1 106.39,54.1 106.39,54.94 106.39,54.94 106.39,66.42 109.07,69.1 110.15,69.1 113.78,72.73 v2(113.78,72.94)
  BOTTOM w0.102: v2(113.78,72.94) 113.78,75.27 115.51,77 117,77 118.55,78.55 119.29,78.55 119.73,78.98 RC121.1 120.1,79.48 120.85,79.48 RC194.2
XDP_OBS1_R: length 59.9
  TOP w0.102: JXDP1.23 93.31,42.86 v2(92.32,41.87) ; RC204.2 113.17,76.38 v2(113.17,72.96)
  IN3 w0.102: v2(92.32,41.87) 93.11,42.66 94.33,42.66 105.4,53.73 105.4,66.53 108.52,69.66 109.87,69.66 v2(113.17,72.96)
  BOTTOM w0.102: RC121.2 118.25,79.1 116.7,77.56 114.98,77.56 v6(114.11,76.69) 113.17,75.75 v2(113.17,72.96)
XDP_RST#_R: length 16.4
  TOP w0.102: JXDP1.46 90.66,48.36 90.8,48.5 91.72,48.5 92.23,49.02 92.23,51.78 93.52,53.07 96.13,53.07 v1(97.61,54.55) 98.34,55.28 100.52,55.28 RC109.2
XTAL24_IN: length 10.3
  TOP w0.102: v2(152.47,87.44) 151.37,87.44 150.32,88.5 v1(150.32,89.95) RC44.2 RC40.1
  BOTTOM w0.076: UC1.A25 153.56,84.68 153.56,84.87 152.9,85.53 152.9,87.57 152.82,87.64 152.67,87.64 v2(152.47,87.44)
XTAL24_IN_R: length 4
  TOP w0.102: v1(148.95,90.55) 148.95,90.97 148.54,91.38 RC40.2 CC7.1 148.54,92.83 148.98,93.27 YC2.3
XTAL24_OUT: length 14.4
  TOP w0.102: v2(152.47,88.02) 152.44,88.05 151.73,88.05 v1(151.25,88.53) 151.23,88.55 RC44.1 CC6.1 151.23,92.48 152.06,93.31 152.06,94.91 151.18,95.79 YC2.1
  BOTTOM w0.076: UC1.B25 153.43,84.14 153.72,84.43 153.72,84.94 153.06,85.6 153.06,87.63 152.89,87.81 152.68,87.81 v2(152.47,88.02)
XTAL24M_IN: length 6.1
  TOP w0.102: U90.33 224.48,47.31 v1(224.95,46.84) 225.49,46.3 CC85.1 225.28,45.66 RC297.2 224.43,44.6 Y6.3
XTAL24M_OUT: length 7.8
  TOP w0.102: Y6.1 222.82,43.49 222.82,45.5 CC86.1 RC297.1 223.98,46.12 U90.32
XTAL_OUT: length 7.3
  TOP w0.102: v2(63.16,109.35) 63.78,109.35 v1(64.7,110.26) 65.4,110.97 CV105.1 65.4,111.63 65.13,111.9 65.13,113.4 YV2401.3
  BOTTOM w0.1: UV1.B10 63.55,109.74 v2(63.16,109.35)
XTALI: length 5.2
  TOP w0.102: U21.10 200.51,145.45 200.66,145.3 200.66,144.91 200.88,144.69 200.88,144.52 R206.2 201.56,142.99 C190.1 202.23,142.96 Y3.1
XTALIN: length 7.3
  TOP w0.102: v2(63.12,108.53) 62.78,108.87 62.78,109.59 62.93,109.74 v1(63.49,109.74) 63.77,110.02 63.77,110.5 63.92,110.65 64.8,110.65 65,110.85 65,111.21 64.94,111.27 CV104.1 64.54,111.68 64.52,111.7 64.52,111.86 YV2401.1
  BOTTOM w0.1: UV1.C11 62.71,108.94 v2(63.12,108.53)
XTALO: length 3.4
  TOP w0.102: U21.9 200.11,145.53 200.27,145.37 v1(200.27,144.8) 200.27,144.21 R206.1 200.66,143.82 R183.2
XTALO_R: length 5.6
  TOP w0.102: R183.1 200.66,141.22 C189.1 201.12,141.2 201.5,140.82 v1(201.64,140.82) 202.01,140.82 202.29,141.1 203.69,141.1 Y3.3
Z4012: length 2.7
  BOTTOM w0.102: RTCR1.2 v1(8.19,15.23)
  BOTTOM w0.508: RTCD1.2 8.99,16.38 8.8,16.57 RTCR1.2
Z4304: length 45.2
  TOP w0.102: v2(87.94,172.62) v1(87.94,173.39)
  IN1 w0.254: v2(87.94,172.62) 87.94,180.86 91.11,184.03 100.78,184.03 101.6,183.22 117.81,183.22 PBATT2.7
  BOTTOM w0.254: PD2.2 88.57,171.32 PR3.1 88.4,172.16 v2(87.94,172.62)
Z4305: length 40.5
  TOP w0.254: PBATT2.6 116.4,183.81 107.08,183.81 106.45,183.17 104.05,183.17 102.66,184.57 v1(100.82,184.57) 94.19,184.57 91.65,182.03 91.65,174.22 v2(90.05,172.62)
  BOTTOM w0.254: PD2.3 89.46,171.32 PR5.1 89.92,172.62 v2(90.05,172.62)
Z4306: length 44.4
  TOP w0.102: v2(87.66,170.19) 87.66,169.59 v1(87.75,169.51)
  IN2 w0.254: PBATT2.5 114.17,183.58 106.32,183.58 105.65,182.92 103.8,182.92 102.99,183.73 90.78,183.73 87.93,180.87 87.93,173.61 88.41,173.13 88.41,172.03 87.66,171.28 v2(87.66,170.19)
  BOTTOM w0.254: v2(87.66,170.19) 87.76,170.09 PR4.1 88.17,168.91 PD1.2
N07538: length 2.3
  TOP w0.254: PU701.28 127.21,156.7 126.97,156.95 v1(126.56,156.95) 126.2,156.59 PR534.1
N07670: length 15.8
  TOP w0.254: PR507.1 PR502.2 142.46,162.55 141.49,163.51 v1(141.49,170.29) 141.49,172.12 141.24,172.38 140.48,172.38 139.97,171.87 PQ501.4
N07710: length 4.2
  TOP w0.254: 150.89,160.82 151.7,160.82 151.88,161 v1(151.88,161.29) 151.7,161.47 PQ506.3 150.37,161.47 150.05,161.78 PR508.2
N07778: length 4.4
  TOP w0.254: PR504.2 147.82,149.79 148,149.97 PQ502.6 148,151.35 148.23,151.57 v1(148.45,151.57) 148.65,151.38 PQ502.5
N07808:
  vias: v1(158.44,169.79) v3(157.94,170.65) v3(158.58,170.65)
N07946:
  vias: v1(146.49,168.41)
N07954: length 31.1
  TOP w0.254: PD510.1 PD507.1 138.85,152.85 138.49,152.48 v2(138.49,152.15) ; v2(146.7,172.86) v1(147.3,172.25) 147.62,171.93 PD513.1
  IN1 w0.254: v3(145.13,166.94) 145.91,167.73 145.91,172.07 v2(146.7,172.86)
  BOTTOM w0.254: PQ524.4 v2(146.7,172.86) ; 145.08,165.65 144.82,165.39 144.82,163.67 144.28,163.13 143.65,163.13 143.17,163.61 142.46,163.61 141.75,162.9 141.75,159.14 138.49,155.89 v2(138.49,152.15)
N07974: length 10.7
  TOP w0.102: v1(146.24,169.85) 146.98,169.11 PQ525.1
  TOP w0.254: PQ525.1 147.67,166.92 147.82,166.76 147.82,165.56 147.42,165.16 143.96,165.16 v3(143.68,165.44)
  BOTTOM w0.254: PR520.2 144.16,165.85 144.08,165.85 v3(143.68,165.44)
N07998: length 4.3
  TOP w0.102: PR518.1 157.03,151.96 PU503.2 ; PR518.1 157.9,151.93 v1(158.13,152.16) ; PR518.1 157.06,150.52 PQ512.1
N08002: length 4.1
  TOP w0.102: v1(158.7,154.96) 158.65,154.91 PU503.4 157.39,154.91 156.38,155.92 156.38,156.63 156.38,156.63 PU504.1
N08014: length 21
  TOP w0.102: PQ525.2 142.91,167.88 PD512.1 142.51,167.09 143.02,166.58 143.02,165.31 143.4,164.93 143.4,163.38 143.6,163.18 144.44,163.18 144.97,163.71 v1(152.95,163.71) 153.81,162.85 PD506.1 PD508.1
N08016: length 6.5
  TOP w0.102: v1(157.85,164.3) 157.3,163.75 PD506.2 158.05,162.85 158.28,162.62 158.28,159.7 PU504.4
N08030: length 6.6
  TOP w0.102: PQ508.1 147.66,138.23 v1(147.65,138.23)
  TOP w0.254: PU502.2 147.26,142.63 PR506.2 PR514.2 146.7,140.32 147.03,139.99 PQ508.1
N08062: length 7.4
  TOP w0.254: PR503.1 140.41,155.23 v1(140.41,155.93) 140.41,156.38 140.97,156.93 140.97,159.02 PQ500.3 142.99,161.04 PD501.1
N08064: length 6.8
  TOP w0.102: PQ500.2 144.02,159.04 v1(144.43,159.45)
  TOP w0.254: PQ500.2 142.95,159.02 142.95,155.42 PR501.1 PR503.2
N08074: length 3.2
  TOP w0.102: PR501.2 143.39,155.59 v1(143.83,156.03)
  TOP w0.254: PR501.2 142.92,154.48 PQ503.6
N08082: length 3.2
  TOP w0.102: PU500.4 145.76,145.1 v1(145.76,144.66)
  TOP w0.381: PQ507.5 147.46,146.44 146.81,145.79 PU500.4
N08084: length 9.5
  TOP w0.102: v1(148.15,144.72) 148,144.87 PQ507.6
  TOP w0.254: 148.85,147.58 149.41,147.58 PQ507.3 151.13,147.09 PR500.1 151.19,147.66 PD504.1 ; 148.85,147.58 148.65,147.77 PQ502.2 ; 148.85,147.58 148.85,146.33 148.31,145.79 PQ507.6
N08086: length 6.3
  TOP w0.254: PQ507.2 150.13,146.44 150.84,145.73 150.84,145.36 151.2,145 v1(151.2,142.89) 151.2,142.4 150.77,141.98 PU502.4
N08128: length 3.8
  TOP w0.102: v1(159.4,156.37) 159.07,156.7 157.8,156.7 157.22,156.12 PR519.1 157.03,156.25 PU504.2
N08144: length 7.1
  TOP w0.102: PD508.2 156.91,160.69 156.91,158.58 155.58,157.25 v1(155.34,157.25) 155.3,157.25 154.13,158.42 PU505.4
N08150: length 2.3
  TOP w0.254: PU701.19 132.65,158.55 133.35,159.25 PR551.1
N08170: length 5.2
  TOP w0.102: PR505.2 146.27,152.2 v1(146.59,152.53)
  TOP w0.254: PQ503.2 143.57,150.71 143.75,150.54 144.06,150.54 144.22,150.69 PQ503.3 144.22,151.85 144.58,152.2 PR505.2
N08182: length 11.7
  TOP w0.254: PQ516.3 147.24,157.52 147.42,157.34 148.36,157.34 148.54,157.16 PQ516.6 149.44,156.7 v1(149.88,156.27) 150.43,155.71 151.3,155.71 152.16,154.85 152.16,153.45 PQ514.2 153.1,152.51 PR562.1 PR522.2
N08184: length 3.3
  TOP w0.102: v1(151.7,157.2) 151.7,156.91 PR521.2 PR523.2 153.07,156.08 PQ514.1
N08204: length 2.5
  TOP w0.102: v1(155.17,155.98) 154.41,155.98 PR523.1 153.48,156.91 PU505.2
N08214: length 4.4
  TOP w0.102: v1(139.14,138.02) PR526.1
  TOP w0.254: PQ515.3 139.71,139.58 PR526.1 139.06,139.09 PQ515.2
N08226: length 4.4
  TOP w0.102: v1(135.21,145.9) 136.8,145.9
  TOP w0.254: 136.8,145.9 136.8,144.4 PR524.2 PR528.1
N08230: length 3.9
  TOP w0.254: PQ517.1 137.76,148.73 137.94,148.91 139.16,148.91 v1(139.33,149.08) 139.5,149.25 139.5,150.44 PD507.2
N08260: length 2.9
  TOP w0.254: PR544.1 PR535.2 140.74,144.64 PQ520.2
N08264: length 3.4
  TOP w0.254: PQ520.1 141.16,147.98 140.76,148.39 140.76,149.47 141.29,149.99 PD510.2
N08280: length 6.4
  TOP w0.254: PR554.1 138.9,161.37 138.4,160.87 PQ522.3 135.98,160.87 135.46,161.39 v1(134.33,161.39) 134.19,161.39 PR551.2
N08282: length 2.9
  TOP w0.254: PR554.2 PR555.1 138.83,159.3 137.63,159.3 PQ522.2
N08290: length 2.2
  TOP w0.254: PR555.2 138.42,158.55 138.03,158.17 PQ523.6
N08296: length 3.7
  TOP w0.254: 138.68,154.31 138.42,154.31 PR557.2 ; 138.68,154.31 138.86,154.14 139.2,154.14 v1(139.33,154.28) PQ523.3 ; 138.68,154.31 PQ523.2
N16958676: length 3.3
  TOP w0.102: R418.2 R417.2 165.82,107.3 166.05,107.06 v1(166.05,106.69) 166.14,106.6 U43.5
N16958821: length 1.9
  TOP w0.102: U43.10 166.14,103 166.07,102.93 166.07,102.46 C391.1
N17049026: length 6.4
  TOP w0.102: C378.1 150.31,106.24 R405.2 148.53,106.24 R444.2 R449.2 146.46,106.24 L45.2 145.95,106.76 v1(144.36,106.76)
N17049030: length 6.1
  TOP w0.102: v1(145,101.8) 145.58,102.38 L44.2 146.56,102.38 147.22,103.04 R450.2 R441.2 149.42,103.04 R404.2 150.31,103.04 C377.1
N17119989: length 8.8
  TOP w0.102: U37.B49 195.08,119.44 194.94,119.58 194.94,120.16 v2(195.34,120.56) ; v3(197.3,117.13) 197.76,116.67 R316.2 v1(198.72,116.06)
  IN2 w0.102: v2(195.34,120.56) 195.34,120.56 195.72,120.18 196.76,120.18 197.3,119.65 v3(197.3,117.13)
N17156946: length 58.6
  TOP w0.254: v2(128.28,145.61) PR14.2 128.7,146.31 128.83,146.18 128.83,144.96 PC5.2 129.86,144.91 129.94,144.84 PR20.1 130.49,143.4 130.72,143.17 PQ5.4
  IN1 w0.203: v2(128.28,145.61) 126.56,147.33 123.23,147.33 114.62,155.94 111.64,155.94 108.26,159.32 107.28,159.32 105.3,161.3 99.6,161.3 99.22,161.68 99.2,161.68 98.97,161.91 97.53,163.36 97.53,170.06 94.91,172.68 v3(94.48,172.68)
  BOTTOM w0.102: v1(93.92,173.3) 94.48,172.74 v3(94.48,172.68)
  BOTTOM w0.254: PQ4.4 95.51,172.46 PR21.1 95,172.16 v3(94.48,172.68)
N17156948: length 2.5
  TOP w0.254: PQ5.1 128.18,141.17 127.95,141.4 127.95,141.87 128.26,142.17 PQ5.2
N17205976: length 3.4
  TOP w0.254: JDEG1.1 223.91,91.55 v1(223.08,90.72) R388.2
N17328413: length 4.6
  TOP w0.254: PR402.2 PR404.1 120.59,143.96 v1(121.12,144.5) 121.12,144.92 120.79,145.25 120.79,146.08 PU401.6
N17352357: length 2.4
  TOP w0.102: v1(102.78,12.15) CC67.2 103.01,13.07 RC83.1
N17353670: length 2
  TOP w0.102: RC128.1 v1(155.6,22.93)
  TOP w0.508: CC69.2 155.6,24.93 RC128.1
N17353833: length 2.1
  BOTTOM w0.102: RC195.1 CC70.2 80.08,23.91 v1(80.41,23.58)
N17404646: length 1.9
  TOP w0.102: v1(181.71,121.62) C339.1 R324.2
N18063845: length 4.5
  TOP w0.102: R413.1 163.45,137.95 v1(163.12,137.63) 163.12,137.22 163.43,136.92 165.34,136.92 165.53,137.1 U42.4
N18070155: length 7.7
  TOP w0.102: U37.B66 196.46,126.64 196.13,126.31 195.77,126.31 195.37,125.9 v2(195.36,125.9) ; R294.1 199.17,128.82 v2(198.87,129.12)
  IN2 w0.102: v2(198.87,129.12) 196.16,126.4 195.6,126.4 195.36,126.16 v2(195.36,125.9)
N18435663: length 2.4
  TOP w0.102: UC4.2 183.47,56.24 RC263.1 v1(183.45,57.23)
N18502042: length 5.5
  TOP w0.102: D23.2 222.08,38.49 222.41,38.16 Q24.1 ; D23.2 D24.2 ; D23.2 222.39,39.03 222.6,39.23 R428.2 224.09,39.79 v1(224.09,40.17)
N18502098: length 4.5
  TOP w0.102: Q24.6 222.67,35.92 v1(223.69,36.94) 226.43,36.94 Q26.2
N18502175: length 6.1
  TOP w0.102: v1(226.84,39.41) 227.65,38.59 R438.1 226.81,38.72 225.15,38.72 224.6,38.18 Q26.1
N18599297: length 0.9
  BOTTOM w0.102: C76.2 R57.1
N18599324: length 3
  BOTTOM w0.102: v1(198.09,61.89) 198.09,62.37 R45.1 196.94,62.39 C85.2
N18632981: length 2.6
  BOTTOM w0.102: R2602.1 R2601.1 87.93,155.57 87.82,155.68 Q126.2
N18633605: length 15
  IN2 w0.254: v3(90.41,156.12) 90.35,156.06 90.35,149.68 89.88,149.21 87.47,149.21 v3(87.11,148.86)
  BOTTOM w0.102: R2578.2 91.71,159.41 v1(91.76,159.46)
  BOTTOM w0.254: v3(87.11,148.86) 86.73,148.48 Q125.3 ; R2578.2 91.18,157.85 90.41,157.09 v3(90.41,156.12)
N18640439: length 3.5
  TOP w0.102: R556.2 v1(186.38,166.28) v3(185.46,166.28)
  BOTTOM w0.203: v3(185.46,166.28) 185.52,166.34 U39.8
N18768391:
  vias: v1(234.51,37.62) v3(233.54,37.53) v3(233.57,36.87) v3(233.57,36.23) v3(233.57,35.57)
N18782591: length 4.6
  TOP w0.102: U52.12 120.56,120.49 120.69,120.36 v1(122.83,120.36) 123.05,120.36 123.87,119.54 R2583.2
N19641658: length 3.8
  TOP w0.102: PR411.1 120.09,148.26 v1(119.7,148.65)
  TOP w0.254: PU401.4 120.3,147.91 PR411.1 119.18,146.79 PR408.2
N19821558: length 1.5
  BOTTOM w0.102: v1(38.6,31.36) 38.12,31.36 PR701.2
N19821564: length 6.5
  TOP w0.102: v1(33.56,31.06) 33.24,31.38 v3(32.73,31.38)
  IN3 w0.102: v2(34.33,32.29) 33.42,31.38 v3(32.73,31.38)
  BOTTOM w0.102: PR710.1 PR711.1 32.08,30.66 32.6,30.66 PC706.1 32.61,31.26 v3(32.73,31.38)
  BOTTOM w0.254: PU700.7 v2(34.33,32.29)
N19821679:
  vias: v1(33.32,39.31)
N19844496: length 9.8
  BOTTOM w0.203: PU300.3 81.09,89.72 v1(80.94,89.88) 80.7,89.88 80.29,90.29 PR318.1
  BOTTOM w0.254: PR318.1 PR317.1 79.91,88.15 PR319.1 79.28,88.76 77.3,88.76 76.14,87.6 PD300.1
N19844507: length 6.7
  BOTTOM w0.203: PU300.26 85.28,87.8 85.69,87.39 86.2,87.39 v1(86.4,87.18)
  BOTTOM w0.254: v1(86.4,87.18) 86.78,87.18 86.96,87.36 88.18,87.36 PC305.2 PR323.2 PC308.2 90.01,87.21 PR322.1
N19844524: length 3.8
  BOTTOM w0.203: v1(84.8,87.18) 84.8,87.26 84.48,87.58 PU300.28
  BOTTOM w0.254: v1(84.8,87.18) 84.8,86.82 PR327.2 PC310.1
N19844548: length 2
  BOTTOM w0.102: PR329.1 95.22,94.02 94.92,93.72 v1(94.92,93.7)
  BOTTOM w0.254: PR329.1 PH301.2
N19844564: length 7.1
  TOP w0.508: PC307.2 96.22,104.24 97.55,105.57 v1(99.77,105.57) PR324.1
N19844606: length 30.7
  IN1 w0.254: v2(94.83,108.06) 94.83,107.81 94.12,107.1 91.46,107.1 90.57,106.21 90.57,101.75 89.31,100.49 83.85,100.49 83.33,99.98 83.33,94.89 v2(84.98,93.25)
  BOTTOM w0.203: PU300.14 84.88,93.15 v2(84.98,93.25) 85.67,93.94 v1(86.45,93.94) PC301.1
  BOTTOM w0.254: PH300.2 v2(94.83,108.06) ; PC301.1 PR305.1
N19844618: length 5.1
  BOTTOM w0.203: PU300.25 85.68,87.91 85.82,87.76 86.24,87.76 86.66,88.18 87.39,88.18 87.4,88.18 ; 87.4,88.18 PC305.1 ; 87.4,88.18 v1(87.35,88.18)
  BOTTOM w0.254: PC305.1 PR323.1 89.22,88.23 PR325.1
N19844649: length 5.1
  BOTTOM w0.203: PU300.16 85.68,92.74 85.99,93.05 87.49,93.05 88.29,93.85 v1(88.5,93.85) 89.23,94.58 PR311.2
N19844680: length 5.2
  BOTTOM w0.203: PU300.2 81.43,89.32 80.99,88.89 v1(80.99,88.61) 80.99,88.01 80.59,87.61 80.28,87.61 PR320.1
  BOTTOM w0.254: PR320.1 79.45,86.78 PC306.1
N19844689: length 3.6
  BOTTOM w0.203: PU300.8 81.94,91.72 v1(80.92,92.74) PR313.1
  BOTTOM w0.254: PR313.1 PR312.1
N19844763: length 2.3
  BOTTOM w0.102: v1(91.29,88.58) 91.13,88.58 90.91,88.8 90.45,88.8 PR325.2
  BOTTOM w0.254: PC308.1 90.06,89.04 PR325.2
N19847729: length 3.2
  TOP w0.203: PU51.4 211.08,156.01 210.56,155.49
  TOP w0.254: PR53.2 PR51.2 210.08,155.01 210.56,155.49
N19847766: length 2.7
  TOP w0.203: PU51.2 209.99,156.81 PR55.1
  TOP w0.254: PR55.1 PR52.1
N19847771: length 5
  TOP w0.102: PR56.2 209.48,154.52 208.28,154.52 v1(208.12,154.68)
  TOP w0.203: PU51.5 211.35,155.61 211.14,155.4 211.14,154.65 210.55,154.06 PR56.2
N19847781: length 0.6
  TOP w0.102: 214.37,162.09 v1(214.37,162.65)
N19847797: length 3.7
  TOP w0.102: PR57.2 210.08,158.77 210.64,158.77 v1(210.95,159.08)
  TOP w0.203: PU51.1 211.22,157.21 210.77,157.66 210.77,157.8 209.94,158.63 PR57.2
N19847834: length 1.2
  TOP w0.102: v1(213.86,150.18) 213.86,150.81 PR62.1
N19847903: length 1.3
  TOP w0.102: PC65.2 223.46,164.8 v1(223.49,164.83)
N19847904:
  vias: v1(226.94,146.01)
N19848836: length 1.2
  BOTTOM w0.102: v1(44.78,16.19) 44.45,15.87 PR100.1
N19848854: length 4.8
  BOTTOM w0.102: v1(33.91,10.51) 33.91,10.69 34.8,11.58 PR111.2
  BOTTOM w0.203: PR111.2 PR110.2 34.92,12.5 35.78,13.36 PU100.7
N19848898: length 3.7
  BOTTOM w0.203: PU100.9 36.06,14.16 35.78,14.44 v1(35.78,15.81) 35.53,16.06 PR106.2
N19849916: length 2.7
  BOTTOM w0.102: v1(83.4,60.13) 83.4,61.49 PR158.2
  BOTTOM w0.508: PR158.2 PC165.2
N19850625: length 10.5
  TOP w0.102: v3(114.5,170.62) v1(115.34,170.62)
  IN2 w1.016: 112.89,162.11 111.83,163.18 111.83,168.03 113.4,169.61 113.4,170.67
  vias: v2(113.4,161.54) v2(113.4,160.84) v3(114.47,171.26)
N19850629: length 12.1
  TOP w0.254: PQ401.2 114.95,152.64 v2(115.31,153) ; v3(119.37,155.23) 118.82,154.68 PC400.2 119.11,154.18 PR403.2 119.01,153.32 PQ402.2
  IN2 w0.254: v2(115.31,153) 115.07,153.23 115.07,153.86 115.33,154.11 117.39,154.11 118.51,155.23 v3(119.37,155.23)
  BOTTOM w0.102: v2(115.31,153) v1(115.31,152.35)
N19850655: length 1.6
  BOTTOM w0.102: PR433.1 110.65,175.28 v1(110.46,175.47)
N19850656: length 5.4
  TOP w0.254: PC413.2 121.2,158.56 v1(121.05,158.41) 120.72,158.41 120.46,158.66 120.46,160.07 120.31,160.23 PU402.6 ; PC413.2 PR421.2 ; PC413.2 PR424.2
N19850732: length 51
  TOP w0.102: v1(112.18,148.42) 112.94,148.42 PQ401.1
  TOP w0.508: PQ401.1 113.98,149.88 113.66,150.2 v3(112.99,150.2)
  IN3 w0.508: v3(103.98,180.94) 103.55,180.94 101.16,183.32 100.02,183.32 99,182.31 99,168.13 98.39,167.52 98.39,166.18 101.18,163.38 101.18,161.66 105.38,157.47 105.38,157.03 108.14,154.27 109.82,154.27 112.99,151.09 v3(112.99,150.2)
  BOTTOM w0.254: PR400.3 104.41,181.37 v3(103.98,180.94)
N19850733: length 57.1
  TOP w0.102: v3(103.98,181.85) 104.56,181.85 v1(104.79,182.08)
  TOP w0.508: v3(116.68,149.46) PQ402.1
  IN3 w0.508: v3(116.68,149.46) 112.57,149.46 111.65,150.38 111.65,151.4 109.85,153.2 107.71,153.2 100.12,160.79 100.12,162.29 97.63,164.78 97.63,168.52 98.29,169.18 98.29,171.72 97.32,172.68 97.32,174.08 98.09,174.84 98.09,182.69 99.53,184.14 101.69,184.14 v3(103.98,181.85)
  BOTTOM w0.254: v3(103.98,181.85) 103.5,181.37 PR400.2
N19850816: length 3.1
  TOP w0.102: PQ410.1 118.38,133.17 v1(118.76,132.79)
  TOP w0.254: PQ410.1 119.43,134.4 PR443.2
N19850828: length 6
  TOP w0.102: PR453.1 112.41,133.93 v1(112.69,133.64)
  TOP w0.254: PR453.1 PR450.1 PR447.2 PR448.2 112.78,137.29 113.35,137.87 PU404.7
N19850842: length 15.6
  TOP w0.102: v1(116.32,141.85) 114.88,140.41 PU404.5
  TOP w0.254: PC434.1 PR445.2 ; PR445.2 v2(112.41,142.44) ; PR445.2 PR451.1 113.22,141.31 113.22,140.6 113.41,140.41 PU404.5 ; v3(110.88,136.89) 111.36,136.41 PR447.1
  BOTTOM w0.254: v2(112.41,142.44) 112.41,137.34 111.95,136.89 v3(110.88,136.89)
N19850846: length 6.7
  TOP w0.102: PR446.2 111.95,138.64 111.15,138.64 110.8,138.99 110.8,139.06 v1(110.38,139.48)
  TOP w0.254: PU404.6 113.6,139.14 112.78,139.96 PC435.1 PR452.1 PR446.2
N19850858: length 10.7
  TOP w0.102: PR443.1 120.14,134.63 120.14,133.39 v1(119.99,133.25)
  TOP w0.254: PR440.2 PR444.1 PC431.1 121.08,137.87 PU404.2 118.36,137.87 118.08,137.58 118.08,136.61 119.57,135.11 PR443.1
N19850879: length 5.3
  TOP w0.102: PR441.2 v1(120.37,141.8)
  TOP w0.254: PR441.2 PR437.1 121.46,139.73 PC432.1 120.87,139.14 PU404.3
N19850885: length 13.3
  TOP w0.254: PU404.1 120.46,136.6 120.61,136.45 v2(120.61,135.83) 120.61,135.2 120.69,135.11 PR435.2 PC439.1 122.49,135.11 123.24,134.37 PQ409.2 ; PR437.2 122.87,140.91 v3(123.08,140.7)
  BOTTOM w0.254: v2(120.61,135.83) v1(120.61,137.98) 120.61,139.96 121.35,140.7 v3(123.08,140.7)
N19850895: length 2.4
  TOP w0.254: PR423.1 115.24,162.43 v1(115.38,162.29) 115.95,161.73 PU402.17
N19850900: length 3.8
  TOP w0.254: PU402.11 119.23,163.85 119.52,164.15 v1(119.92,164.15) 121.83,164.15 PR432.1
N19850905: length 4
  TOP w0.508: PD401.1 111.65,163.49 v1(111.65,162.77) 111.99,162.43 PR423.2 112.97,162.03 112.77,161.83 112.77,161.78 112.7,161.72 PC417.1
N19850931: length 4.3
  TOP w0.102: PR422.2 120.46,157.49 v1(120.81,157.15)
  TOP w0.254: PU402.3 118.23,158.5 118.61,158.11 119.46,158.11 119.88,157.7 PR422.2
N19905073: length 3.2
  BOTTOM w0.102: v1(59.88,36.92) PC612.1
  BOTTOM w0.508: PC612.1 PR601.2
N20025090: length 6.2
  BOTTOM w0.102: v1(62.8,30.59) 62.29,30.59 61.83,30.13 PC614.1
  BOTTOM w0.254: PC614.1 61.84,29.6 PR634.2 ; PR634.2 61.84,27.82 PR603.2 ; PR634.2 60.58,28.71 60.45,28.59 PU600.4
N20054548: length 3.4
  BOTTOM w0.102: v1(314.54,149.97) 314.18,150.33 R39.1
  BOTTOM w0.254: U17.22 313.14,151.23 313.36,151.01 R39.1
N20054658: length 3.1
  BOTTOM w0.254: U17.37 304.41,150.23 v1(303.77,149.59) 302.97,148.79 C134.1
N20054660: length 4.9
  BOTTOM w0.254: U17.35 306.23,149.01 305.34,148.12 v1(304.83,148.12) 303.88,148.12 303.15,147.39 C134.2
N20089981: length 3.5
  BOTTOM w0.254: U17.31 308.23,148.35 v1(308,148.11) 306.51,146.63 C385.1
N20133265: length 3.7
  BOTTOM w0.102: v1(50,22.31) PR620.2
  BOTTOM w0.254: PR620.2 PR618.2 50.82,24.17 PR621.1 PR619.1
N20137396: length 2.1
  BOTTOM w0.102: v1(51.37,22.3) 51.38,22.3 51.83,22.74 PR619.2
  BOTTOM w0.254: PC620.1 52.63,23.19 PR619.2
N20143338: length 2.1
  BOTTOM w0.102: v1(49.98,25.72) 50.55,25.14 PR622.2
  BOTTOM w0.254: PR622.2 PC622.1
N20194225: length 3.9
  BOTTOM w0.102: PR607.2 60.85,23.07 v1(61.05,22.87)
  BOTTOM w0.254: PR607.2 PC617.1 ; PC617.1 59.11,23.08 PR608.1 ; PC617.1 59.09,23.05 PR604.2
N20340292: length 1.9
  BOTTOM w0.102: PR611.1 v1(57.22,20.2)
  BOTTOM w0.254: PR610.2 PR611.1
N20539095: length 16.3
  BOTTOM w0.254: R153.2 297.75,156.73 297.48,156.45 297.48,153.86 297.48,153.86 297.48,153.42 297.48,153.17 296.74,152.43 v1(296.74,151.88) C412.1 297.43,147.45 298.51,147.45 299.78,148.72 Q123.2 300.42,148.72 301.19,147.95 301.24,147.95 301.26,147.94 R142.2
N20539102: length 3.9
  BOTTOM w0.102: v1(297.42,149.92) 297.42,149.93 297.98,150.49 R208.2 298.39,149.44 Q123.6 298.74,149.37 298.89,149.22 298.89,148.92 298.7,148.72 Q123.5
N21005554: length 1.5
  BOTTOM w0.102: U51.12 261.74,155.27 C409.1
N21082240: length 3.6
  TOP w0.102: U52.2 116.56,120.55 115.33,119.32 RC32.1 114.57,118.99 v1(114.33,119.23)
N21162283: length 0.9
  TOP w0.102: CC84.1 R290.2
N21214262: length 4.1
  TOP w0.102: U90.28 221.98,48.29 221.67,47.99 220.83,47.99 220.55,47.71 v1(220.39,47.71) 220.28,47.71 219.83,48.17 R2701.1
N21386608: length 5.2
  BOTTOM w0.102: v1(93.54,140.81) 93.54,141.66 D76.2 92.9,141.88 92.54,141.52 U86.4 91.73,141.52 91.05,142.2 R110.2
N21466889: length 1.5
  BOTTOM w0.102: C427.1 260.94,155.16 U51.10
N21609269: length 5.1
  TOP w0.102: v1(32.35,100.01) 32.35,100.73 RV2909.2 32.33,101.37 32.33,104.03 31.92,104.44 UV5.L8
N21618610: length 4
  BOTTOM w0.254: UV4.L8 31.52,109.9 31.52,110.47 31.06,110.93 31.06,113.09 RV2906.2
N21623176: length 4.6
  TOP w0.102: RV2907.2 33.73,85.5 v1(33.73,86.14) 33.73,86.44 32.27,87.9 32.27,88.47 31.93,88.81 UV7.L8
N21628194: length 9.2
  BOTTOM w0.102: v1(25.35,93.57) RV2908.2 26.59,94.68 27.4,95.49 31,95.49 31.46,95.03 31.46,94.22 UV6.L8
N21706833: length 2.9
  BOTTOM w0.102: PR321.1 93.71,108.36 v1(94.11,108.76)
  BOTTOM w0.254: PC304.2 92.47,107.55 92.71,107.79 PR321.1
N21706836: length 3.1
  BOTTOM w0.203: 90.76,105.59 91.04,105.3 PU301.7
  BOTTOM w0.381: PC304.1 91.06,107.09 90.64,106.67 90.64,105.7 90.76,105.59
N21711362: length 8.6
  BOTTOM w0.102: PR328.1 94.67,96.98 v1(94.67,97.45)
  BOTTOM w0.254: PL300.2 99.83,98.14 99.38,97.7 96.49,97.7 PR328.1
N21720435: length 3.2
  BOTTOM w0.102: PR155.2 v1(85.42,73.77)
  BOTTOM w0.508: PC164.1 84.73,72.87 PR155.2
N21722925: length 4.5
  BOTTOM w0.203: PC150.2 v1(77.49,69.58) 77.49,68.11 77.92,67.67 PU150.21
N21726938: length 4.5
  BOTTOM w0.203: PR157.1 83.2,71.08 v1(83.2,70.28) 83.2,68.36 82.91,68.07 PU150.2
N21828358: length 67.1
  TOP w0.102: v3(94.45,147.05) 93.06,148.45 93.06,152.84 94.93,154.72 98.11,154.72 98.38,154.45 JLVDS1.13 ; v1(130.94,120.55) 130.29,121.2 v3(129.94,121.2) LE2.2
  IN1 w0.097: v3(129.94,121.2) 129.73,120.99 125.52,120.99 124.59,121.92 117.12,121.92 114.7,124.33 107.93,124.33 98.74,133.52 98.74,138.95 95.55,142.14 95.55,144.35 95.01,144.88 95.01,146.49 v3(94.45,147.05)
N22048929: length 3.7
  BOTTOM w0.61: JMINI1.24 v1(314.3,178.36) 314.77,177.89 R233.1 R228.1
N22150023: length 6.2
  TOP w0.102: R406.1 223.54,97.83 222.88,97.17 v1(222.88,96.54) 222.88,96.07 223.4,95.55 JDEG1.9
N22201445: length 5
  BOTTOM w0.203: PU301.6 90.65,104.9 90.34,105.21
  BOTTOM w0.381: PR321.2 v1(90.14,107.18) 90.14,105.42 90.34,105.21
N22285464: length 3.4
  TOP w0.102: R2627.2 295.42,162.5 296,162.5 v1(296.23,162.72) 296.23,163.33 296.67,163.77 U83.24
N22421033: length 5
  TOP w0.102: U90.26 220.11,50.32 219.76,49.97 v1(218.52,49.97) 217.54,49.97 R2699.1
N22423064: length 2.4
  TOP w0.102: R2700.1 219.75,49.06 v1(219.92,49.22) 220.52,49.82 U90.27
N22905003: length 3
  TOP w0.254: RV2720.1 54.35,109.25 v1(54.01,108.91) 53.65,108.55 v5(53.2,108.55)
  BOTTOM w0.254: v5(53.2,108.55) 53.61,108.14 UV1.D22
N22905006: length 4.5
  TOP w0.102: v5(51.53,109.35) 51.75,109.57 v1(52.26,109.57) 52.31,109.57 52.78,110.04 54.49,110.04 RV2721.1
  BOTTOM w0.134: UV1.C24 51.93,108.95 v5(51.53,109.35)
N22905009: length 3.4
  TOP w0.102: v5(50.73,110.14) 50.84,110.25 52,110.25 RV2722.1 52.27,110.52 51.91,110.88 v1(51.29,110.88)
  BOTTOM w0.1: v5(50.73,110.14) UV1.B25
N22916336:
  vias: v1(64.25,105.8) v5(63.07,105.3) v5(63.96,105.3) v5(64.78,105.3)
N23032286: length 0.5
  BOTTOM w0.254: UV1.M6 66.87,101.48 v2(66.5,101.11)
  vias: v1(65.94,101.04)
N23032504: length 10.1
  BOTTOM w0.102: v1(60.21,116.37) 60.24,116.34 60.24,114.68 59.76,114.2 RV2442.1 60.24,113.7 60.47,113.7 61.31,112.86 61.31,112.57 62.9,110.98 63.6,110.98 64.01,110.57 64.01,109.4 UV1.C10
N23032510: length 6.2
  BOTTOM w0.102: UV1.A10 63.23,110.54 63.01,110.76 62.78,110.76 61.06,112.49 61.06,112.5 60.42,113.14 v1(60.37,113.14) 59.91,113.14 RV2441.2
N23034682: length 3.2
  TOP w0.102: v5(62.29,108.54) 61.36,108.54 v1(61.18,108.72) 61.18,109 61.59,109.41 RV2444.2
  BOTTOM w0.1: UV1.D11 62.69,108.14 v5(62.29,108.54)
N23437023: length 8.6
  TOP w0.102: v2(318.25,155.76) v1(318.82,155.76)
  IN1 w0.254: v2(318.25,155.76) 313.81,160.21 v3(313.71,160.21)
  BOTTOM w0.254: Q20.1 317.86,155.76 v2(318.25,155.76) ; v3(313.71,160.21) R152.2
N23621118: length 1.5
  BOTTOM w0.102: PR632.2 v1(44.47,41.98)
N23621189: length 3
  BOTTOM w0.102: PR631.2 52.52,35.12 v1(52.16,35.49)
  BOTTOM w0.508: PR631.2 PC627.1
N23656617: length 3.7
  TOP w0.254: PR524.1 136.13,143.27 136.44,142.96 v1(137.34,142.96) 138.19,142.96 138.41,142.74 PQ515.6
N23693397: length 4.6
  TOP w0.102: RD5.2 v1(148.88,24.63)
  TOP w0.356: v2(149.78,24.28) 149.49,24.28 148.89,23.67 148.89,23.63 RD5.2
  BOTTOM w0.356: v2(149.78,24.28) 149.18,24.88 JDIMM1.197
N23693399: length 4.5
  TOP w0.102: RD6.2 149.9,23.63 v1(150.87,22.67)
  TOP w0.356: v2(150.54,24.28) 149.89,23.63 RD6.2
  BOTTOM w0.356: JDIMM1.201 150.38,25.22 150.54,25.06 v2(150.54,24.28)
N23699971: length 3.7
  TOP w0.102: v1(223.97,28.29) 224.08,28.41 v2(224.76,28.41)
  TOP w0.356: v2(224.76,28.41) 225.03,28.69 RD10.1
  BOTTOM w0.356: v2(224.76,28.41) 224.93,28.23 224.93,27.39 224.88,27.33 JDIMM2.201
N23699973: length 7.8
  TOP w0.356: RD11.1 225.49,29.7 v3(225.9,29.3)
  BOTTOM w0.356: JDIMM2.197 223.68,29.87 224.53,30.72 225.11,30.72 225.9,29.93 v3(225.9,29.3)
N23709542: length 1.3
  BOTTOM w0.102: v1(76.89,41.34) 76.75,41.47 PC615.1
N23724597: length 3.7
  BOTTOM w0.102: U19.10 89.84,76.16 89.77,76.09 C163.1 89.97,75.83 90.64,75.83 90.95,75.53 90.95,74.94 v1(91.1,74.79)
N23724615: length 1.9
  BOTTOM w0.102: R155.2 88.87,80.1 89.04,79.92 U19.3
N23724651: length 3
  BOTTOM w0.102: v1(87.47,74.79) 87.62,74.79 C152.1 88.46,76.11 88.84,76.49 88.84,76.52 89.04,76.72 U19.12
N23729658: length 2.6
  TOP w0.102: v1(33.34,118.43) 33.34,118.42 33.01,118.09 RZ10.2 31.01,118.09 QZ5.6
N23729757: length 3.3
  TOP w0.102: RZ11.2 30.07,116.23 29.45,116.86 QZ5.3 28.27,116.86 27.75,116.34 v1(27.75,116.33)
N23729780: length 3.2
  TOP w0.102: RZ40.2 58.18,86.56 58.77,85.98 QZ21.3 59.2,85.96 58.75,85.52 v1(58.75,84.8)
N23729789: length 2.7
  TOP w0.102: QZ21.6 61.27,87.28 61.81,86.74 RZ41.2 62.49,86.04 v1(62.22,85.76)
N23819369: length 7.5
  TOP w0.254: PQ505.4 131.93,180.21 v2(132.32,180.61)
  BOTTOM w0.102: v1(133.75,181.24) 133.11,180.61 v2(132.32,180.61)
  BOTTOM w0.254: v2(132.32,180.61) 131.54,180.61 131.25,180.31 131.25,179.26 131.97,178.54 PR510.1 PC506.1
N24106181: length 6.5
  TOP w0.102: v1(143.6,138.3) 143.6,139.76 PR560.1
  TOP w0.254: PQ519.5 141.98,141.87 142.16,141.69 PR561.1 PR560.1
N24276865: length 4.2
  BOTTOM w0.102: 76.57,117.32 76.57,116.84 v1(77.35,116.06) ; 76.57,117.32 R345.1 R344.1 ; 76.57,117.32 76.12,116.87 QC8.6
N24520734: length 3.7
  TOP w0.102: v1(148.96,162.6) PD503.2
  TOP w0.254: PD503.2 147.59,162.34 146.88,161.63 PR507.2
N24520740: length 3.2
  TOP w0.102: PD503.1 147.22,160.2 v1(146.24,159.22)
  TOP w0.254: PD503.1 148.96,160.2 PQ506.6
N24520821: length 14
  TOP w0.102: v1(145.79,138.37) 145.79,140 145.47,140.32 PR564.1
  TOP w0.254: PQ515.5 v3(139.06,143.17) ; PR564.1 PR563.1 145.51,141.69 145.76,141.95 v3(145.76,143.7)
  IN1 w0.254: v3(145.76,143.7) 143.98,143.7 143.25,142.96 139.27,142.96 v3(139.06,143.17)
N24568926: length 2.1
  TOP w0.102: PU402.8 122.04,161.23 PR429.2
N24568942: length 2.3
  TOP w0.102: PR430.2 121.69,161.72 v1(121.15,161.72) 120.61,161.72 120.61,161.73 PU402.9
N24568999: length 2.5
  TOP w0.203: PU51.19 212.89,158.38 212.3,158.98 v1(212.3,159.07) 211.95,159.41 211.95,160.08 PR59.1
N24602247: length 15.3
  TOP w0.254: 140.6,142.46 PQ519.6 ; 140.6,142.46 140.34,142.2 140.34,140.31 140.12,140.09 140.12,139.27 139.84,138.99 139.84,136.73 v1(140.93,135.64) 142.4,134.17 143.2,134.17 144.28,133.09 PQ528.1 ; 140.6,142.46 140.32,142.74 PR535.1
N24704245: length 3.8
  TOP w0.102: v2(77.6,67.27) 78.42,67.27 PR150.2 78.12,66.05 v1(77.94,66.05)
  BOTTOM w0.203: PU150.20 v2(77.6,67.27)
N24714082: length 2.1
  BOTTOM w0.102: U19.5 89.84,79.51 90.19,79.86 90.19,80.12 89.86,80.45 R165.2
N24760088: length 6.3
  TOP w0.102: v1(126.2,144.64) 126.53,144.31 PQ2.3
  TOP w0.254: PR9.1 127.78,139.71 127.55,139.94 127.55,141.97 PQ2.3
N24760090: length 7
  TOP w0.254: PL3.2 124.15,144.91 v1(124.45,144.61) PQ2.1 124.45,139.33 PR10.1
N24760094: length 9.5
  TOP w0.254: PR11.2 126.91,139.02 126.53,139.4 PQ2.2 125.31,141.06 125.09,140.83 v1(125.09,139.51) 125.09,138.95 125.24,138.8 125.86,138.8 PQ3.1 126.33,138.32 126.36,138.32 PR13.1
N24793632: length 5.1
  TOP w0.254: PU405.1 129.4,133.79 129.74,134.13 PR449.2 130,134.13 v1(131.4,132.74) 132.06,132.74 PQ411.1
N24793658: length 15.6
  TOP w0.102: PQ702.3 v1(131.46,128.03)
  TOP w0.254: v3(129.63,128.82) 130.23,128.22 PQ702.3 ; PR442.1 122.08,133.13 122.24,132.97 123.12,132.97 v3(123.29,132.79) 123.82,132.79 124.34,133.31 124.34,134.53 124.83,135.02 PQ409.6
  IN1 w0.254: v3(129.63,128.82) 128.86,128.82 126.17,131.51 124.58,131.51 v3(123.29,132.79)
N24793714: length 10.9
  TOP w0.102: v3(128.31,130.28) v1(127.55,130.28)
  TOP w0.254: PQ702.5 129.58,130.33 129.39,130.52 128.55,130.52 v3(128.31,130.28) ; PU405.4 126.38,135.09 126.17,134.87 126.17,133.68 125.71,133.22 125.28,133.22 v3(124.83,132.78)
  IN1 w0.254: v3(124.83,132.78) 125.72,131.89 126.32,131.89 127.94,130.28 v3(128.31,130.28)
N24837780: length 39.1
  IN3 w0.254: v2(89.69,170.19) 91.42,171.92 91.42,183.36 93.23,185.18 102.07,185.18 104.04,183.22 107.15,183.22 107.89,183.96 110.55,183.96 PBATT2.3
  BOTTOM w0.102: PD1.3 v1(90.76,168.91)
  BOTTOM w0.254: v2(89.69,170.19) 89.69,168.92 PD1.3
N24847666: length 4.6
  TOP w0.102: v1(126.88,166.06) PD509.2
  TOP w0.254: PQ518.1 125.35,162.81 PD509.2
N24847670: length 55.7
  TOP w0.102: v1(136.81,132.99) 137.33,133.51 PQ529.1
  TOP w0.254: PQ518.2 125,160.04 v3(125.36,159.68) 125.67,159.37 PR527.2 ; PQ529.1 v3(138.13,132.63)
  BOTTOM w0.254: v3(138.13,132.63) 136.93,131.43 120.78,131.43 118.89,133.32 118.89,153.4 120.32,154.83 120.32,156.6 123.39,159.68 v3(125.36,159.68)
N24847672: length 41.6
  TOP w0.102: v3(124.04,157.57) 123.96,157.57 123.33,156.95 v1(123.33,156.45)
  TOP w0.254: PQ518.3 126.32,158.61 126.37,158.56 v3(126.37,157.49) 126.3,157.43 PR527.1 PR567.1 124.18,157.43 v3(124.04,157.57) ; PR568.1 148.71,169.47 v3(148.59,169.35)
  IN1 w0.254: v3(124.04,157.57) 124.15,157.67 124.15,159.73 125.57,161.15 125.57,162 126.9,163.33 127.62,163.33 128.56,164.27 129.62,164.27 130.61,165.26 131.24,165.26 141.34,165.26 142.9,166.83 144.19,166.83 144.58,166.43 145.67,166.43 v3(148.59,169.35)
  BOTTOM w0.254: v3(126.37,157.49) 126.29,157.57 v3(124.04,157.57)
N24847684: length 4.3
  TOP w0.102: v1(138.4,131.3) PD514.2
  TOP w0.254: PR525.2 141.15,132.86 PQ529.2 140.03,131.31 PD514.2
N24856259: length 4.2
  TOP w0.102: PD513.2 152.09,171.93 v1(152.68,172.53)
  TOP w0.254: PQ526.1 150.22,173.11 PD513.2
N24856273: length 14.5
  TOP w0.254: PR565.2 151.18,177.48 PQ526.2 150.9,176.2 149.83,175.12 148.12,175.12 v1(147.32,174.32) 146.17,173.16 146.17,170.94 148.62,168.49 PR540.1
N24856289: length 2.3
  TOP w0.102: v1(149.71,169.04) 149.53,168.86 PR540.2
  TOP w0.254: PQ527.1 149.47,167.91 PR540.2
N24856313: length 7.4
  TOP w0.102: v1(153.03,170.1) 153,170.1 152.42,169.52 PU506.4
  TOP w0.254: PU506.4 152.42,169.13 151.49,168.2 151.07,168.2 150.65,167.78 150.65,166.41 149.86,165.62 149.5,165.62 PQ527.2
N24865866: length 4.1
  TOP w0.254: PQ519.3 142.88,140.56 143.13,140.31 v1(143.13,139.61) 142.53,139.01 PR539.1 141.98,139.21 PQ519.2
N24866547: length 3.3
  TOP w0.102: v1(144.44,129.73) PQ528.2
  TOP w0.254: PR566.2 144.44,131.51 PQ528.2
N24966871: length 4.2
  TOP w0.102: PD4.2 133.56,142.93 133.02,143.47 v1(132.52,143.47)
  TOP w0.254: PD4.2 135.23,142.93 135.65,142.51 PQ1.1
N25442948: length 4.5
  TOP w0.102: U87.4 141.9,112.35 D80.2 141.76,110.79 141.77,110.79 v1(141.77,109.35)
N25461188: length 4.3
  BOTTOM w0.102: JMINI1.16 307.9,178.99 308.18,178.71 308.61,178.71 v1(309.03,178.29) 309.03,177.33 308.83,177.12 R234.1
N25461247: length 3
  BOTTOM w0.102: JMINI1.14 307.1,178.5 v1(307.28,178.32) 307.28,178.32 R236.1
N25461262: length 4
  BOTTOM w0.102: JMINI1.8 304.7,178.94 304.54,178.78 303.83,178.78 303.75,178.7 v1(303.75,177.98) R238.1
N25461295: length 2.9
  BOTTOM w0.102: JMINI1.12 v2(306.3,178.57) 306.3,177.21 R240.1
N25461301: length 2.9
  BOTTOM w0.102: R239.1 305.5,177.12 v1(305.5,178.28) JMINI1.10
N25462362: length 4
  TOP w0.102: v1(313.3,188.45) R244.2 313.07,187.36 v2(312.32,186.61)
  BOTTOM w0.102: JMINI1.19 312.3,186.64 v2(312.32,186.61)
N25462371: length 4.8
  TOP w0.102: R241.2 310.73,187.74 v2(310.51,187.97) v1(310.51,188.57)
  BOTTOM w0.102: v2(310.51,187.97) 310.51,187.31 310.89,186.93 311.34,186.93 311.5,187.09 JMINI1.17
N26045473: length 2.1
  TOP w0.102: R273.2 C319.1 v1(199.79,175)
N26045635: length 0.9
  TOP w0.102: RE4.2 CE8.1
N26045731: length 2
  TOP w0.102: v1(184.99,176) 185.14,176.14 CE9.1 RE5.2
N26176018: length 2.2
  BOTTOM w0.102: v1(13.96,110.02) 14.37,110.43 R460.2 15.26,110.43 15.47,110.64 QZ22.5
N26268990: length 3.3
  TOP w0.102: U45.5 194.01,110.42 194.12,110.53 v1(194.66,110.53) 194.95,110.53 195.33,110.15 R422.2 R421.2
N26269092: length 4.3
  TOP w0.102: U45.3 193.89,109.62 193.98,109.54 195.49,109.54 R423.2 R424.2 195.65,108.24 v1(194.86,108.24)
N27140797: length 8.3
  BOTTOM w0.102: v1(76.34,105.21) 76.05,104.91 75.15,104.91 RV2436.1 73.68,105.57 73.4,105.3 69.99,105.3 69.74,105.55 69.74,106.03 UV1.F3
N27141414: length 2.1
  TOP w0.102: v1(52.78,107.26) 53.16,106.88 v5(53.21,106.88) 53.37,107.04 RV2704.1
  BOTTOM w0.1: UV1.F22 53.63,106.47 v5(53.21,106.88)
N27141416: length 2.2
  TOP w0.102: v1(53.39,104.57) 53.59,104.37 v5(53.98,104.37) 54,104.4 RV2705.1
  BOTTOM w0.1: v5(53.98,104.37) UV1.J22
N27747674: length 4.6
  BOTTOM w0.102: JSATA1.10 221.47,120.49 v1(222.51,119.46) 223.04,118.92 R52.2
N28030709: length 3.8
  TOP w0.102: R3000.2 146.65,110.78 v1(146.35,110.78)
  TOP w0.254: U4.9 148.66,109 148.15,109.51 R3000.2
N28282435: length 3.2
  TOP w0.508: UC5.5 204.83,58.46 204.7,58.33 203.99,58.33 RC38.1 CC22.1
N28305266: length 2.5
  TOP w0.102: Q24.3 221.11,38.6 D23.1 v1(219.57,39.03)
N28834607: length 4.6
  BOTTOM w0.102: U18.3 270.49,182.49 270.39,182.59 v1(270.39,183.01) 270.39,183.65 R154.2 271.32,183.48 271.32,182.35 271.29,182.32 U18.5
N29162349: length 4.4
  BOTTOM w0.102: QC6.2 75.03,100.14 75.16,100.01 R347.1 R346.2 v1(78.9,100.01)
N29193033: length 5.4
  TOP w0.102: R319.2 183.78,130.18 184.53,130.18 184.85,129.86 v1(184.85,129.25) 185.66,128.44 186.28,128.44 186.88,127.84 186.88,127.83 187.07,127.64 U37.B18
N29201344: length 4
  TOP w0.102: v1(211.94,53.1) 212.13,53.29 RC202.1 212.47,53.87 212.47,54.47 212.3,54.65 UC5.1
N31283223: length 2.8
  TOP w0.102: U37.A62 198.16,126.39 v1(198.89,125.66) 199.34,125.21 R323.1
N31479955: length 6.5
  TOP w0.102: v2(188.15,127.58) 188.15,127.47 187.83,127.14 U37.B19 ; R321.1 183.89,129.42 v2(184.24,129.78)
  BOTTOM w0.102: v2(188.15,127.58) 188.13,127.6 186.42,127.6 v1(185.44,128.58) v2(184.24,129.78)
N35502990: length 0.6
  BOTTOM w0.102: 225.63,104.88 v1(226.22,104.88)
N48705663: length 3.6
  TOP w0.102: PQ3.2 125.22,136.86 126.06,136.02 v1(126.06,135.8)
  TOP w0.254: PR10.2 PR12.1 124.99,137.12 PQ3.2
N51701576: length 2.8
  TOP w0.102: U15.11 213.92,124.01 213.82,123.91 213.1,123.91 213.01,123.82 ; 213.01,123.82 R77.2 ; 213.01,123.82 v1(213.01,124.93)
N53734664: length 6
  TOP w0.102: U38.B61 162.2,123.14 v2(162.28,123.21) ; v2(159.2,123.91) 158.61,124.5 158.08,124.5 R381.1
  IN1 w0.097: v2(159.2,123.91) 159.24,123.96 161.53,123.96 v2(162.28,123.21)
N53866851: length 3.1
  TOP w0.102: R382.2 C363.1 175.07,129.17 173.83,129.17 v1(173.78,129.12)
N61090377: length 131.8
  TOP w0.254: R33.1 R31.1 199.3,14.33 v1(197.56,14.33) 196.39,14.33 v2(195.7,15.02) ; QD1.3 230.83,33.01 231.16,32.68 v3(231.16,31.91)
  IN2 w0.254: v2(195.7,15.02) 195.19,15.53 187.47,15.53 186.68,16.32 184.65,16.32 184.34,16.01 158.18,16.01 156.61,17.59 135.78,17.59 133.77,15.58 126.89,15.58 v3(126.64,15.84)
  BOTTOM w0.254: v3(231.16,31.91) 231.66,31.41 231.66,20.59 225.82,14.74 209.59,14.74 209.24,14.39 207.03,14.39 206.67,14.74 196.02,14.74 195.7,15.06 v2(195.7,15.02) ; R29.1 R30.1 126.18,14.06 126.64,14.52 v3(126.64,15.84)
N61399843: length 2.3
  TOP w0.102: U37.A14 189.33,130.05 v1(189.54,130.26) 189.74,130.45 R318.2
N61858263: length 2.4
  BOTTOM w0.102: R211.1 20.45,31.09 v1(20.68,30.86) 20.68,30.47 20.99,30.16 U27.26
N62014302: length 2.1
  BOTTOM w0.102: U46.12 258.62,160.86 v1(258.74,160.73) 259.64,160.73 C401.1
N62015979: length 2
  BOTTOM w0.102: C402.1 258.33,161.71 258.28,161.66 U46.10
N62018216: length 5.1
  BOTTOM w0.102: U46.5 255.16,161.66 255.11,161.71 R426.2 ; R426.2 R425.2 255.08,160.82 255.12,160.86 U46.3 ; R426.2 254.17,162.6 254.23,162.66 v1(254.23,162.83)
N62020898: length 2.7
  TOP w0.203: U45.10 v1(190.08,110.42) 189.59,109.93 C398.1
N62020976: length 5.2
  TOP w0.102: U45.12 190.75,109.62 190.52,109.38 189.98,109.38 189.58,108.98 C397.1 188.84,108.98 188.36,108.5 187.57,108.5 v1(186.96,109.1)
N62022297: length 1.7
  TOP w0.102: C390.1 167.3,102.65 166.94,103.01 U43.12
N62022948: length 3.5
  TOP w0.102: U43.3 166.94,106.01 167.28,106.34 167.28,107.48 R416.2 168.5,107.79 v1(168.55,107.83)
N62071680: length 8.7
  TOP w0.102: v2(162.37,125.23) 161.79,125.23 161.7,125.14 U38.B57 ; R349.1 158.13,129.15 v1(159.17,129.15) 159.43,129.4 160.19,129.4 v3(160.67,128.92)
  IN1 w0.097: v3(160.67,128.92) 160.67,126.94 v2(162.37,125.23)
N62078629: length 2.7
  TOP w0.102: v2(271.4,179.06) 271.38,179.04 C148.1 v1(272.38,178.23)
  BOTTOM w0.102: U18.10 271.29,179.58 271.4,179.47 v2(271.4,179.06)
N62078782: length 2.8
  TOP w0.102: v1(269.09,178.23) C147.1 v2(270.1,178.84)
  BOTTOM w0.102: U18.12 270.49,179.51 270.1,179.12 v2(270.1,178.84)
N62111964: length 4.6
  TOP w0.102: R403.2 173.31,134.38 Q12.2 174.74,134.55 v1(174.86,134.43)
N63746311: length 9.9
  TOP w0.102: v2(162.83,119.8) 162.69,119.66 U38.B2 ; R352.1 164.92,113.19 v1(165.2,113.47) v2(165.71,113.47)
  BOTTOM w0.102: v2(162.83,119.8) 162.98,119.65 162.98,117.11 163.74,116.34 163.74,115.76 165.26,114.25 165.26,113.92 v2(165.71,113.47)
N63746359: length 7.5
  TOP w0.102: v2(166.28,120.29) 165.69,119.7 U38.B8 ; v3(164.86,116.72) 164.86,115.68 R338.1
  IN3 w0.102: v2(166.28,120.29) 164.48,118.49 164.48,117.11 v3(164.86,116.72)
N64492809: length 11.5
  TOP w0.102: v2(322.01,155.26) v1(322.66,155.26)
  IN1 w0.254: v3(315.48,160.23) 319.55,156.17 319.55,155.59 320.21,154.93 321.68,154.93 v2(322.01,155.26)
  BOTTOM w0.254: Q21.3 322.01,156.15 v2(322.01,155.26) ; R157.2 v3(315.48,160.23)
N64492816: length 11.3
  TOP w0.102: v2(320.68,153.48) v1(320.68,152.9)
  IN1 w0.254: v2(320.68,153.48) 318.99,155.17 318.99,155.76 314.6,160.16 v3(314.6,160.18)
  BOTTOM w0.254: v3(314.6,160.18) R156.2 ; Q21.6 v2(320.68,153.48)
N64569940: length 0.9
  BOTTOM w0.254: C136.1 R149.2
N64569944: length 1.2
  BOTTOM w0.254: R148.2 v2(307.34,160.22) C135.1
N70882705: length 2.9
  TOP w0.102: R435.1 226.99,34.07 v1(227.42,33.64) 227.42,33.22 226.79,32.59 Q16.1
N70882773: length 141.6
  TOP w0.102: Q28.3 207.77,143.23 206.52,141.97 206.52,140.07 207.25,139.33 v3(207.92,139.33) ; v3(217.8,44.49) v1(214.24,40.93) 212.64,39.33 212.64,34.43 215.69,31.38 220.59,31.38 221.63,32.42 224.38,32.42 224.94,32.98 Q16.2
  IN1 w0.097: v3(207.92,139.33) 207.92,137.17 210.68,134.4 210.68,121.6 v3(210.81,121.47)
  IN2 w0.102: v3(210.81,121.47) 210.28,120.94 210.28,109.33 217.54,102.07 218.82,102.07 221,99.89 221,90.13 219.42,88.56 v3(219.42,85.84)
  BOTTOM w0.102: v3(219.42,85.84) 219.42,83.07 225.8,76.69 226.05,76.69 226.84,75.91 226.84,71.93 224.82,69.91 224.82,59.5 225.35,58.97 225.35,58.27 224.7,57.61 224.7,57.21 224.7,56.65 220.87,52.81 220.87,51.27 217.8,48.2 v3(217.8,44.49)
N74832224: length 5.1
  TOP w0.102: R367.1 R370.1 158.18,120.54 158.62,120.54 159.25,121.17 v1(159.25,121.53) 159.25,121.86 159.68,122.29 160.21,122.29 160.32,122.39 U38.A59

## Copper pours and planes (outline as drawn)
1.5VRUN_FB on BOTTOM (solid shape): 233.76,90.82 235.28,90.82 235.47,90.63 235.47,89.34 235.3,89.17 233.97,89.17 233.97,89.17 233.81,89.17 233.65,89.33 233.65,90.34 233.32,90.67 232.52,90.67 232.41,90.78 232.41,91.07 232.58,91.24 233.33,91.24
1.5VRUN_LX on BOTTOM (solid shape): 228.79,91.96 228.79,90.54 229.35,89.98 230.14,89.98 230.21,89.91 230.21,89.28 230.13,89.2 229.33,89.2 229.27,89.15 228.16,89.15 226.87,87.86 225.7,87.86 225.67,87.88 225.67,91.56 225.85,91.73 226.91,91.73 227.27,92.09 228.66,92.09
