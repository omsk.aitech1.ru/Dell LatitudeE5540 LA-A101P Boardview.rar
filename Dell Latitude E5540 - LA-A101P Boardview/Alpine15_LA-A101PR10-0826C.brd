# Allegro board Alpine15_LA-A101PR10-0826C.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
USB3TP0: length 163.6
  IN1 w0.097: v2(24.31,77.2) 24.5,77.38 26.18,77.38 27.4,78.6 45.08,78.6 53.35,70.33 54.57,70.33 57.11,67.79 66.25,67.79 70.9,63.15 76,63.15 81.23,57.92 94.77,57.92 96.77,59.91 96.77,62.73 101.24,67.2 101.24,69.44 103.02,71.22 103.02,71.95 105.73,74.65 112.22,74.65 115.81,78.24 116.97,78.24 119.4,80.67 125.8,80.67 126.81,81.69 127.91,81.69 128.27,82.05 129.24,82.05 131.62,84.43 134.27,84.43 138.9,89.07 138.9,89.97 139.86,90.94 140.09,90.94 140.87,91.72 143.92,91.72 146.23,89.41 146.58,89.41 v2(146.78,89.22)
  BOTTOM w0.076: 147.27,87.11 147.27,87.09 147.3,87.06 147.3,85.82 147.96,85.16 147.96,84.01 147.88,83.93 147.7,83.93 147.54,83.77 147.54,83.65 147.66,83.53 147.8,83.53 UC1.B34
  BOTTOM w0.102: v2(24.31,77.2) 24.34,77.23 25.06,77.23 25.66,77.82 25.66,78.74 25.37,79.02 24.51,79.89 23.48,79.89 C293.2 ; 147.27,87.11 147.27,89.48 147.17,89.58 147.06,89.58 146.93,89.46 146.89,89.46 146.78,89.34 v2(146.78,89.22)
USB3TP0_C: length 1.9
  BOTTOM w0.102: R250.1 20.93,80.09 L41.4 21.33,80.09 21.64,79.78 21.97,79.78 C293.1
USB3TP0_D+: length 11.1
  BOTTOM w0.102: JUSB1.9 12.81,84.03 13.15,83.69 13.57,83.69 14.14,83.12 14.59,83.12 15.29,82.42 15.29,80.1 15.68,79.72 15.97,79.72 16.11,79.86 D17.5 D17.6 18.02,79.86 18.17,79.72 18.63,79.72 19.01,80.09 L41.3 19.68,80.09 R250.2
USB3TP1: length 206.8
  TOP w0.102: v3(293.55,166.59) 293.55,166.39 293.67,166.27 293.85,166.27 C2969.1
  IN3 w0.086: v3(293.55,166.59) 293.55,166.58 293.17,166.2 291.61,166.2 288.36,162.95 271.36,162.95 264.48,156.07 255.42,156.07 250.25,150.9 250.25,150.49 250.25,147.91 244.82,142.48 235.33,142.48 232.43,139.58 230.12,139.58 228.11,137.58 220.82,137.58 218.92,135.67 213.25,135.67 211.14,133.57 211.14,132.2 207.48,128.54 207.48,120.69 199.05,112.25 197.06,112.25 195.45,110.65 192.22,110.65 190.67,112.21 188.8,112.21 188.21,111.62 182.88,111.62 177.27,106.01 174.95,106.01 174.95,106.01 174.6,106.01 170.53,101.94 163.39,101.94 163.01,102.32 155.97,102.32 155.75,102.09 151.03,102.09 149.74,100.81 145.45,100.81 144.86,100.23 144.86,99.92 v2(144.69,99.76)
  BOTTOM w0.076: 147.81,87.11 147.81,87.1 147.85,87.06 147.85,87.03 147.86,87.02 147.86,85.73 148.34,85.25 148.44,85.25 148.59,85.1 148.59,84.91 148.56,84.87 148.49,84.87 148.42,84.95 148.33,84.95 148.29,84.91 148.29,84.61 148.34,84.55 UC1.A33
  BOTTOM w0.102: v2(144.69,99.76) 144.78,99.76 144.96,99.58 144.96,99.52 145.09,99.39 145.09,99.3 144.96,99.17 144.47,99.17 143.78,98.49 v3(143.78,97.13) 143.78,93.58 146.48,90.88 147.12,90.88 147.81,90.19 147.81,87.11 ; C2969.1 294.18,166.52 293.86,166.19 293.68,166.19 293.55,166.32 v3(293.55,166.59)
USB3TP1_C: length 2.5
  TOP w0.102: U83.19 296.71,166.27 296.61,166.17 v3(296.08,166.17) 295.52,166.17 C2969.2
USB3TP1_RP: length 42.6
  TOP w0.102: v2(305.65,166.86) 305.48,166.69 304.99,166.69 R2656.2
  IN3 w0.086: v2(337.99,172.38) 337.99,172.46 338.32,172.79 338.9,172.79 339.31,172.38 339.31,171.84 338.93,171.46 335.88,171.46 334.21,169.79 310.87,169.79 307.69,166.61 305.91,166.61 v2(305.65,166.86)
  BOTTOM w0.102: JIO1.24 338.8,172.45 338.7,172.55 338.55,172.71 338.25,172.71 338.15,172.6 338.14,172.6 337.99,172.45 v2(337.99,172.38) ; v2(305.65,166.86) 305.5,166.71 304.97,166.71 R2656.2
USB3TP1_RP_C: length 2.8
  TOP w0.102: R2656.1 303.43,166.75 303.05,166.75 v3(302.68,166.38) 302.43,166.13 302.19,166.13 302.04,166.27 U83.12
USB3TP1_RP_CL: length 9.5
  BOTTOM w0.102: R2653.2 295.47,166.22 296.75,166.22 297.37,166.84 v3(300.89,166.84) 301.56,166.84 302.01,166.39 302.41,166.39 302.73,166.71 303.39,166.71 R2648.1
USB3TP4: length 135.3
  TOP w0.102: v4(189.68,165.72) 189.87,165.91 190.33,165.91 190.56,166.14 190.56,167.84 189.65,168.74 189.65,173.54 190.74,174.64 190.74,175.68 190.47,175.96 190.47,177.89 189.57,178.78 189.57,178.97 189.84,179.25 L56.1 189.87,179.84 R277.1
  BOTTOM w0.076: 149.62,87.12 149.62,87.1 149.65,87.07 149.65,85.58 150.11,85.12 150.11,84.3 150,84.19 149.85,84.19 149.75,84.29 149.75,84.51 UC1.A31
  BOTTOM w0.102: v4(189.68,165.72) 189.68,165.85 189.83,166 190.11,166 190.55,165.57 190.55,165.56 190.55,162.03 189.94,161.42 189.79,161.26 189.79,158.38 188.93,157.52 186.68,157.52 184.11,154.95 182.77,154.95 179.92,152.11 177.22,152.11 175.3,150.19 169.93,150.19 169.08,151.04 163.72,151.04 161.18,148.5 160.25,147.57 160.25,145.57 159.48,144.79 159.48,141.92 145.41,127.85 145.41,125.54 145.22,125.35 145.22,110.54 143.69,109.02 143.69,106.98 142.43,105.73 142.43,103.19 145.75,99.87 145.75,98.93 145.22,98.4 145.22,93.22 146.89,91.54 147.35,91.54 149.62,89.27 149.62,87.12
USB3TP4_D+: length 4.5
  TOP w0.102: v2(190.7,182.96) 190.66,182.96 190.45,182.75 190.45,182.73 190.15,182.42 189.69,182.42 189.53,182.26 189.53,182.13 189.84,181.81 L56.2 189.87,181.49 R277.2
  BOTTOM w0.102: JDOCK1.92 190.45,183.49 190.49,183.46 190.49,183.17 v2(190.7,182.96)
USB_DB_DET#: length 164.1
  TOP w0.102: v3(96.69,116.78) 96.69,120.15 103.62,127.09 104.3,127.09 105.11,126.28 105.11,125.56 105.91,124.76 107.64,124.76 JUDB1.20 107.66,124.76 109.08,124.76 109.57,125.25 109.57,125.97 109.41,126.12 R490.1 ; v2(194.97,129.99) 195.33,129.63 U37.A2
  IN1 w0.097: v2(194.97,129.99) 195.09,129.87 196.12,129.87 196.61,130.36 199.28,130.36 200.98,128.66 200.98,128.66 201.2,128.44 201.21,128.44 201.8,127.84 201.8,125.05 202.38,124.48 202.38,123.76 199.66,121.04 199.66,118.46 198.39,117.19 198.39,116.7 195.96,114.28 195.47,114.28 194.58,113.38 192.5,113.38 191.86,112.74 190.61,112.74 187.71,109.84 186.02,109.84 185.51,110.35 182.79,110.35 177.7,105.26 175.4,105.26 173.59,103.45 173.22,103.45 173.22,103.46 172.1,103.46 172.1,103.45 171.54,103.45 171.54,103.46 166.06,103.46 165.43,104.09 161.63,104.09 160.57,103.02 153.25,103.02 152.46,103.81 152.46,105.1 151.17,106.39 150.91,106.39 150.57,106.73 124.86,106.73 123.97,107.61 121.51,107.61 120.44,106.54 119.03,106.54 116.6,104.11 107.69,104.11 99.59,112.21 99.59,114.42 97.28,116.72 96.74,116.72 v3(96.69,116.78)
  BOTTOM w0.102: v3(96.69,116.78) 96.69,116.31 v1(96.43,116.05)
USB_DB_PWR_EN#: length 121.4
  TOP w0.102: v3(117.75,139.23) 117.75,138.31 116.17,136.74 116.17,135.83 115.63,135.28 115.63,133.18 v1(114.41,131.96) 114.22,131.77 110.83,131.77 109.83,130.77 JUDB1.8 ; v2(192.5,119.83) 192.59,119.74 U37.B44 ; R291.2 191.02,116.44 v2(191.35,116.77)
  IN1 w0.097: v3(117.75,139.23) 118,138.97 125.95,138.97 127.96,136.97 129.33,136.97 130.34,135.95 132.27,135.95 134.04,134.19 141.53,134.19 143.21,135.87 146.03,135.87 150.56,131.33 150.56,129.61 151.43,128.73 151.43,115 151.84,114.6 151.84,113.69 155.13,110.4 155.8,110.4 156.73,110.4 157.4,111.07 157.58,111.07 157.58,111.07 161.26,111.07 161.35,111.16 162.6,111.16 163.18,111.16 163.93,110.4 164.55,110.4 165.02,109.93 170.16,109.93 170.64,110.41 175.28,110.41 178.11,113.23 179.47,113.23 182.16,115.92 189.35,115.92 189.79,116.37 189.79,116.37 190.95,116.37 v2(191.35,116.77) 191.61,117.03 191.77,117.03 192.09,117.35 192.09,119.44 192.48,119.83 v2(192.5,119.83)
USB_MCARD1_DET#: length 246.9
  TOP w0.076: 171.21,79.46 170.96,79.21 169.89,79.21 v2(169.6,79.5)
  TOP w0.102: v3(321.07,181.32) 321.22,181.17 321.22,172.88 319.73,171.39 v6(319.73,167.93) 319.73,163.71 320.31,163.13 320.31,162.5 319.88,162.06 314.19,162.06 311.29,159.17 306.11,159.17 304.99,158.05 300.75,158.05 300.19,157.49 290.8,157.49 289.81,158.48 278.16,158.48 255.35,135.67 254.32,135.67 253.76,136.23 235.25,136.23 234.1,137.37 223.65,137.37 222.39,136.12 215.57,136.12 211.19,131.74 210.77,131.74 205.68,126.65 205.68,117.98 v3(205.77,117.89) ; R459.2 171.21,79.46 ; v3(198.33,125.08) 198.14,124.89 U37.A59
  IN1 w0.097: v3(205.77,117.89) 205.36,117.89 202.25,114.79 202.25,114.11 198.32,110.18 197.34,110.18 196.41,109.25 196.41,107.54 192.73,103.86 192.73,103.85 192.73,103.85 192.73,97.48 195.22,94.99 195.22,94.13 194.55,93.47 194.55,88.72 190.66,84.83 190.66,84.43 185.8,79.56 183.53,79.56 182.7,80.39 175.17,80.39 174.35,81.22 170.3,81.22 169.6,80.52 v2(169.6,79.5)
  BOTTOM w0.076: UC1.K3 167.06,78.87 167.4,78.53 168.33,78.53 168.44,78.41 169.15,78.41 169.6,78.87 v2(169.6,79.5)
  BOTTOM w0.102: v3(321.07,181.32) 320.7,180.95 JMINI1.40 ; v3(198.33,125.08) 198.97,125.08 205.77,118.29 v3(205.77,117.89)
USB_MCARD2_DET#: length 101.9
  TOP w0.102: v3(187.72,159.57) v1(188.39,159.57) ; RP5.4 183.96,126.26 184.09,126.39 v3(184.09,126.85) 184.65,127.41 185.51,127.41 186.03,126.89 U37.A18
  IN1 w0.097: v3(240.53,160.1) 237.97,162.66 232.63,162.66 232.21,162.24 227.77,162.24 227.31,162.7 218.33,162.7 216.82,161.19 204.8,161.19 202.39,163.6 189.45,163.6 187.72,161.86 v3(187.72,159.57)
  IN3 w0.102: v3(184.09,126.85) 184.09,127.82 183.77,128.14 183.77,133.85 183.2,134.42 183.2,139.13 185.41,141.34 185.41,143.8 187.65,146.04 187.65,150.73 186.98,151.4 186.43,151.95 186.43,154.56 185.82,155.17 185.82,157.11 186.63,157.92 186.63,158.48 v3(187.72,159.57)
  BOTTOM w0.102: JMINI2.40 v3(240.53,160.1)
USB_OC0#: length 258.2
  IN3 w0.076: 171.03,62.85 170.91,62.85 170.66,63.09 170.66,63.52 171.03,63.89
  IN3 w0.102: v3(190.47,62.72) 189.84,62.72 189.61,62.5 188.37,62.5 188.14,62.72 184.14,62.72 183.68,63.18 180.56,63.18 178.43,61.05 174.87,61.05 173.07,62.85 171.03,62.85 ; v2(171.59,66.72) 171.77,66.54 171.77,64.62 171.04,63.89 171.03,63.89 ; v3(220.06,73.19) 222.8,75.93 222.8,78.06 227.84,83.1 230.24,83.1 234.33,87.18 234.33,88.63 233.85,89.11 233.85,96.97 228.2,102.61 228.2,111.84 229.47,113.11 229.47,120.81 234.99,126.33 234.99,127.26 235.13,127.39 237.21,129.48 239.97,129.48 241.8,131.3 248.65,131.3 256.87,139.53 258.24,139.53 270.11,151.4 272.74,151.4 279.95,158.61 287.5,158.61 287.51,158.61 288.31,158.61 291.19,158.61 292.51,159.93 294.07,159.93 295.73,161.6 303.23,161.6 303.8,162.17 307.64,162.17 309.57,164.1 314.95,164.1 317.87,167.02 331.21,167.02 v3(333.14,165.09)
  BOTTOM w0.076: UC1.AL3 167.08,67.32 167.61,67.32 167.81,67.52 167.81,67.65 168.03,67.87 168.27,67.87 168.45,67.69 169.3,67.69 169.69,67.31 170.31,67.31 170.57,67.05
  BOTTOM w0.102: v3(333.14,165.09) 334.09,164.13 334.32,164.13 335,163.45 JIO1.59 ; v2(171.59,66.72) 170.9,66.72 170.57,67.05 ; RP14.6 192.3,63.03 192.12,62.85 190.59,62.85 v3(190.47,62.72) 190.41,62.67 190.41,61.78 191.82,60.37 196.78,60.37 197.91,61.51 198.1,61.51 198.1,61.51 202.06,61.51 202.06,61.51 202.24,61.51 202.37,61.38 202.47,61.28 207.83,61.28 208.54,61.99 208.54,63.76 209.07,64.28 209.07,64.43 211.32,66.69 213.74,66.69 214.32,67.27 214.32,69 v1(217.07,71.75) 218.51,73.19 v3(220.06,73.19)
USB_OC1#: length 306.6
  TOP w0.102: v1(119.22,131.52) 119.88,131.52 v3(119.88,131.52)
  IN2 w0.102: v3(180.38,68.21) 182.72,70.55 184.12,70.55 184.95,71.39 189.05,71.39 189.55,71.89 189.55,85.74 189.12,86.17 189.12,88.53 187.6,90.05 184.19,90.05 182.98,91.26 182.98,98.27 182.64,98.61 182.64,99.59 179.17,103.06 179.17,104.94 178.2,105.92 175.96,105.92 171.71,110.17 168.84,110.17 167.94,111.07 167.94,111.93 166.74,113.12 166.74,113.52 165.29,114.97 158.17,114.97 157.01,113.82 154.83,113.82 154.32,114.32 154.32,115.8 151.55,118.57 151.55,120.58 151.72,120.75 151.72,125.96 148.18,129.5 132.95,129.5 129.59,126.15 129.18,126.15 128.27,127.06 128.27,128.45 125.66,131.06 122.28,131.06 122.27,131.05 121.52,131.05 121.23,131.34 120.06,131.34 v3(119.88,131.52) 119.7,131.34 111.61,131.34 108.49,128.22 105.68,128.22 105.11,127.65 100.82,127.65 100.36,128.1 100.36,130.16 99.73,130.8 98.68,130.8 94.3,126.42 v3(94.3,119.04)
  IN3 w0.076: 171.03,63.24 v2(171.02,63.24)
  IN3 w0.102: v3(94.3,119.04) 81.11,119.04 78.77,116.7 68.37,116.7 67.36,117.7 52.28,117.7 48,113.42 25.28,113.42 23.31,111.45 23.31,95.72 22.44,94.86 22.44,76.94 22.25,76.75 v3(22.25,76.75) ; 171.03,63.24 173.08,63.24 175.05,61.28 178.32,61.28 180.64,63.59 180.64,65.55 180.58,65.6 180.58,66.89 180.18,67.3 180.18,68.01 v3(180.38,68.21)
  BOTTOM w0.076: 170.77,63.59 170.49,63.87 168.97,63.87 168.28,64.56 UC1.AT1
  BOTTOM w0.102: v3(180.38,68.21) 181.3,69.13 181.3,69.61 182.83,71.14 182.83,72.06 RP3.1 ; 170.77,63.59 170.77,63.49 v2(171.02,63.24) ; US1.5 v3(22.25,76.75)
USB_OC2#: length 177.6
  TOP w0.102: v3(130.2,130.63) 130.01,130.82 121.99,130.82 121.76,131.05 110.7,131.05 109.92,130.27 JUDB1.9
  IN2 w0.102: v2(176.19,69.46) 176.32,69.46 176.39,69.53 178.38,69.53 180.17,67.74 180.17,67.3 180.39,67.08 181.13,67.08 181.41,67.36 181.41,68.92 182.81,70.32 184.21,70.32 185.05,71.16 189.14,71.16 189.78,71.8 189.78,85.84 189.35,86.27 189.35,88.63 187.46,90.51 184.06,90.51 183.21,91.36 183.21,98.37 182.87,98.71 182.87,99.69 179.4,103.16 179.4,105.03 178.28,106.16 176.05,106.16 171.81,110.4 168.95,110.4 168.16,111.19 168.16,112.03 166.97,113.22 166.97,113.62 165.39,115.2 158.04,115.2 156.89,114.04 154.93,114.04 154.55,114.43 154.55,115.94 151.98,118.5 151.98,120.69 152.15,120.86 152.15,125.86 148.28,129.73 131.11,129.73 v3(130.2,130.63)
  IN3 w0.102: v3(190.06,63.51) 189.88,63.69 183.51,63.69 181.52,65.68 181.52,67.88 180.79,68.62 178.76,68.62 178.28,69.1 176.55,69.1 v2(176.19,69.46)
  BOTTOM w0.076: 170.78,69.56 170.63,69.56 170.32,69.25 168.61,69.25 168.33,69.54 167.94,69.54 167.71,69.3 167.7,69.3 UC1.AH2
  BOTTOM w0.102: RP14.7 192.04,63.53 191.61,63.11 190.63,63.11 190.38,63.36 190.22,63.36 v3(190.06,63.51) ; v2(176.19,69.46) 175.99,69.46 175.61,69.84 174.06,69.84 v1(173.75,69.53) 173.29,69.07 171.85,69.07 171.36,69.56 170.78,69.56
USB_OC3#: length 266.6
  TOP w0.102: RP13.3 183.43,59.22 183.15,59.5 183.15,59.83 182.97,60.01 182.97,60.68 182.82,60.83 182.32,60.83 v2(181.93,60.44)
  IN2 w0.102: v3(189.18,62.93) 188.37,62.93 186.95,61.51 182.59,61.51 181.93,60.84 v2(181.93,60.44)
  IN3 w0.102: v2(337.4,165.1) 336.71,164.4 330.19,164.4 328.16,166.43 318.07,166.43 315.04,163.4 312.73,163.4 311.04,161.71 303.99,161.71 303.42,161.14 295.92,161.14 294.26,159.47 292.7,159.47 291.38,158.15 288.49,158.15 280.17,158.15 272.96,150.94 270.29,150.94 253.54,134.19 252.16,134.19 249.04,131.08 241.89,131.08 240.06,129.25 237.3,129.25 235.22,127.16 235.22,126.24 229.71,120.73 229.71,113.03 228.43,111.75 228.43,102.84 234.14,97.13 234.14,89.15 234.56,88.72 234.56,86.96 230.37,82.76 227.83,82.76 223.31,78.24 223.31,76.01 221.43,74.13 221.43,73.54 v3(220.56,72.68)
  BOTTOM w0.076: 170.78,61.51 169.76,61.51 168.36,62.91 167.34,62.91 167.01,63.25 UC1.AV3
  BOTTOM w0.102: v2(181.93,60.44) 181.93,60.54 181.63,60.84 180.71,60.84 180.36,60.49 178.73,60.49 178.53,60.29 175.71,60.29 175.53,60.11 v6(174.41,60.11) 174.23,60.29 172.74,60.29 171.52,61.51 170.78,61.51 ; JIO1.58 338.55,163.95 v2(337.4,165.1) ; v3(189.18,62.93) 189.84,62.93 189.92,62.85 189.92,61.67 191.58,60.01 195.06,60.01 195.2,60.15 196.88,60.15 198.01,61.28 202.15,61.28 202.38,61.05 207.38,61.05 208.79,59.64 209.35,59.64 210.93,58.06 211.16,58.06 211.22,58 214.19,58 214.6,58.41 214.95,58.41 216.09,59.54 216.63,59.54 217.01,59.92 217.01,64.53 216.12,65.42 215.61,65.42 215.15,65.87 215.15,67.27 v3(220.56,72.68)
USB_PWR_SHR_EN#: length 209.9
  TOP w0.102: R391.2 189.12,137.02 189.37,137.27 v3(189.42,137.27) 193.28,137.27 194.99,135.57 206.32,135.57 207.46,136.71 210.77,136.71 212.65,138.59 235.25,138.59 235.74,138.1 255.42,138.1 280.46,163.14 280.46,164.48 285.51,169.53 290.08,169.53 293.16,172.61 304.86,172.61 306.17,173.93 316.37,173.93 v3(318.46,176.01) ; v3(191.15,126.78) 191.59,127.22 U37.B10
  IN3 w0.102: v3(189.42,137.27) 189.96,136.74 189.96,134.56 189.25,133.84 189.25,129.86 191.37,127.74 191.37,127 v3(191.15,126.78)
  BOTTOM w0.102: JIO1.60 340.72,163.45 341,163.17 342.7,163.17 342.99,163.46 342.99,170.29 343.08,170.38 343.08,179.68 341.77,180.99 334.69,180.99 v1(333.44,179.74) 328.87,175.17 319.29,175.17 v3(318.46,176.01)
USB_PWR_SHR_VBUS_EN#: length 174.4
  TOP w0.102: U37.B50 195.59,119.62 v2(195.37,119.83) ; v2(200.79,120.61) 201.19,120.61 R302.2 202.03,119.76 203.48,119.76 205.45,121.73 205.45,126.74 210.67,131.96 211.1,131.96 215.48,136.34 222.29,136.34 223.55,137.6 234.24,137.6 235.27,136.57 253.88,136.57 254.55,135.9 255.25,135.9 278.06,158.71 289.91,158.71 290.9,157.72 300.09,157.72 300.7,158.33 303.44,158.33 303.95,158.84 305.01,158.84 305.56,159.4 311.2,159.4 314.5,162.7 v3(319.81,162.7)
  IN3 w0.102: v3(336.9,162.57) 334.74,162.57 v3(334.1,163.21) ; v2(195.37,119.83) 195.37,119.43 196.74,118.06 200.36,118.06 201.44,119.14 201.44,119.96 v2(200.79,120.61)
  BOTTOM w0.102: v3(319.81,162.7) 322.01,164.9 v1(331.03,164.9) 332,164.9 333.7,163.21 v3(334.1,163.21) ; v3(336.9,162.57) 337.27,162.95 JIO1.62
USB_SIDE_EN#: length 251.5
  TOP w0.102: U37.A33 188.33,117.98 187.98,117.62 187.98,117.28 188.1,117.16 R288.2 188.66,115.51 188.66,114.17 189.09,113.74 190.34,113.74 v3(190.77,114.17)
  IN1 w0.097: v3(190.77,114.17) 190.77,114.16 189.28,112.68 183.85,112.68 177.33,106.16 173.52,106.16 171.85,104.48 168.47,104.48 167.98,104.98 161.25,104.98 160.87,104.61 154.24,104.61 151.57,107.28 151.28,107.28 150.11,108.45 148.42,108.45 147.6,107.64 125.83,107.64 123.47,109.99 119.18,109.99 116.26,107.07 116.26,106.51 115.06,105.31 108.47,105.31 105.4,108.38 105.4,119.12 102.12,122.4 82.27,122.4 80.28,120.41 79.02,120.41 74.36,115.75 74.36,98.61 72.66,96.91 72.66,96.11 74.56,94.22 74.56,94.21 74.59,94.18 74.59,91.06 75.04,90.61 75.04,86.97 68.93,80.86 61.65,80.86 60.46,82.05 v3(60.46,82.18)
  IN2 w0.102: v3(60.46,82.18) 58.25,84.39 51.23,84.39 48.96,82.12 48.96,74 45.51,70.55 35.83,70.55 33.14,67.86 v3(25.29,67.86)
  BOTTOM w0.102: v3(25.29,67.86) 24.84,67.41 22.94,67.41 22.25,68.1 v1(22.25,69.29) US1.4
USB_SIDE_EN_IOR#: length 187.3
  TOP w0.102: U37.B11 191.08,127.95 191.28,127.75 191.28,127.29 191.18,127.19 190.98,127.19 190.74,126.95 190.74,126.61 190.98,126.38 191.88,126.38 v2(192.32,126.82) ; v3(190.26,116.86) 190.14,116.73 R295.2
  IN2 w0.102: v3(190.26,116.86) 190.88,116.86 191.28,117.26 191.28,125.77 v2(192.32,126.82) 192.33,126.82 192.74,127.23 192.74,128.9 191.94,129.7 191.94,130.75 193.95,132.75 v3(193.95,133.51)
  BOTTOM w0.102: v3(193.95,133.51) 195.89,135.46 209.29,135.46 210,136.17 211.92,136.17 215.2,139.44 231.23,139.44 232.32,138.35 232.32,137.08 232.74,136.66 239.85,136.66 243.86,140.68 262.92,140.68 272.45,150.21 281.31,150.21 285.01,153.91 291.68,153.91 292.57,154.8 292.57,159.91 295.92,163.25 296.05,163.38 306.11,163.38 307.56,164.83 315.05,164.83 317.67,162.22 320.11,162.22 322.16,164.27 v1(328.51,164.27) 331.84,164.27 333.31,162.8 334.76,162.8 334.91,162.95 JIO1.61
USBP0+: length 281.2
  IN1 w0.076: v2(163.39,66.61) 163.11,66.61 163.01,66.72 162.63,66.72 162.3,66.39 162.3,63.38 163.83,61.85 167.59,61.85 167.86,61.58 167.86,61.27 167.84,61.24 167.84,61.23
  IN1 w0.097: 167.84,61.23 167.84,59.72 168.14,59.42 168.14,55.87 170.19,53.81 174.43,53.81 177.06,51.19 198.21,51.19 201.51,54.49 202.43,54.49 207.87,59.94 207.87,73.73 206.26,75.34 205.93,75.67 205.93,85.65 206.19,85.9 206.19,102.27 206.45,102.53 206.45,103.22 208.26,105.03 213.44,105.03 225.85,117.44 225.85,127.67 230.34,132.16 231.27,132.16 236.98,137.88 260.59,137.88 277.73,155.02 277.8,155.02 277.8,155.03 278.14,155.03 278.14,155.02 289.26,155.02 297.32,163.08 306.59,163.08 307.45,163.94 331.65,163.94 332.17,164.45 339.11,164.45 341.63,166.97 341.63,169.28 342.16,169.82 342.16,170.02 v2(342.36,170.22)
  BOTTOM w0.076: UC1.AM8 163.58,66.8 v2(163.39,66.61)
  BOTTOM w0.102: v2(342.36,170.22) 342.23,170.34 342.23,170.93 341.85,171.31 340.76,171.31 340.62,171.45 JIO1.28
USBP0-: length 281.1
  IN1 w0.076: v2(163.44,65.83) 163.44,66.05 162.94,66.55 162.7,66.55 162.46,66.32 162.46,63.45 163.9,62.01 167.66,62.01 168.02,61.64 168.02,61.27 168.05,61.24 168.05,61.23
  IN1 w0.097: 168.05,61.23 168.05,59.81 168.35,59.51 168.35,55.95 170.28,54.02 174.52,54.02 177.14,51.4 198.12,51.4 201.43,54.71 202.34,54.71 207.66,60.02 207.66,73.64 206.05,75.25 205.72,75.58 205.72,85.73 205.98,85.99 205.98,102.36 206.24,102.62 206.24,103.31 208.18,105.24 213.36,105.24 225.64,117.52 225.64,127.76 230.25,132.37 231.18,132.37 236.77,137.96 236.9,138.09 260.5,138.09 277.52,155.11 277.64,155.23 277.71,155.23 277.71,155.24 278.22,155.24 278.23,155.23 289.17,155.23 297.23,163.29 306.51,163.29 307.36,164.15 331.56,164.15 332.08,164.66 339.02,164.66 341.42,167.06 341.42,169.37 341.95,169.91 341.95,170.12 341.86,170.22 v2(341.4,170.22)
  BOTTOM w0.076: UC1.AN8 163.77,66.15 v2(163.44,65.83)
  BOTTOM w0.102: v2(341.4,170.22) 341.79,170.22 342.01,170.44 342.01,170.84 341.76,171.09 340.76,171.09 340.62,170.95 JIO1.30
USBP1+: length 178.7
  TOP w0.102: R249.1 22.26,80.29 L42.4 22.67,80.37 22.96,80.67 23.9,80.67 26.27,78.31 30.56,78.31 32.5,76.37 42.33,66.53 42.88,65.99 49.87,65.99 v2(50.06,65.8)
  IN1 w0.076: 158.48,68.23 158.49,68.22 158.54,68.22 158.56,68.2 158.57,68.2 158.85,67.92 160.89,67.92 161.07,68.1 161.89,68.1 162.2,67.79 162.2,67.22 162.5,66.92 163.13,66.92 163.23,67.03 164.1,67.03 164.26,66.87 164.26,65.36 164.43,65.19 164.58,65.19 v2(164.82,64.94)
  IN1 w0.097: 158.48,68.23 157.97,68.74 157.02,68.74 156.59,69.17 156.59,70.14 155.02,71.71 147.62,71.71 146.9,71 135.58,71 134.64,71.94 133.2,71.94 132.32,72.82 132.32,75.53 131.83,76.03 126.36,76.03 126.26,76.14 121.53,76.14 120.54,75.15 119.76,75.15 117.97,73.36 117.18,73.36 114.32,70.5 107.45,70.5 105.31,68.35 105.31,60.87 96.69,52.25 80.11,52.25 73.5,58.86 70.19,58.86 64.06,64.99 54.63,64.99 53.63,65.99 50.24,65.99 v2(50.06,65.8)
  BOTTOM w0.076: UC1.AT7 164.4,64.53 v2(164.82,64.94)
USBP1-: length 178.7
  TOP w0.102: R251.1 22.26,81.31 L42.1 22.61,81.22 22.95,80.89 23.99,80.89 26.36,78.52 30.65,78.52 42.97,66.2 49.87,66.2 v2(50.06,66.39)
  IN1 w0.076: 158.63,68.38 158.92,68.08 160.82,68.08 161,68.27 161.96,68.27 162.37,67.86 162.37,67.28 162.57,67.09 163.06,67.09 163.16,67.19 164.17,67.19 164.42,66.94 164.42,65.43 164.5,65.35 164.58,65.35 v2(164.82,65.59)
  IN1 w0.097: v2(50.06,66.39) 50.24,66.2 53.71,66.2 54.71,65.2 64.18,65.2 64.19,65.19 64.19,65.16 70.28,59.07 73.59,59.07 80.19,52.46 96.6,52.46 105.1,60.95 105.1,68.44 107.36,70.71 114.23,70.71 117.09,73.57 117.88,73.57 119.67,75.36 120.46,75.36 121.44,76.35 126.34,76.35 126.45,76.24 131.92,76.24 132.54,75.62 132.54,72.9 133.29,72.15 134.72,72.15 135.66,71.21 146.81,71.21 147.53,71.92 155.1,71.92 156.8,70.23 156.8,69.25 157.1,68.95 158.06,68.95 158.63,68.38
  BOTTOM w0.076: UC1.AR7 v2(164.82,65.59)
USBP1_R_D+: length 9.8
  TOP w0.102: R249.2 20.95,80.37 L42.3 20.39,80.37 20.07,80.69 19.85,80.69 19.73,80.58 19.73,80 19.6,79.87 D18.2 18.68,80.62 18.62,80.68 18.11,80.68 17.22,79.79 15.77,79.79 15.04,80.52 14.53,80.52 14.31,80.3 JUSB1.3
USBP1_R_D-: length 9.8
  TOP w0.102: JUSB1.2 14.31,80.91 14.49,80.73 15.13,80.73 15.86,80 17.13,80 18.02,80.89 18.53,80.89 18.68,81.04 D18.3 19.53,81.8 19.73,81.59 19.73,81.02 19.85,80.91 20.07,80.91 20.39,81.22 L42.2 20.95,81.22 R251.2
USBP2+: length 56.3
  TOP w0.102: v2(156.73,88.38) 156.57,88.54 156.29,88.54 155.85,88.99 155.85,89.81 155.83,89.83 155.83,90.36 155.85,90.37 155.85,92.49 155.58,92.76 155.58,96.44 152.38,99.64 152.38,100.71 151.11,101.98 151.11,106.55 150.06,107.6 150.06,108.15 U4.1
  IN3 w0.086: v2(163.44,65.22) 163.44,64.93 163.57,64.8 163.79,64.8 164.07,65.09 164.07,67.65 162.83,68.89 162.83,69.53 162.93,69.63 162.93,72.2 160.59,74.54 160.59,75.15 158.92,76.82 156.83,76.82 156.55,76.54 155.44,76.54 155.03,76.95 155.03,79.46 154.88,79.61 154.88,82.16 155.97,83.25 155.97,84.41 156.16,84.6 156.16,85.8 157.27,86.91 157.27,88.48 157.07,88.69 156.84,88.69 156.73,88.58 v2(156.73,88.38)
  BOTTOM w0.076: v2(163.44,65.22) 163.72,65.5 UC1.AP8
USBP2-: length 56.3
  TOP w0.102: v2(156.71,89.06) 156.71,88.89 156.58,88.76 156.38,88.76 156.06,89.08 v3(156.06,90.09) 156.06,92.58 155.79,92.85 155.79,96.53 152.59,99.73 152.59,100.8 151.32,102.07 151.32,106.64 150.27,107.69 150.27,108.04 150.46,108.22 U4.2
  IN3 w0.086: v2(156.71,89.06) 156.91,88.86 157.19,88.86 157.45,88.61 157.45,86.83 156.34,85.73 156.34,84.53 156.15,84.34 156.15,83.17 155.06,82.08 155.06,79.68 155.2,79.54 155.2,77.03 155.51,76.72 156.48,76.72 156.76,77 158.99,77 160.77,75.22 160.77,74.61 163.11,72.27 163.11,69.56 163.01,69.46 163.01,68.97 164.25,67.72 164.25,65.01 163.87,64.63 163.72,64.63 163.59,64.5 v2(163.59,64.44)
  BOTTOM w0.076: UC1.AR8 163.59,64.61 v2(163.59,64.44)
USBP4+: length 290.1
  IN1 w0.097: v2(342.18,164.5) 342.18,163.92 341.87,163.61 340.44,163.61 340.29,163.77 332.45,163.77 331.84,163.16 307.98,163.16 306.22,161.4 296.71,161.4 287.87,152.56 278.19,152.56 254.44,128.82 233.92,128.82 231.15,126.04 231.15,125.82 227.7,122.38 227.7,114.74 226.3,113.35 226.3,97.88 224.78,96.35 224.78,95.38 224.15,94.75 222.48,94.75 221.71,93.99 221.71,85.49 224.78,82.42 224.78,66.56 224.18,65.96 221.87,63.65 221.87,60.51 216.82,55.46 213.1,55.46 210.85,53.21 210.85,52.15 211.75,51.24 211.75,49.35 206.96,44.56 177.66,44.56 166.61,55.61 166.61,56.71 165.89,57.43 165.89,57.47 165.89,57.47 165.57,57.79 164.9,57.79 162.2,60.49 162.2,61.24 162,61.44 161.21,61.44 158.93,63.72 158.93,66.8 159.2,67.07 159.4,67.07 v2(159.55,67.22)
  BOTTOM w0.076: UC1.AL15 160,67.31 159.91,67.22 v2(159.55,67.22)
  BOTTOM w0.102: JIO1.52 340.65,165.45 340.66,165.44 341.82,165.44 342.13,165.14 342.13,164.55 v2(342.18,164.5)
USBP4-: length 290.1
  IN1 w0.097: v2(341.47,164.5) 341.63,164.5 341.97,164.17 341.97,164.01 341.79,163.82 340.53,163.82 340.38,163.98 332.36,163.98 331.75,163.37 307.9,163.37 306.14,161.61 296.62,161.61 287.79,152.77 278.1,152.77 254.35,129.03 233.84,129.03 230.94,126.13 230.94,125.91 227.49,122.46 227.49,114.83 226.09,113.43 226.09,97.96 224.57,96.44 224.57,95.47 224.06,94.96 222.39,94.96 221.5,94.07 221.5,85.4 224.57,82.33 224.57,66.65 224.1,66.17 224.09,66.17 221.66,63.73 221.66,60.6 216.73,55.67 213.01,55.67 210.63,53.29 210.63,52.06 211.54,51.16 211.54,49.44 206.87,44.77 177.74,44.77 166.82,55.7 166.82,56.81 165.65,57.97 164.97,57.97 162.41,60.54 162.41,61.33 162.08,61.65 161.3,61.65 159.14,63.81 159.14,66.72 159.26,66.84 159.64,66.84 159.78,66.7 159.78,66.56 159.6,66.38 v2(159.55,66.38)
  BOTTOM w0.076: UC1.AM15 159.58,66.38 v2(159.55,66.38)
  BOTTOM w0.102: JIO1.54 340.57,164.95 340.85,165.23 341.73,165.23 341.91,165.05 341.91,164.78 341.63,164.5 v2(341.47,164.5)
USBP5+: length 180.5
  IN3 w0.076: v2(160.99,66.71) 160.8,66.9 160.5,66.9 159.81,67.6 159.05,67.6 158.62,68.02 158.54,68.02
  IN3 w0.086: 158.54,68.02 158.32,68.02 157.52,68.82 156.97,68.82 156.44,69.35 155.31,69.35 155.14,69.18 154.01,69.18 153.79,68.96 153.32,68.96 152.87,69.41 152.87,69.89 152.87,69.96 152.14,70.7 144.74,70.7 143.65,69.61 131.01,69.61 130.45,69.05 123.51,69.05 119.23,64.77 119.23,64.51 118.68,63.97 118.3,63.97 v3(118.1,63.77)
  BOTTOM w0.076: v2(160.99,66.71) 160.8,66.71 UC1.AN13
  BOTTOM w0.102: v3(118.1,63.77) 118.1,63.85 117.95,64.01 117.66,64.01 117.33,64.34 117.33,67.61 115.9,69.04 113.74,69.04 110.1,72.68 110.1,75.69 106.61,79.18 106.61,82.49 105.38,83.72 105.38,86.87 108.52,90.02 125.52,90.02 126.84,91.34 126.84,93.69 127.52,94.37 127.52,104.37 120.22,111.67 114.75,111.67 112.77,113.65 112.77,114.9 111.9,115.76 111.9,117.41 107.65,121.66 107.65,124.51 105.49,126.67 105.49,131.6 105.97,132.08 105.97,154 105.13,154.84 104.75,154.84 104.46,154.55 L52.1 103.43,154.55 R2579.1
USBP5-: length 180.5
  IN3 w0.076: 158.54,68.2 158.55,68.2 158.56,68.19 158.61,68.19 158.61,68.19 158.69,68.19 159.12,67.76 159.88,67.76 160.57,67.07 160.71,67.07 v2(161,67.36)
  IN3 w0.086: v4(118.1,64.4) 118.36,64.14 118.61,64.14 119.06,64.59 119.06,64.84 123.44,69.23 130.37,69.23 130.93,69.79 143.58,69.79 144.67,70.88 152.21,70.88 153.05,70.04 153.05,69.89 153.05,69.48 153.39,69.14 153.72,69.14 153.94,69.35 155.06,69.35 155.24,69.53 156.51,69.53 157.04,69 157.59,69 158.39,68.2 158.54,68.2
  BOTTOM w0.076: v2(161,67.36) 160.77,67.13 UC1.AM13
  BOTTOM w0.102: v4(118.1,64.4) 117.92,64.22 117.75,64.22 117.54,64.43 117.54,67.7 115.99,69.26 113.83,69.26 110.32,72.77 110.32,75.78 106.82,79.27 106.82,82.58 105.59,83.81 105.59,86.78 108.61,89.8 125.61,89.8 127.05,91.25 127.05,93.6 127.74,94.28 127.74,104.46 120.31,111.89 114.84,111.89 112.98,113.74 112.98,114.98 112.12,115.85 112.12,117.5 107.86,121.75 107.86,124.6 105.71,126.76 105.71,131.51 106.19,131.99 106.19,154.09 105.22,155.06 104.75,155.06 104.4,155.4 L52.4 103.43,155.4 R2580.1
USBP5_D+: length 6.3
  TOP w0.102: v4(101.24,154.6) 100.98,154.85 100.74,154.85 100.51,155.07 100.51,156.09 100.5,156.11 100.5,156.68 100.51,156.69 100.51,157.48 100.4,157.59 100.07,157.59 99.93,157.45 JLVDS1.7
  BOTTOM w0.102: v4(101.24,154.6) 101.5,154.86 101.6,154.86 101.91,154.55 L52.2 102.35,154.55 R2579.2
USBP5_D-: length 6.2
  TOP w0.102: v3(101.24,155.23) 101.07,155.07 100.83,155.07 100.73,155.16 v3(100.73,156.34) 100.73,157.57 100.49,157.81 100.07,157.81 99.93,157.95 JLVDS1.6
  BOTTOM w0.102: R2580.2 102.35,155.4 L52.3 101.91,155.4 101.59,155.08 101.39,155.08 v3(101.24,155.23)
USBP6+: length 185.3
  IN3 w0.076: v2(161.48,65.92) 161.48,65.75 161.61,65.62 161.84,65.62 161.98,65.76 161.98,67.91 161.66,68.24 159.48,68.24 159.13,68.58 159.13,69.18 159.19,69.24 159.19,69.59 158.73,70.05 158.56,70.05 158.55,70.04 158.54,70.04
  IN3 w0.086: v2(116.5,72.05) 116.55,72.05 116.83,71.76 116.83,71.64 117.06,71.41 117.76,71.41 118.95,70.22 128.05,70.22 128.58,70.75 129.38,70.75 130.34,71.71 152.77,71.71 154.09,70.4 156.51,70.4 156.86,70.04 158.54,70.04
  BOTTOM w0.076: v2(161.48,65.92) 161.62,65.78 161.97,65.78 162.04,65.85 162.04,66.03 UC1.AN11
  BOTTOM w0.102: v2(116.5,72.05) 116.54,72.05 116.87,71.72 116.87,71.55 116.69,71.37 114.63,71.37 114.62,71.39 114.09,71.39 114.07,71.37 113.08,71.37 111.02,73.44 111.02,76.24 108.91,78.34 108.91,81.48 106.51,83.88 106.51,86.55 109.06,89.1 127.23,89.1 127.75,89.62 127.75,92.92 128.44,93.61 128.44,104.77 120.6,112.61 116.04,112.61 115.74,112.91 115.74,115.53 110.89,120.38 110.89,122.63 107.5,126.02 107.5,126.72 107.04,127.18 107.04,129.36 106.92,129.47 106.92,154.6 104.87,156.65 102.52,156.65 101.55,157.62 99.91,157.62 99.69,157.85 99.69,158.1 100.01,158.42 L58.4 100.01,159.39 R2594.1
USBP6-: length 185.3
  IN3 w0.076: 158.54,70.22 158.79,70.22 159.35,69.65 159.35,69.17 159.3,69.12 159.3,68.65 159.55,68.4 161.73,68.4 162.14,67.98 162.14,65.69 161.91,65.45 161.65,65.45 v2(161.48,65.28)
  IN3 w0.086: v2(117.08,72.05) 117.01,71.97 117.01,71.71 117.14,71.59 117.83,71.59 119.02,70.4 127.98,70.4 128.51,70.93 129.31,70.93 130.27,71.89 152.85,71.89 154.17,70.57 156.58,70.57 156.93,70.22 158.54,70.22
  BOTTOM w0.076: v2(161.48,65.28) 161.7,65.5 UC1.AP11
  BOTTOM w0.102: R2588.1 99.16,159.39 L58.1 99.16,158.44 99.47,158.13 99.47,157.76 99.83,157.4 101.46,157.4 102.43,156.44 104.78,156.44 106.71,154.51 106.71,129.38 106.82,129.27 106.82,127.09 107.28,126.63 107.28,125.93 110.67,122.54 110.67,120.29 115.52,115.44 115.52,112.83 115.95,112.39 120.51,112.39 128.22,104.69 128.22,93.7 127.54,93.01 127.54,89.71 127.14,89.32 108.97,89.32 106.29,86.64 106.29,83.79 108.7,81.39 108.7,78.25 110.8,76.15 110.8,73.35 112.99,71.16 v3(114.35,71.16) 116.78,71.16 117.08,71.46 v2(117.08,72.05)
USBP6_D+: length 11.6
  TOP w0.102: v2(100.22,166.81) 100.12,166.91 100.12,168.19 99.88,168.43 99.57,168.43 99.31,168.69 JTS1.3
  BOTTOM w0.102: v2(100.22,166.81) 100.04,166.64 100.04,166.03 100.49,165.58 100.49,164.15 99.69,163.35 99.69,162.95 99.94,162.7 D88.2 99.74,161.89 99.74,161.28 100.01,161 L58.3 100.01,160.47 R2594.2
USBP6_D-: length 11.5
  TOP w0.102: JTS1.2 99.26,167.89 99.58,168.21 99.79,168.21 99.9,168.1 99.9,167.09 99.62,166.81 v2(99.56,166.81)
  BOTTOM w0.102: R2588.2 99.16,160.47 L58.2 99.16,160.88 99.52,161.24 99.52,161.8 D88.3 99.25,162.7 99.47,162.91 99.47,163.44 100.27,164.24 100.27,165.49 99.83,165.94 99.83,166.64 99.65,166.81 v2(99.56,166.81)
USBP7+: length 71.1
  TOP w0.102: v4(211.29,44.84) 211.29,45.5 211.59,45.8 213.64,45.8 213.66,45.78 214.19,45.78 214.2,45.8 216.42,45.8 216.81,45.41 L72.1 217.64,45.41 R2694.1
  IN3 w0.076: v2(160.96,66.15) 160.77,65.96 160.47,65.96 160.18,65.66 160.18,64.83 160.17,64.82 160.17,64.81
  IN3 w0.086: v4(211.29,44.84) 210.98,44.84 210.94,44.81 210.37,44.81 209.46,45.71 209.46,45.93 204.19,51.21 204.19,51.4 201.89,53.71 194.76,53.71 193.87,54.6 191.72,54.6 191.34,54.22 183.66,54.22 183.29,53.84 178.77,53.84 176.52,56.09 172,56.09 171.47,56.63 168.01,56.63 165.37,59.27 164.63,59.27 164.06,59.84 164.06,60.86 161.38,63.54 160.78,63.54 160.17,64.15 160.17,64.81
  BOTTOM w0.076: v2(160.96,66.15) 160.64,65.83 UC1.AP13
USBP7+_D: length 7.6
  TOP w0.102: R2694.2 218.85,45.41 L72.2 219.36,45.41 219.52,45.58 220.24,45.58 220.96,46.3 221.87,46.3 221.99,46.19 222.8,46.19 223.38,46.77 v3(223.38,47.34) 223.38,48.11 223.48,48.2 U90.31
USBP7-: length 71
  TOP w0.102: R2697.1 217.64,46.26 L72.4 216.82,46.26 216.57,46.01 v3(213.92,46.01) 211.5,46.01 210.91,45.43 v3(210.71,45.43)
  IN3 w0.076: v2(160.96,65.5) 160.96,65.74 160.9,65.8 160.54,65.8 160.34,65.59 160.34,64.83 160.35,64.82 160.35,64.81
  IN3 w0.086: v3(210.71,45.43) 210.81,45.43 210.99,45.25 210.99,45.1 210.87,44.99 210.44,44.99 209.64,45.79 209.64,46.01 204.37,51.28 204.37,51.47 201.96,53.88 194.83,53.88 193.94,54.77 191.64,54.77 191.26,54.39 183.59,54.39 183.22,54.02 178.84,54.02 176.59,56.27 172.07,56.27 171.54,56.8 168.09,56.8 165.44,59.45 164.7,59.45 164.24,59.91 164.24,60.93 161.45,63.71 160.85,63.71 160.35,64.22 160.35,64.81
  BOTTOM w0.076: v2(160.96,65.5) 160.64,65.18 UC1.AR13
USBP7-_D: length 7.6
  TOP w0.102: R2697.2 218.85,46.26 L72.3 219.37,46.26 219.55,46.09 219.55,45.88 219.63,45.79 220.12,45.79 220.84,46.52 221.12,46.52 221.14,46.53 v3(221.39,46.53) 221.71,46.53 221.72,46.52 221.96,46.52 222.08,46.4 222.71,46.4 223.17,46.86 223.17,48.12 223.11,48.18 223.06,48.18 222.98,48.26 U90.30
USBRBIAS: length 12.5
  TOP w0.076: RC159.1 160.37,60.64 159.15,61.86 v1(159.15,62.39) 159.15,66.48 159.53,66.86 159.7,66.86 160.56,67.73 161.43,67.73 v2(161.46,67.7)
  BOTTOM w0.076: UC1.AJ10 162.22,68.16 161.95,68.16 UC1.AJ11 161.68,67.92 v2(161.46,67.7)
USH_SMBCLK: length 130.9
  TOP w0.102: U38.A50 160.31,126.89 v2(160.03,127.17) ; v3(186.63,89.04) 187.28,88.39 190.72,88.39 193.97,85.14 195.61,85.14 196.85,83.9 196.85,79.05 197.76,78.14 199.76,78.14 201.78,76.12 207.23,76.12 208.01,75.34 213.26,75.34 219.7,68.9 219.7,68.79 219.7,59.52 218.48,58.3 218.48,57.17 218.71,56.93 218.71,55.95 218.24,55.48 218.24,54.53 218.06,54.35 QC4.6 ; v2(160.19,131.68) 160.01,131.86 159.73,131.86 v3(159.11,132.48) 158.15,133.45 157.14,133.45 156.82,133.76 156.82,134 R491.2
  BOTTOM w0.102: v3(186.63,89.04) 186.88,89.29 186.88,89.5 186.74,89.65 183.35,89.65 178.68,94.32 176.53,94.32 171.19,99.66 171.19,101.36 165.95,106.6 165.95,107.79 165.59,108.15 159.89,108.15 158.33,109.71 158.33,110.77 160.16,112.6 160.16,112.61 160.16,117.77 160.75,118.35 160.75,121.85 160.95,122.05 160.95,126.5 160.28,127.17 v2(160.03,127.17) 160.22,127.37 160.82,127.37 161.18,127.72 161.18,131.76 161.05,131.89 160.39,131.89 v2(160.19,131.68)
USH_SMBDAT: length 128.2
  TOP w0.102: QC4.3 219.34,55.65 218.94,56.04 218.94,57.03 218.71,57.26 218.71,58.2 219.93,59.42 219.93,68.7 219.93,68.99 213.35,75.57 208.11,75.57 207.32,76.35 201.87,76.35 199.86,78.37 197.86,78.37 197.08,79.15 197.08,83.99 195.7,85.37 194.07,85.37 190.81,88.62 187.68,88.62 v4(187.27,89.04) ; v2(162.31,127) 162.17,127.14 U38.B53 ; R492.2 157.05,134.06 157.05,133.85 157.23,133.67 158.24,133.67 159.83,132.09 160.01,132.09 v2(160.19,132.26)
  BOTTOM w0.102: v2(160.19,132.26) 160.33,132.12 161.15,132.12 161.41,131.86 161.41,127.88 162.29,127 v2(162.31,127) 162.17,126.86 161.64,126.86 161.18,126.4 161.18,121.96 161.05,121.82 160.98,121.75 160.98,118.26 160.39,117.67 160.39,112.7 160.39,112.51 158.56,110.68 158.56,109.81 159.99,108.38 165.68,108.38 166.18,107.88 166.18,106.69 171.42,101.46 171.42,99.76 176.62,94.55 178.77,94.55 183.45,89.88 186.83,89.88 187.11,89.6 187.11,89.19 v4(187.27,89.04)
USX2064_RBIAS: length 3.2
  TOP w0.254: U90.35 225.48,48.06 v1(226.28,47.26)
  TOP w0.508: v1(226.28,47.26) 226.66,46.87 R2689.1
USX_SCL: length 9.5
  TOP w0.102: QC4.1 219.11,54.35 218.52,53.76 216.93,53.76 216.63,53.45 v1(216.63,53.08) R2692.1 216.7,51.9 217.82,51.9 R2696.2 218.33,51.9 218.65,51.9 218.86,51.7 219.07,51.49 219.68,51.49 219.85,51.32 U90.24
USX_SDA: length 11.3
  TOP w0.102: v3(220.21,56.04) 220.56,55.69 220.56,54.65 220.23,54.32 220.23,52.47 220.38,52.32 U90.22 ; v3(218.2,56.28) 218.2,56.55 217.97,56.78 R2698.2 216.53,56.78 v1(216.42,56.68) R2693.1 216.58,55.54 216.69,55.65 QC4.4
  IN3 w0.102: v3(220.21,56.04) 219.98,56.28 v3(218.2,56.28)
V_SYS: length 75.9
  TOP w0.102: v3(158.46,137.35) 156.99,137.35 153.37,133.72 153.37,129.34 151.83,127.8 151.83,124.98 v1(152.21,124.6) 152.31,124.5 153.91,124.5 154.04,124.37 154.55,124.37 155.06,124.88 R381.2
  TOP w0.254: PU402.7 120.51,160.73 120.87,160.36 121.93,160.36 PC424.1 121.6,159.98 121.6,159.98 121.1,159.48 v2(121.1,159.47)
  IN1 w0.097: v3(158.46,137.35) 157.99,137.35 153.36,141.99 150.82,141.99 148.85,143.96 148.19,143.96 146.8,145.35 138.14,145.35 135.32,148.17 125.09,148.17 120.72,152.54 120.72,152.57 120.7,152.59 120.7,156.44 120.7,156.44 120.7,157.12 120.72,157.14 120.72,159.09 v2(121.1,159.47)
VCI_IN2#: length 9.7
  TOP w0.102: v3(163.31,120.64) 163.47,120.79 163.47,121.3 162.62,122.14 U38.B63 ; RP17.4 161.57,116.66 161.28,116.95 v3(161.28,117.21)
  IN1 w0.097: v3(161.28,117.21) 161.28,119.95 161.56,120.23 162.29,120.23 162.37,120.16 162.68,120.16 162.76,120.23 163.11,120.23 163.31,120.43 v3(163.31,120.64)
VCP: length 78.1
  TOP w0.102: v2(167.4,116.87) 167.94,117.41 U38.A12
  TOP w0.254: v3(123,142.51) 123,141.97 122.83,141.8 PR441.1 122.38,142.35 v1(121.94,142.79) 121.28,142.79 120.92,142.43 119.52,142.43 119.24,142.71 PR402.1 119.11,143.2 PU403.1 116.33,143.2 116.08,143.45 116.08,144.28 116.27,144.47 PU403.2
  IN1 w0.097: v3(123,142.51) 129.01,142.51 129.85,141.66 133.6,141.66 135.19,140.07 135.19,139.34 136.24,138.29 137.81,138.29 138.37,138.85 141.57,138.85 142.69,139.97 150,139.97 157.53,132.44 157.53,132.43 157.53,126.53 157.2,126.19 157.2,125.92 157.2,125.74 157.2,125.55 157.2,123.63 157.66,123.17 157.66,122.94 157.66,122.94 157.66,122.68 159.01,121.33 159.01,121.01 159.51,120.5 159.51,118.39 161.1,116.8 161.45,116.8 162.57,117.93 166.58,117.93 166.92,117.59 166.92,117.35 v2(167.4,116.87)
VCP_1: length 3.5
  TOP w0.254: PR404.2 PR405.1 119.24,145.63 v1(119.09,145.78) 118.52,145.78 118.5,145.77 118.5,145.77 118.48,145.74 PU403.3
VCT_LAN_R1: length 4.4
  TOP w0.102: v1(196.92,143.13) 196.92,143.34 197.42,143.85 R175.2 197.86,144.29 198.06,144.49 198.58,144.49 198.95,144.85 198.95,145.43 198.91,145.47 U21.6
VFB: length 4
  BOTTOM w0.203: PU300.24 86.75,88.92 86.88,88.8 87.71,88.8 v1(88.18,89.28) 88.29,89.38 88.29,89.96 88.56,90.23 88.99,90.23 PR334.2
VGA_DET: length 7.3
  TOP w0.102: R74.2 188.49,158.15 v1(188.04,157.71) 186.58,156.24 U6.M3
VGA_ID: length 7.4
  TOP w0.102: R320.2 R317.1 199.41,126.15 v3(199.13,126.43) ; v3(195.81,123.14) 195.81,123.14 U37.B59
  IN3 w0.102: v3(199.13,126.43) 198.84,126.43 196.65,124.24 196.65,123.95 195.85,123.14 v3(195.81,123.14)
VGA_IREF: length 3.7
  TOP w0.102: U6.M5 183.27,158.03 183.56,158.03 184.06,157.52 v1(185.11,157.52) R2705.1
VIDALERT_N: length 62.9
  TOP w0.102: v3(95.21,81.8) 96.31,82.89 102.68,82.89 103.11,82.46 103.38,82.46 103.51,82.33 105.17,80.67 105.17,78.39 110.48,73.08 110.48,70.91 110.92,70.47 113.99,70.47 115.43,71.92 115.43,73.11 v2(116.22,73.9)
  BOTTOM w0.102: v2(116.22,73.9) 116.17,73.95 116.17,74.59 116.7,75.11 RC244.2 118.02,75.11 118.27,75.36 120.8,75.36 121.22,75.78 122.92,75.78 124.02,76.87 RC248.2 ; v3(95.21,81.8) 94.45,82.56 86.91,82.56 85.87,81.52 v6(83.15,81.52) 82.11,81.52 81.5,82.13 81.5,86.85 82.31,87.66 82.69,87.66 82.88,87.85 PU300.32
VIDSCLK: length 67.6
  TOP w0.102: v2(116.71,74.28) 116.71,74.2 116.78,74.13 116.78,73.34 115.99,72.55 115.99,71.69 114.22,69.91 110.68,69.91 109.88,70.71 109.88,72.89 104.61,78.16 104.61,80.43 103.15,81.9 100.6,81.9 99.66,80.96 97.63,80.96 v3(96.79,81.8)
  BOTTOM w0.089: UC1.N63 128.43,77.37 127.4,76.34 126.55,76.34
  BOTTOM w0.102: v2(116.71,74.28) 116.97,74.54 117.57,74.54 117.72,74.68 120.91,74.68 121.45,75.22 123.16,75.22 124.27,76.34 126.55,76.34 ; PU300.31 83.28,87.68 82.56,86.96 PR331.2 82.44,86.02 82.06,85.64 82.06,82.36 82.34,82.08 v6(85.23,82.08) 85.64,82.08 86.68,83.12 95.47,83.12 v3(96.79,81.8)
VIDSOUT: length 72.4
  TOP w0.102: v3(120.42,75.93) 120.42,75.45 119.78,74.8 115.83,74.8 114.87,73.85 114.87,72.5 113.4,71.03 111.39,71.03 111.04,71.39 111.04,73.32 105.76,78.6 105.76,79.06 105.76,80.93 104.54,82.15 104.54,82.53 103.21,83.86 101.75,83.86 101.42,83.53 96.15,83.53 94.66,82.03 94.66,82.03 v3(94.4,81.77)
  BOTTOM w0.076: UC1.L63 127.91,78.12 127.47,77.68 127.09,77.68
  BOTTOM w0.102: RC249.2 120.11,76.25 v3(120.42,75.93) 120.92,76.43 122.72,76.43 123.98,77.68 127.09,77.68 ; v3(94.4,81.77) 94.17,82 87.14,82 86.1,80.96 v6(81.14,80.96) 80.08,82.03 80.08,85.84 80.25,86.02 PR330.2 80.79,86.94 81.61,87.76 81.61,88.64 81.89,88.92 PU300.1
VMM2310_BLU: length 10.6
  TOP w0.102: U6.M8 182.92,159.49 183.13,159.7 184.06,159.7 184.6,160.23 184.6,160.57 185.49,161.45 R351.1 v3(186.07,162.37)
  BOTTOM w0.102: U39.5 186.73,166.06 186.91,165.87 v1(186.91,165.49) 186.91,163.21 v3(186.07,162.37)
VMM2310_CLK_DDC2: length 12.1
  TOP w0.102: v5(183.35,157.54) 183.06,157.25 182.5,157.25 U6.L4
  BOTTOM w0.102: v5(183.35,157.54) 183.35,158.77 183.1,159.02 183.1,162.06 183.71,162.67 v1(183.71,165.95) 184.73,166.97 U39.10
VMM2310_DAT_DDC2: length 12.1
  TOP w0.102: v5(183.81,157.21) 183.63,157.03 182.93,157.03 U6.M4
  BOTTOM w0.102: U39.9 185.13,166.96 185.03,166.86 v1(185.03,165.72) 184.12,164.81 184.12,162.57 183.45,161.91 183.45,159.17 183.81,158.81 v5(183.81,157.21)
VMM2310_GRN: length 11.9
  TOP w0.102: v3(186.07,160.79) R312.1 185.61,160.06 v1(185.12,159.57) 184.65,159.09 183.04,159.09 U6.M7
  BOTTOM w0.102: U39.2 187.92,166.38 187.6,166.05 187.6,162.32 v3(186.07,160.79)
VMM2310_HSYNC: length 9.4
  TOP w0.102: U6.M9 182.87,160.06 183.74,160.06 v3(183.9,160.22)
  BOTTOM w0.102: U39.6 186.33,165.8 186.17,165.65 186.17,164.55 185.23,163.61 185.23,161.55 v1(184.93,161.25) v3(183.9,160.22)
VMM2310_RED: length 13.1
  TOP w0.102: v3(186.03,159.33) 186.07,159.29 R311.1 185.89,158.48 183.08,158.48 U6.M6
  BOTTOM w0.102: v3(186.03,159.33) 188.2,161.5 188.2,164.74 188.32,164.86 v1(188.32,166.15) U39.1
VMM2310_VSYNC: length 9.4
  TOP w0.102: U6.L9 182.43,160.44 183.48,160.44 v5(183.89,160.84)
  BOTTOM w0.102: v5(183.89,160.84) 184.83,161.78 v1(184.83,163.14) 184.83,163.94 185.69,164.81 185.69,165.72 185.92,165.96 U39.7
VMM_DPB_CTRLCLK: length 43.8
  TOP w0.102: v3(183.25,171.77) 183.89,171.13 183.89,170.02 184.42,169.49 184.42,169.33 184.56,169.18 RP6.1 184.83,169.04 184.83,167.93 v3(184.29,167.4) 183.91,167.02 183.91,166.35 183.66,166.09 183.66,165.54 181.83,163.71 181.83,163.08 U6.K13 ; U11.12 v3(160.77,162.55)
  IN3 w0.102: v3(183.25,171.77) 183.63,171.39 183.63,170.24 183.02,169.63 178.53,169.63 176.69,171.47 166.02,171.47 162.35,167.8 162.35,167.4 161.33,166.38 161.33,163.11 v3(160.77,162.55)
VMM_DPB_CTRLDAT: length 43.6
  TOP w0.102: U6.L14 182.06,163.47 182.06,163.62 v3(183.54,165.1) 183.89,165.44 183.89,166 184.14,166.25 184.14,166.92 185.06,167.84 185.06,169.05 RP6.2 185.19,169.5 185,169.69 184.54,169.69 184.12,170.12 184.12,171.51 v3(183.89,171.74) ; U11.9 162.72,162.67 v3(162.54,162.49)
  IN3 w0.102: v3(162.54,162.49) 162.54,162.76 162.35,162.95 161.74,162.95 161.56,163.13 161.56,166.29 162.58,167.3 162.58,167.71 166.11,171.24 176.59,171.24 178.43,169.4 183.12,169.4 183.89,170.17 v3(183.89,171.74)
VMM_DPC_CTRLCLK: length 12.5
  TOP w0.102: R49.1 171.77,163.58 v3(172.36,163) 172.43,162.93 v1(172.9,162.93) 175.02,162.93 175.53,162.42 175.96,162.42 U6.B12 ; U13.12 166.35,162.93 v3(166.72,162.57)
  IN3 w0.102: v3(172.36,163) 167.6,163 167.17,162.57 v3(166.72,162.57)
VMM_DPC_CTRLDAT: length 12.5
  TOP w0.102: U13.9 168.3,162.28 v3(168.32,162.27) ; R46.1 172.09,162.63 v3(172.36,162.37) 172.62,162.63 v1(174.15,162.63) 174.94,162.63 175.48,162.09 U6.A12
  IN3 w0.102: v3(168.32,162.27) 168.11,162.06 167.58,162.06 167.45,162.19 167.45,162.53 167.7,162.77 171.91,162.77 172.32,162.37 v3(172.36,162.37)
VMM_GPIO6: length 27.5
  TOP w0.102: v3(176.19,152.97) 176.22,153 176.22,153.76 176.94,154.48 U6.C1 ; RP6.3 185.69,167.75 184.62,166.69 v2(184.62,166.03)
  IN2 w0.102: v2(184.62,166.03) 185,166.03 185.61,165.42 185.61,163.6 185.31,163.3 185.31,161.71 185.47,161.55 185.47,155.67 184.01,154.22 177.44,154.22 v3(176.19,152.97)
VMM_GPIO7: length 9.1
  TOP w0.102: RP6.4 v1(186.19,167.69) 185.06,166.56 185.06,165.79 183.46,164.2 183.14,164.2 182.43,163.48 182.43,162.33 182.66,162.09 U6.M12
VMM_GPIO8: length 5
  TOP w0.102: U6.M13 183.04,162.5 184.78,162.5 185.06,162.77 v1(186.45,162.77) 186.96,162.77 R54.1
VMM_GPIO09: length 7.5
  TOP w0.102: v1(169.69,156.5) 169.46,156.73 169.46,157.21 169.75,157.5 171.14,157.5 R232.1 172.79,158.03 173.07,157.75 175.44,157.75 U6.A5
VMM_MESCL: length 6.3
  TOP w0.102: U6.B5 v5(175.96,157.22) ; R40.1 172.2,158.91 172.38,159.09 v3(172.69,159.09)
  IN3 w0.102: v3(172.69,159.09) 172.86,159.27 173.07,159.27 173.22,159.12 173.22,158.18 173.65,157.75 175.44,157.75 v5(175.96,157.22)
VMM_MESDA: length 6.2
  TOP w0.102: R42.1 172.3,159.84 172.38,159.75 v2(172.69,159.75) ; U6.B6 v5(175.96,157.87)
  IN3 w0.102: v2(172.69,159.75) 172.94,159.5 173.17,159.5 173.45,159.22 173.45,158.27 173.75,157.97 175.86,157.97 v5(175.96,157.87)
VMM_SPI_CLK: length 17.7
  TOP w0.102: U6.B3 176.26,156.24 175.94,155.92 174.91,155.92 v3(174.54,156.28) ; v3(168.32,153.73) 168.32,153.61 v1(167.97,153.26) 167.48,152.77 164.91,152.77 164.33,152.18 U7.6
  IN3 w0.102: v3(168.32,153.73) 173.05,153.73 174.54,155.23 v3(174.54,156.28)
VMM_SPI_CS#: length 17.8
  TOP w0.102: U7.1 167.02,149.64 167.48,150.1 R64.2 169.24,150.1 169.64,150.49 169.64,151.42 v1(170.07,151.85) 170.07,154.16 169.51,154.72 v3(168.82,154.72) ; v5(175.2,157.26) 175.57,156.89 U6.A4
  IN3 w0.102: v5(175.2,157.26) 174.34,157.26 173.96,156.88 173.96,155.59 172.94,154.57 168.98,154.57 v3(168.82,154.72)
VMM_SPI_DIN: length 13.2
  TOP w0.102: U7.2 167.82,150.91 v1(168.23,151.33) 168.47,151.56 v3(168.47,152.13) ; U6.B4 v5(175.96,156.57)
  IN3 w0.102: v3(168.47,152.13) 169.26,152.13 169.94,152.82 173.14,152.82 175.96,155.64 v5(175.96,156.57)
VMM_SPI_DO: length 18.1
  TOP w0.102: v3(175.17,156.42) 175.36,156.24 U6.A3 ; v3(164.25,153.53) 163.95,153.22 162.17,153.22 161.94,153.45 U7.5
  IN3 w0.102: v3(164.25,153.53) 165.24,152.54 169.23,152.54 169.74,153.05 173.05,153.05 175.17,155.17 v3(175.17,156.42)
  BOTTOM w0.102: v3(164.25,153.53) v1(164.96,153.53)
VMM_SPI_HOLD: length 3.3
  TOP w0.102: v1(159.4,153) R65.2 160.49,150.91 U7.7
VMM_SPI_WP#: length 20.8
  TOP w0.102: U6.B1 176.29,154.82 175.45,153.99 v3(175.33,153.99) ; v3(165.07,149.57) 165.07,151.65 165.6,152.18 U7.3 167.58,152.18 168.02,152.63 168.85,152.63 v1(169.59,153.36)
  IN3 w0.102: v3(175.33,153.99) 173.68,152.34 170.14,152.34 169.46,151.65 168.72,151.65 166.64,149.57 v3(165.07,149.57)
VOL_DOWN#: length 121.2
  TOP w0.102: v3(157.14,135.98) 155.95,135.98 153.8,133.83 v1(153.8,132.7) 153.8,131.93 156.15,129.58 R349.2 ; JMED1.2 94.94,180.25 94.12,179.44 94.12,174.8 90.34,171.02 90.34,165.39 89.27,164.32 89.27,158.69 89.41,158.55 89.65,158.3 v2(89.65,158.05)
  TOP w0.254: v2(140.63,139.86) 140.63,138.73 R360.2
  IN1 w0.097: v2(89.65,158.05) 90.25,157.45 90.83,157.45 92.17,156.11 98.21,156.11 100.16,158.06 105.31,158.06 107.19,156.18 107.65,156.18 112.64,151.19 112.64,151.19 120.88,142.95 129.11,142.95 129.94,142.12 136.72,142.12 138.28,140.56 139.49,140.56 140.19,139.86 v2(140.63,139.86) 141.14,140.37 141.8,140.37 142.36,140.93 143.78,140.93 144.8,141.95 149.01,141.95 150.15,140.81 152.31,140.81 v3(157.14,135.98)
VOL_MUTE#: length 141.5
  TOP w0.102: JMED1.3 94.94,179.75 94.38,179.18 94.38,174.73 90.61,170.95 90.61,164.96 v1(90.08,164.43) 89.5,163.85 89.5,158.78 90.06,158.22 90.06,157.42 89.73,157.09 v3(89.73,155.66) ; R358.2 R352.2 165.19,111.9 165.81,111.9 v3(166,111.71)
  IN1 w0.097: v3(89.73,155.66) 90.24,155.15 98.8,155.15 99.89,156.25 103.29,156.25 103.8,155.74 104.41,155.74 118.17,141.98 118.17,141.01 119.37,139.81 129.76,139.81 132.2,137.37 134.33,137.37 135.68,136.03 141.74,136.03 143.8,138.09 146.22,138.09 151.96,132.35 151.96,130.4 153.49,128.87 153.49,125.71 152.83,125.05 152.83,116.89 153.83,115.89 153.83,114.46 155.12,113.17 158.54,113.17 158.66,113.3 160.28,113.3 160.86,112.72 161.95,112.72 163.83,112.72 164.51,112.03 165.67,112.03 v3(166,111.71)
VOL_UP#: length 141.8
  TOP w0.102: R338.2 165.24,114.41 R362.2 164.23,115.43 v2(164.23,116.7) ; v3(89.42,146.44) 89.42,150.76 89.31,150.87 89.31,157.53 89.04,157.8 89.04,164.77 90.1,165.82 90.1,171.13 93.84,174.88 93.84,179.54 95.05,180.75 JMED1.1 100.48,180.75 v1(101.08,181.35)
  IN1 w0.097: v3(89.42,146.44) 97.17,138.7 97.17,133.57 101.88,128.86 101.88,126.67 113.83,114.72 135.57,114.72 v3(138.07,112.23)
  IN3 w0.102: v3(138.07,112.23) 138.44,112.6 139.75,112.6 140.45,111.9 143.72,111.9 144.19,112.37 146.8,112.37 147.33,112.9 148.63,112.9 148.86,113.13 148.86,113.35 149.44,113.93 157.42,113.93 158.94,115.45 162.98,115.45 v2(164.23,116.7)
VR_EN: length 17.9
  TOP w0.076: v2(131.13,81.54) 130.67,81.08 127.75,81.08
  TOP w0.102: v2(116.6,79.39) 116.83,79.39 117.33,79.88 119.13,79.88 119.85,80.61 124.9,80.61 125.37,81.08 127.75,81.08
  BOTTOM w0.076: v2(131.13,81.54) 131.13,81.53 131.46,81.2 UC1.F60
  BOTTOM w0.102: RC246.2 116.48,80.33 v1(116.6,80.2) 116.6,79.39 v2(116.6,79.39)
VR_HOT#: length 2.6
  BOTTOM w0.203: PR326.1 83.44,86.02 83.23,86.24 v1(83.23,87.01) 83.68,87.46 PU300.30
VR_READY: length 15.4
  BOTTOM w0.076: 129.35,85.99 130.47,85.99 131.73,84.73 131.73,84.15 131.95,83.93 131.95,83.78 132.11,83.62 132.11,83.38 UC1.C59
  BOTTOM w0.102: 129.35,85.99 128.48,86.85 125.64,86.85 124.91,86.12 v1(122.24,86.12) 121.81,86.12 121.5,85.81 121.5,84.82 121.3,84.62 RC247.2
VREF: length 57.8
  IN1 w0.254: v2(93.92,108.04) 91.13,108.04 89.93,106.84 89.93,102.02 89.04,101.13 83.58,101.13 82.12,99.67 v2(82.12,97.25) 82.12,96.57 81.3,95.74 79.04,95.74 77.64,94.35 77.64,92.16 78.88,90.92 78.88,86.81 80.56,85.13 84.83,85.13 86.53,86.83 v2(87.33,86.83)
  BOTTOM w0.203: 85.74,86.83 84.88,87.69 PU300.27
  BOTTOM w0.254: PH300.1 v2(93.92,108.04) ; 85.74,86.83 85.79,86.78 86.91,86.78 86.97,86.83 v2(87.33,86.83) PC309.1 88.09,86.2 PR322.2 PR300.1 ; PR302.1 82.31,97.07 v2(82.12,97.25) 81.93,97.45 v1(80,97.45) 79.64,97.09 PR303.1 79.64,95.93 PR304.1
