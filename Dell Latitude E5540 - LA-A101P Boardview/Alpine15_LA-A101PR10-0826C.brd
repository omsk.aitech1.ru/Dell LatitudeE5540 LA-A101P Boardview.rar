# Allegro board Alpine15_LA-A101PR10-0826C.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SD_UHS2_D1N: length 5.6
  BOTTOM w0.089: R337.1 26.81,32.84 L48.4 26.81,32.49 26.59,32.27 26.59,31.86 26.18,31.46 v1(26.04,31.46) 24.65,31.46 23.9,30.7 23.9,30.36 23.79,30.26 U27.33
SD_UHS2_D1N_D: length 42.9
  IN3 w0.089: v3(26.79,35.75) 26.56,35.98 26.56,36.95 5.6,57.91 5.6,61.6 5.92,61.91 6.32,61.91 v2(6.77,61.45)
  BOTTOM w0.089: v3(26.79,35.75) 26.6,35.56 26.6,35.23 26.81,35.01 L48.3 26.81,34.18 R337.2 ; v2(6.77,61.45) 6.38,61.85 5.75,61.85 5.41,62.19 5.41,64 5.05,64.36 JSD1.15
SD_UHS2_D1P: length 5.6
  BOTTOM w0.089: R333.1 25.96,32.84 L48.1 25.96,32.44 26.19,32.22 26.19,32.03 26.02,31.85 24.49,31.85 v1(24.13,31.49) 23.5,30.86 23.5,30.52 23.4,30.42 23.4,30.28 23.39,30.27 U27.32
SD_UHS2_D1P_D: length 42.9
  IN3 w0.089: v2(6.8,62.75) 6.29,62.24 5.78,62.24 5.27,61.73 5.27,57.77 26.23,36.82 26.23,35.95 v3(26,35.72)
  BOTTOM w0.089: v2(6.8,62.75) 6.29,62.24 5.91,62.24 5.8,62.35 5.8,63.95 6.15,64.3 JSD1.16 ; R333.2 25.96,34.18 L48.2 25.96,35.01 26.2,35.25 26.2,35.52 v3(26,35.72)
SDWP: length 41.6
  IN1 w0.097: v2(18.91,26.93) 19.11,26.93 21.41,29.23 21.66,29.23 23.49,31.05 23.49,35.16 22.54,36.11 22.54,48.67 v2(23.71,49.85)
  BOTTOM w0.102: JSD1.19 28.77,59.2 28.63,59.33 26.18,59.33 23.71,56.87 v2(23.71,49.85) ; v2(18.91,26.93) 19.18,27.2 U27.20
SIO_EXT_SCI#: length 87.6
  TOP w0.102: RC199.1 174.77,96.25 v1(174.34,95.82) 173.85,95.82 v2(173.7,95.97) ; v2(170.18,129.86) 169.94,129.63 U38.A33
  IN2 w0.102: v2(173.7,95.97) 173.7,95.69 171.87,93.86 171.87,90.61 169.64,88.38 169.64,81.59 167.02,78.98 167.02,78.4 166.57,77.94 166.05,77.94 165.85,77.74 v2(165.69,77.74)
  BOTTOM w0.076: UC1.N5 165.51,77.56 v2(165.69,77.74)
  BOTTOM w0.102: v2(173.7,95.97) 173.7,96.33 170.63,99.4 170.63,101.24 168.78,103.08 166.62,103.08 164.03,105.68 163.75,105.68 161.78,107.66 159.71,107.66 157.45,109.92 157.45,110.57 158.27,111.39 159.68,112.8 159.68,117.77 159.38,118.07 159.38,122.62 160.47,123.71 160.47,126.1 159.85,126.72 159.77,126.72 159.53,126.96 159.53,132.87 160.76,134.1 162.11,134.1 162.7,133.5 162.7,132.9 163.49,132.12 169.38,132.12 170.25,131.24 170.25,129.94 v2(170.18,129.86)
SIO_EXT_SMI#: length 86
  TOP w0.076: v1(165.54,69.82) 165.83,70.12 v2(165.83,70.22)
  TOP w0.102: U38.A6 164.94,117.92 164.43,117.41 164.43,117.33 164.21,117.11 164.07,117.11 163.85,116.88 163.85,113.88 v2(163.95,113.78) ; RP12.7 187.97,78.39 188.4,77.96 v3(188.4,78)
  IN2 w0.076: 170.88,72.16 170.76,72.16 169.99,71.39 169.32,71.39 168.15,70.22 v2(165.83,70.22)
  IN2 w0.102: 170.88,72.16 173.77,72.16 175.15,73.54 176.1,73.54 177.47,74.92 178.29,74.92 179.63,76.26 182.39,76.26 182.46,76.33 183.59,76.33 184.13,76.86 184.13,77.51 184.69,78.07 188.33,78.07 v3(188.4,78) 188.57,78 189.09,78.53 189.09,85.54 188.66,85.97 188.66,87.24 188.26,87.64 185.22,87.64 182.53,90.34 182.53,98.07 182.07,98.52 182.07,99.52 178.72,102.87 178.72,104.75 178.01,105.46 175.75,105.46 171.49,109.71 168.61,109.71 167.48,110.84 167.48,111.67 166.84,112.31 165.71,112.31 164.23,113.78 v2(163.95,113.78)
  BOTTOM w0.076: v2(165.83,70.22) 165.87,70.22 165.51,69.86 UC1.AG5
SIO_EXT_WAKE#: length 128.8
  TOP w0.102: R316.1 197.76,115.09 v3(198.47,114.38) ; v2(183.53,61.02) 183.2,60.69 183.2,60.11 183.58,59.72 RP13.2
  IN2 w0.102: v3(214.85,51.22) 214.44,51.63 214.44,51.7 212.87,53.27 212.87,56.45 209.45,59.87 209.45,81.64 207.43,83.65 207.43,86.63 205.98,88.07 205.98,97.39 204.35,99.02 202.86,99.02 201.74,100.14 201.74,102.78 201.26,103.26 201.26,104.23 201.23,104.26 201.1,104.39 201.1,104.39 200.97,104.52 200.83,104.66 200.83,104.66 200.7,104.79 198.47,107.02 v3(198.47,114.38)
  BOTTOM w0.076: UC1.AU2 167.59,63.91 167.91,64.23 168.38,64.23 168.92,63.69 170.26,63.69 170.4,63.55 170.4,63.08 170.78,62.7
  BOTTOM w0.102: v3(214.85,51.22) 212.49,53.58 208.79,53.58 207.75,54.62 205.46,54.62 204.84,54 196.2,54 195.5,54.7 192.22,54.7 192.08,54.83 190.74,56.17 190.39,56.17 187.67,58.89 187.67,60.11 187.3,60.49 185.56,60.49 185.31,60.24 184.11,60.24 183.76,60.59 183.76,60.79 v2(183.53,61.02) 183.3,61.25 178.72,61.25 178.21,60.74 173.68,60.74 171.92,62.5 v1(171.5,62.5) 170.98,62.5 170.78,62.7
SIO_PWRBTN#: length 418.8
  TOP w0.102: v2(162.93,124.24) 162.93,124.47 162.65,124.75 161.99,124.75 161.88,124.64 U38.B58 ; v3(222.01,76.85) 222.01,77.1 222.5,77.59 JAPS1.11 ; v3(97.17,46.52) v1(97.6,46.09) 98.52,45.17 101.92,45.17 102.06,45.31 RC107.1 ; v3(194.53,76.41) 196.37,74.57 196.89,74.57 197.77,73.7 199.78,73.7 200.06,73.98 202.76,73.98 203.24,73.49 206.7,73.49 207.54,72.66 v3(212.56,72.66)
  IN1 w0.097: v3(212.56,72.66) 212.59,72.66 215.46,75.53 220.69,75.53 v3(222.01,76.85)
  IN3 w0.076: v2(164.54,68.26) 164.54,68.26 165.18,67.61 165.18,64.91 166.09,63.99 166.09,62.48 168.47,60.11
  IN3 w0.102: 168.47,60.11 169.51,59.07 169.51,57.57 169.8,57.28 171.91,57.28 172.41,56.78 178.63,56.78 179.11,56.3 179.11,55.05 179.67,54.49 183.02,54.49 184.39,55.87 189.73,55.87 189.96,56.09 193.69,56.09 194.86,54.93 198.21,54.93 200.27,56.98 201.79,56.98 202.26,56.51 v3(202.26,56.18) 205.04,53.41 205.04,51.47 209.73,46.79 210.19,46.79 211.07,45.9 211.13,45.9 211.51,45.51 211.51,45.46 213.13,43.84 213.13,42.06 217.67,37.53 217.67,36.99 219.32,35.34 220.28,35.34 224.91,30.72 224.91,28.99 225.19,28.71 225.19,27.75 224.93,27.49 224.93,23 224.22,22.29 224.22,19.75 223.28,18.81 222.37,18.81 219.98,16.42 202.9,16.42 201,14.52 187.1,14.52 186.97,14.39 171.56,14.39 171.38,14.21 171.05,14.21 170.84,14.41 152.57,14.41 151.68,15.3 124.1,15.3 123.54,14.74 119.27,14.74 115.99,18.02 107.48,18.02 106.9,18.6 106.37,18.6 105.35,19.62 105.35,24.85 105.35,24.86 105.35,26.04 96.36,35.04 92.29,35.04 90.44,36.89 90.44,41.85 92.62,44.03 94.68,44.03 v3(97.17,46.52)
  BOTTOM w0.076: v2(164.54,68.26) 164.54,67.91 UC1.AL7
  BOTTOM w0.102: v3(194.53,76.41) 194.53,77.23 197.04,79.74 197.04,82.99 198.44,84.39 198.75,84.39 199.94,85.58 199.94,86.58 196.23,90.29 196.23,93.76 193.97,96.02 190.34,96.02 189.96,96.4 186.43,96.4 181.93,100.9 181.93,102.85 182.95,103.86 182.95,105.54 181.31,107.17 180.44,107.17 180.43,107.17 180.29,107.17 176.62,110.84 176.62,110.99 176.62,110.99 176.62,111.39 176.62,114.98 175.1,116.51 175.1,119.93 173.45,121.58 173.45,121.61 173.13,121.93 171.29,121.93 170.55,122.67 164.51,122.67 v2(162.93,124.24) ; v3(222.01,76.85) 222.01,70.99 221.71,70.68 221.71,70.67 218.18,67.14 218.18,65.54 219.22,64.5 219.22,57.87 217.41,56.06 210.51,56.06 210.44,56.13 210.05,56.13 208.54,57.64 207.66,57.64 207.46,57.44 204.36,57.44 203.1,56.18 v3(202.26,56.18)
SIO_RCIN#: length 103.7
  TOP w0.102: v3(182.34,76.9) 182.83,77.39 RP11.8 ; v2(173.32,125.79) 173.17,125.79 v1(172.81,125.44) 172.27,124.89 U38.A27
  IN1 w0.076: v2(166.49,73.93) 166.98,74.42 168.26,74.42 168.77,74.93 169.21,74.93
  IN1 w0.097: 169.21,74.93 171.68,74.93 172.13,74.49 173.28,74.49 173.91,73.86 175.84,73.86 177.98,76 180,76 180.11,76.11 181.27,76.11 181.61,76.45 181.89,76.45 v3(182.34,76.9) 182.84,76.39 190.84,76.39 191.27,76.82 194.83,76.82 v3(195.24,76.41)
  BOTTOM w0.089: v2(166.49,73.93) 166.19,74.23 UC1.V4
  BOTTOM w0.102: v2(173.32,125.79) 175.1,124.01 175.1,121.29 176.09,120.3 176.09,118.45 176.65,117.89 176.65,115.68 177.11,115.22 177.11,111.13 180.57,107.66 181.51,107.66 183.43,105.74 183.43,103.66 182.63,102.86 182.63,102.19 183.15,101.67 183.15,100.83 184.29,99.68 184.29,99.22 185.94,97.57 189.48,97.57 190.54,96.51 194.19,96.51 196.71,93.99 196.71,90.49 200.42,86.78 200.42,84.82 199.51,83.91 198.64,83.91 197.53,82.79 197.53,79.54 195.24,77.26 v3(195.24,76.41)
SIO_SLP_A#: length 288.2
  TOP w0.076: 128.76,71.59 129.77,70.57 131.33,70.57 131.6,70.85 132.46,70.85 133.09,70.22 133.64,70.22 134.26,70.83 146.58,70.83 149.38,73.63 152.8,73.63 153.42,73.01 154.85,73.01 155.16,72.71 155.16,72.38 154.88,72.1 154.47,72.1 153.81,71.44 153.81,70.88 154.42,70.27 154.73,70.27 155.38,69.62 156.69,69.62 156.82,69.75 157.35,69.75 157.57,69.53 157.57,69.02 158.42,68.18 162.39,68.18 162.62,68.41 163.69,68.41 163.92,68.64 164.75,68.64 v2(165.13,68.26)
  TOP w0.102: U37.B63 195.88,125.14 v2(195.78,125.04) ; v3(223.26,74.41) 223.94,75.09 JAPS1.6 ; 128.76,71.59 124.22,71.59 121.57,68.93 114.19,68.93 114,69.13 109.85,69.13 107.25,71.72 v3(107.25,73.54) ; v3(197.32,109.31) 197.27,109.26 R423.1 ; v3(189.63,60.92) 189.63,61.43 189.01,62.05 UC7.1
  IN1 w0.076: 169.21,62.41 167.34,64.27 165.65,64.27 165.3,64.62 165.3,67.46 165.13,67.63 v2(165.13,68.26)
  IN1 w0.097: v3(189.63,60.92) 189.6,60.9 188.48,60.9 187.85,60.26 187.85,57.96 186.71,56.82 186.71,56.43 185.31,55.03 185.31,54.36 185.21,54.27 184.01,54.27 183.75,54.52 178.04,54.52 172.77,59.8 171.82,59.8 169.21,62.41
  IN2 w0.102: v3(209.81,54.56) 209.52,54.85 209.52,58.83 208.76,59.59 208.76,81.32 206.23,83.85 206.23,86.54 205.1,87.67 205.1,93.05 203.32,94.83 203.32,96.58 204.21,97.47 204.21,97.73 203.67,98.26 202.65,98.26 200.8,100.11 200.8,102.56 200.57,102.78 200.57,103.95 200.42,104.11 197.32,107.2 v3(197.32,109.31) 197.32,111.39 194.69,114.02 194.69,114.88 193.49,116.09 193.49,119.14 193.29,119.34 193.29,123.66 195.03,125.41 195.41,125.41 v2(195.78,125.04)
  IN3 w0.102: v3(107.25,73.54) 107.25,72.38 105.17,70.29 99.08,70.29 98.52,70.85 97.2,70.85 96.86,71.19 94.88,73.16 85.27,73.16 84.61,73.82 81.02,73.82 80.25,73.06 v3(79.96,73.06)
  BOTTOM w0.076: UC1.AL5 165.13,67.89 v2(165.13,68.26)
  BOTTOM w0.102: PR153.1 79.14,73.19 v1(79.29,73.34) 79.68,73.34 v3(79.96,73.06) ; v3(189.63,60.92) 189.22,60.92 189.12,60.82 189.12,59.73 189.5,59.35 189.5,58.03 190.67,56.86 191.03,56.86 191.26,56.63 195.6,56.63 197.54,54.68 203.89,54.68 205.12,55.91 205.25,56.04 207.68,56.04 209.17,54.56 v3(209.81,54.56) 210.02,54.34 212.94,54.34 214.47,52.82 216.17,52.82 217.54,54.19 221.27,54.19 224.01,56.93 224.01,64.75 222.65,66.12 222.65,70.01 222.65,70.29 222.95,70.6 222.95,72.4 223.26,72.71 v3(223.26,74.41)
SIO_SLP_LAN#: length 222.9
  TOP w0.076: 171.42,59.98 170.91,60.49 170.04,60.49 169.33,61.2 169,61.2 167.63,62.57 164.24,62.57 163.99,62.82 163.99,63.66 164.38,64.05 164.74,64.05 165.18,64.49 165.18,67.77 165.62,68.21 165.62,68.62 165.09,69.16 v2(164.71,69.16)
  TOP w0.102: 171.42,59.98 174.01,57.39 174.01,54.5 178,50.51 203.8,50.51 205.04,51.75 205.04,53.63 205.55,54.14 206.9,54.14 207.16,54.4 207.16,54.96 207.05,55.06 207.05,55.61 208.4,56.95 v3(208.4,57.21) ; U22.4 219.04,183.3 219.66,182.68 v1(219.66,176.85) 219.66,174.85 212.17,167.36 212.17,163.68 210.46,161.96 209.31,161.96 208.85,161.5 208.85,161.25 208.61,161.01 208.61,159.59 v3(207.51,158.48) ; v2(193.64,130.43) 193.64,130.39 194.07,129.96 194.07,129.7 193.84,129.47 U37.A5
  IN2 w0.102: v3(208.4,57.21) 208.4,59.3 208.52,59.42 208.52,75.25 207.33,76.44 207.33,77.99 208.53,79.19 208.53,81.22 205.97,83.79 205.97,86.26 204.87,87.36 204.87,92.85 202.84,94.88 202.84,97.75 200.35,100.24 200.35,100.72 200.35,100.73 200.35,101.1 200.35,101.29 200.35,101.48 200.35,103.85 196.87,107.33 196.87,110.5 194.47,112.9 194.47,114.79 193.26,115.99 193.26,119.05 192.94,119.36 192.94,127.11 192.97,127.13 192.97,127.86 193.18,128.07 193.18,129.96 v2(193.64,130.43)
  IN3 w0.102: v2(193.64,130.43) 193.64,132.15 193.06,132.74 193.06,137.04 193.56,137.55 197.18,137.55 198.22,136.51 205.11,136.51 207.03,138.43 207.03,139.53 207.27,139.78 207.27,143.29 206.31,144.25 206.31,150.23 206.87,150.79 206.87,151.9 206.14,152.64 206.14,153.34 206.5,153.7 206.5,157.47 v3(207.51,158.48)
  BOTTOM w0.076: v2(164.71,69.16) 164.25,68.69 UC1.AJ7
SIO_SLP_S0#: length 292.8
  TOP w0.076: v2(170.07,70.67) 169.43,70.04 166.43,70.04 165.91,69.52 164.26,69.52 164.25,69.53 163.95,69.53 163.74,69.32 163.74,69.06 163.38,68.69 162.6,68.69 162.25,68.34 159.18,68.34 158.41,69.12 158.41,69.56 158.06,69.91 157.51,69.91 156.93,70.5 154.52,70.5 154.07,70.95 154.07,71.39 154.47,71.79 154.87,71.79 155.32,72.24 155.32,72.78 154.92,73.18 153.48,73.18 152.87,73.79 148.97,73.79 146.17,71 132.75,71 132.73,71.01 131.29,71.01 130.86,71.44 129.42,71.44 128.93,71.92 127.75,71.92
  TOP w0.102: JAPS1.15 222.98,79.59 221.45,78.07 v3(221.45,77.96) ; U38.A36 168.44,129.32 168.97,129.85 v2(168.97,129.85) ; v3(108.55,71.94) 108.55,71.26 110.45,69.35 114.09,69.35 114.28,69.16 121.03,69.16 123.79,71.92 127.75,71.92
  IN2 w0.102: v3(200.47,60.21) 200.4,60.28 200.4,68.07 200.47,68.14 200.47,73.28 203.77,76.59 203.77,80.11 201.16,82.73 201.16,83.34 199.62,84.87 199.62,85.39 198.94,86.08 198.94,89.01 198.64,89.3 198.64,95.57 195.14,99.08 195.14,101.95 189.02,108.08 189.02,109.51 188.41,110.12 188.41,114.18 183.2,119.38 183.2,121.47 182.38,122.3 177.01,122.3 176.39,122.92 175.46,122.92 174.82,123.56 174.82,127.97 174.36,128.43 170.38,128.43 v2(168.97,129.85)
  IN3 w0.076: 171.03,62.27 169.72,62.27 168.51,63.48 168.51,66.42 168.23,66.7 168.23,68.66 168.82,69.25 170.2,69.25 170.71,69.77 170.71,70.19 170.23,70.67 v2(170.07,70.67)
  IN3 w0.102: v3(108.55,71.94) 107.23,71.94 105.35,70.06 98.96,70.06 98.4,70.62 96.76,70.62 v3(96.36,71.03) ; 171.03,62.27 172.71,62.27 174.39,60.59 178.63,60.59 180.76,62.72 182.74,62.72 182.95,62.52 182.95,62.22 183.1,62.06 188.26,62.06 188.45,62.25 192.81,62.25 194.86,60.21 197.98,60.21 198.62,59.57 199.84,59.57 v3(200.47,60.21)
  BOTTOM w0.076: v2(170.07,70.67) 169.75,70.99 168.71,70.99 168.6,70.88 168.02,70.88 167.85,70.71 167.85,70.53 167.61,70.3 167.1,70.3 UC1.AF3
  BOTTOM w0.102: v3(96.36,71.03) 95.22,72.17 95.22,73.16 94.22,74.15 87.11,74.15 86.81,74.46 v1(83.86,74.46) 83.56,74.15 83.05,74.15 82.82,73.93 PR157.2 ; v3(221.45,77.96) 221.53,77.89 221.53,71.19 221.12,70.78 221.12,70.77 217.69,67.34 217.69,65.34 218.74,64.3 218.74,58.07 217.21,56.55 210.69,56.55 210.62,56.62 210.31,56.62 208.8,58.13 207.46,58.13 207.26,57.92 204.16,57.92 204.03,57.8 201.2,57.8 200.3,58.7 200.3,60.03 v3(200.47,60.21)
SIO_SLP_S3#: length 646
  TOP w0.102: R417.1 166.48,109.37 178.24,109.37 180.49,111.62 181.86,111.62 186.81,106.67 196.48,106.67 199.09,109.28 201.23,109.28 v3(202.58,110.63) ; JAPS1.2 v3(223.99,73.09) ; U37.B65 196.41,126.14 196.17,125.9 v2(195.94,125.9)
  IN1 w0.097: v3(274.59,150.61) 274.59,149.94 255.32,130.67 233.18,130.67 228.79,126.29 228.79,125.41 227.09,123.71 v3(227.09,123.42) 226.99,123.32 226.99,122.48 226.36,121.84 226.36,116.52 222.14,112.31 222.14,104.71 224.09,102.75 224.09,95.67 223.87,95.44 222.19,95.44 221.02,94.27 221.02,85.2 223.54,82.69 223.54,79.06 223.18,78.7 223.18,76.62 223.94,75.86 223.94,73.14 v3(223.99,73.09)
  IN2 w0.102: v3(32.02,19.47) 34.43,21.88 36.54,21.88 38.73,24.07 49.57,24.07 49.92,23.71 60.37,23.71 60.7,23.38 63.71,23.38 64.98,24.65 64.98,24.65 73.45,24.65 v3(73.75,24.95) 74.06,24.65 75.17,24.65 75.81,25.28 80.04,25.28 86.92,18.4 91.46,18.4 91.58,18.27 106.75,18.27 107.36,17.66 116.51,17.66 119.64,14.54 138.6,14.54 141.19,11.95 145.37,11.95 145.84,12.42 149.99,12.42 151.86,14.28 169.49,14.28 170.08,14.87 170.89,14.87 171.05,15.02 171.38,15.02 171.54,14.87 186.93,14.87 187.39,14.41 201.39,14.41 202.78,15.81 226.64,15.81 227.42,16.59 227.42,19.54 225.54,21.42 225.54,23.89 226.15,24.5 226.15,28.26 225.21,29.2 225.21,32.52 217.58,40.15 217.58,40.41 214.3,43.69 214.3,43.85 206.99,51.17 206.81,51.17 206.31,51.66 206.31,53.05 203.93,55.43 196.06,55.43 v3(195.74,55.76) ; v2(195.94,125.9) 196.23,125.62 199.58,125.62 199.99,125.21 199.99,118.89 200.85,118.03 200.85,115.56 202.4,114.01 202.4,110.81 v3(202.58,110.63)
  IN3 w0.076: 169.41,60.11 166.53,62.99 v2(166.53,64.97)
  IN3 w0.102: v3(195.74,55.76) 194.92,56.58 184.42,56.58 182.82,54.98 180.33,54.98 179.59,55.72 179.59,56.5 178.83,57.26 172.79,57.26 172.05,58 171.52,58 169.41,60.11
  BOTTOM w0.076: UC1.AT4 166.19,64.63 v2(166.53,64.97)
  BOTTOM w0.102: PR111.1 32.51,11.61 30.75,13.37 v1(30.75,17.21) 30.75,18.2 v3(32.02,19.47) ; v3(223.99,73.09) 223.18,72.28 223.18,70.5 222.91,70.23 222.91,66.2 224.24,64.87 224.24,57.02 224.24,56.84 220.45,53.05 218.63,53.05 217.93,52.34 217.29,52.34 214.49,52.34 212.72,54.11 209.29,54.11 207.58,55.82 205.35,55.82 203.99,54.45 196.55,54.45 196.03,54.98 196.03,55.47 v3(195.74,55.76) ; v2(195.94,125.9) 196.1,125.9 197.98,124.01 198.83,124.01 200.4,122.45 201.15,122.45 202.29,121.31 202.29,119.11 214.01,107.39 214.01,107.37 214.01,105.71 216.46,103.26 223.04,103.26 223.25,103.05 225.32,103.05 225.83,103.05 226.86,104.09 226.86,105.36 225.91,106.32 225.91,112.11 227.83,114.03 227.83,122.68 v3(227.09,123.42) ; R734.2 75.02,27.09 73.75,25.82 v3(73.75,24.95) ; R425.1 253,160.82 252.49,161.33 252.49,162.47 253.03,163.01 253.03,164.54 254.14,165.65 254.14,166.05 254.27,166.18 261.93,166.18 267.38,160.73 267.38,154.49 271.26,150.61 v3(274.59,150.61)
SIO_SLP_S4#: length 493.1
  TOP w0.102: R421.1 197.33,111.04 197.55,111.26 207.41,111.26 213.53,105.14 213.53,103.26 v3(212.87,102.6) ; v3(222.55,74) 223.55,74 224.15,74.59 JAPS1.5 ; v3(209.52,133.13) 206.57,133.13 205.27,131.84 205.27,128.9 201.01,124.64 199.52,124.64 199.25,124.9 199.15,124.9 198.38,125.67 198.07,125.67 197.85,125.89 U37.A61
  IN2 w0.102: v3(196.34,56.55) 197.23,55.66 204.05,55.66 207.49,52.22 207.49,51.01 226.46,32.04 226.46,24.27 225.77,23.58 225.77,21.52 227.65,19.64 227.65,16.5 227.52,16.36 227.52,16.36 226.74,15.58 202.94,15.58 201.4,14.05 151.95,14.05 150.04,12.15 145.89,12.15 145.46,11.72 141.09,11.72 138.5,14.31 119.54,14.31 116.42,17.44 107.27,17.44 106.66,18.05 91.43,18.05 91.3,18.17 86.83,18.17 79.95,25.06 75.91,25.06 75.28,24.42 65.08,24.42 63.81,23.15 54.88,23.15 54.65,23.38 49.25,23.38 48.81,23.81 39.03,23.81 36.72,21.5 35.32,21.5 v3(33.29,19.47) ; v3(209.52,133.13) 209.34,132.96 209.34,107.63 213.05,103.92 213.05,102.78 v3(212.87,102.6) 212.19,101.93 212.19,93.36 212.63,92.92 212.76,92.79 212.89,92.66 213,92.56 213,90 213.55,89.44 213.55,89.25 213.55,88.31 212.77,87.52 212.77,86.58 219.12,80.23 219.12,75.2 219.6,74.71 221.83,74.71 v3(222.55,74)
  IN3 w0.076: 169.74,60.11 167.5,62.35 167.5,65.12 166.93,65.68 166.38,65.68 166.13,65.92 166.13,67.12 166.06,67.19 166.06,67.77 165.7,68.14 v2(165.7,69.17)
  IN3 w0.102: 169.74,60.11 171.62,58.23 171.95,58.23 171.96,58.23 172.14,58.23 172.88,57.49 178.98,57.49 180.64,55.84 182.92,55.84 184.42,57.34 187.21,57.34 188.11,58.23 190.11,58.23 190.62,57.72 195.17,57.72 v3(196.34,56.55)
  BOTTOM w0.076: UC1.AJ6 165.04,68.69 165.52,69.17 v2(165.7,69.17)
  BOTTOM w0.102: v3(196.34,56.55) 197.98,54.91 203.63,54.91 204.99,56.27 207.77,56.27 209.08,54.96 209.98,54.96 210.29,54.65 214.87,54.65 215.36,54.16 217.16,54.16 217.41,54.42 221.18,54.42 223.79,57.02 223.79,64.66 222.42,66.03 222.42,69.92 222.42,70.39 222.72,70.69 222.72,72.5 223.03,72.81 223.03,73.52 v3(222.55,74) ; PR107.1 32.76,15.17 31.99,15.93 v1(31.99,15.94) 31.99,18.17 v3(33.29,19.47) ; v3(212.87,102.6) 213.38,102.09 222.59,102.09 222.78,101.91 224.33,101.91 231.54,94.7 231.54,94.27 232,93.81 PR203.1
SIO_SLP_S5#: length 174.8
  TOP w0.102: v3(222.55,73.37) 222.56,73.37 222.94,73.76 223.86,73.76 224.2,74.09 JAPS1.4 ; v2(172.43,120.39) U38.A18
  IN1 w0.076: v2(165.7,65.51) 167.13,65.51 168.37,64.27 169.21,64.27
  IN1 w0.097: v3(196.49,60.9) 196.49,62.62 194.63,64.47 194.28,64.47 194.15,64.35 194.15,64.35 192.91,63.11 190.63,63.11 190.61,63.13 190.25,63.13 190.23,63.11 189.81,63.11 189.26,63.66 184.41,63.66 183.52,64.55 182.26,64.55 181.7,63.99 181.7,63.54 181.48,63.31 181.48,62.87 181.07,62.46 178.78,60.17 177.79,60.17 172.88,60.17 170.42,62.64 170.42,63.19 169.33,64.27 169.21,64.27
  IN2 w0.102: v3(196.59,59.04) 196.49,59.14 v3(196.49,60.9) 196.18,61.21 196.18,62.88 195.68,63.38 195.68,65.87 194.68,66.86 194.35,66.86 194.1,67.12 194.1,68.77 195,69.67 195,74.14 196.45,75.59 196.45,77.88 197.76,79.18 200.19,79.18 200.65,79.65 200.65,80.76 199.86,81.55 198.95,81.55 197.58,82.92 197.58,83.88 197.39,84.07 197.39,88.37 197.09,88.66 197.09,94.78 195,96.87 193.64,98.23 193.26,98.23 192.22,99.28 192.22,103.01 187.62,107.6 187.62,108.32 185.27,110.67 185.27,116.02 182.29,119.01 182.29,121.1 182.1,121.28 178.56,121.28 177.21,119.93 172.89,119.93 v2(172.43,120.39)
  BOTTOM w0.076: UC1.AP5 165.38,65.83 v2(165.7,65.51)
  BOTTOM w0.102: v3(196.59,59.04) 196.59,58.38 v1(197.92,57.05) 199.3,55.66 203.27,55.66 204.56,56.96 208.07,56.96 209.38,55.65 210.26,55.65 210.33,55.58 216.19,55.58 218.28,55.58 219.7,57 219.7,64.7 218.66,65.74 218.66,66.94 222.19,70.47 222.19,70.48 222.49,70.79 222.49,73.32 v3(222.55,73.37)
SIO_SLP_SUS#: length 161.2
  TOP w0.102: U37.B6 193.59,127.87 193.86,127.6 193.86,127.28 v2(194.32,126.82)
  IN2 w0.076: v2(169.03,65.55) 169.03,65.29 170.55,63.77 170.55,62.37 170.88,62.04
  IN2 w0.102: v2(194.32,126.82) 194.78,127.28 194.78,127.58 197.55,130.34 201.89,130.34 203.95,128.29 204.08,128.15 204.08,109.17 205.81,107.45 205.81,102.15 206.39,101.56 206.39,99.22 207.38,98.23 207.38,89.34 210.28,86.45 210.28,86.12 210.28,84.64 214.87,80.05 214.87,71.48 214.76,71.37 214.63,71.23 214.34,70.95 214.34,70.94 214.16,70.77 214.16,69.74 214.16,68.04 214.3,67.91 214.75,67.45 218.48,67.45 v3(219.22,66.71) ; v3(192.04,58.2) 192.04,58.46 191.07,59.42 184.83,59.42 184.42,59.83 182.46,59.83 182.38,59.9 180.48,59.9 180.33,59.75 173.17,59.75 170.88,62.04
  BOTTOM w0.076: v2(169.03,65.55) 168.61,65.55 168.37,65.8 167.95,65.8 167.79,65.64 167.01,65.64 166.96,65.69 166.5,65.69 UC1.AP4
  BOTTOM w0.102: v3(219.22,66.71) 218.89,66.38 218.89,65.85 223.33,61.41 223.33,57.21 220.99,54.88 216.78,54.88 216.3,55.35 216.1,55.35 210.24,55.35 210.17,55.42 209.27,55.42 207.96,56.73 204.77,56.73 204.64,56.6 203.41,55.37 198.46,55.37 196.59,57.24 193.01,57.24 v1(192.73,57.52) v3(192.04,58.2)
SIO_SLP_WLAN#: length 154.9
  TOP w0.076: v2(165.68,66.73) 165.7,66.73 166.61,65.82 167.07,65.82 168.42,64.48 168.42,63.57 169.57,62.42 171.21,62.42
  TOP w0.102: R318.1 189.74,132.78 v2(189.8,132.85) ; 171.21,62.42 v1(172.22,62.42) 172.58,62.42 177.41,57.59 177.41,57.09 177.87,56.63 177.87,53.52 179.05,52.34 194.07,52.34 198.45,56.72 198.45,59.61 199.08,60.23 199.08,61.8 199.25,61.98 199.25,62.24 199.48,62.47 199.83,62.47 200.32,61.98 200.32,61.62 200.71,61.23 203.44,61.23 209.82,67.6 210.4,67.6 212.28,69.48 v3(215.74,69.48)
  IN2 w0.102: v3(215.74,69.48) 216.5,70.24 216.5,81.37 211.85,86.02 211.85,91.37 210.96,92.26 210.96,102.13 210.94,102.15 210,103.09 210,103.6 208.07,105.53 208.07,127.44 204.51,131 204.51,131.45 203.77,132.19 199.44,132.19 198.58,133.06 196.4,133.06 195.07,134.38 192.85,134.38 191.81,133.34 190.29,133.34 v2(189.8,132.85)
  BOTTOM w0.076: UC1.AM5 165.29,67.13 v2(165.68,66.73)
SKIP#: length 2.5
  BOTTOM w0.203: PR315.1 80.75,91.85 v1(81.17,91.43) 81.27,91.32 PU300.7
SKIP#1: length 36.7
  IN2 w0.254: v2(77.72,90.01) 77.72,91.46 82.82,96.56 82.82,100.24 91.84,109.26 95.82,109.26 96.54,108.55 96.54,107.1 v2(95.57,106.14)
  BOTTOM w0.203: v2(95.57,106.14) 95.57,106.03 95.24,105.7 PU301.1
  BOTTOM w0.254: v2(77.72,90.01) v1(77.72,90.79) 77.72,91.56 PR314.2 PR315.2
SL_BAT_PRES#: length 2.4
  TOP w0.254: PU701.21 131.65,158.42 132.46,159.23 PR549.1
SLATE_MODE_R: length 29.8
  TOP w0.102: RP12.6 187.62,77.89 188.08,77.43 v3(188.08,76.8)
  IN2 w0.076: v2(166.49,67.98) 166.49,67.97 166.85,67.61 170.09,67.61 170.25,67.76 170.25,68.46 170.58,68.79 170.68,68.79 170.88,69
  IN2 w0.102: v3(188.08,76.8) 187.7,76.42 187.27,76.42 186.91,76.78 186.91,76.99 186.32,77.58 185.85,77.58 185.44,77.17 185.44,76.26 184.98,75.81 183.17,75.81 179.54,72.17 178.2,72.17 175.83,72.17 174.41,70.75 173.99,70.75 172.72,69.48 171.36,69.48 170.88,69
  BOTTOM w0.076: UC1.AL4 166.19,67.69 v2(166.49,67.98)
SLEEVE: length 48.9
  TOP w0.254: v2(299.66,147.71) 300.04,147.33 v1(301.41,147.33) 307.96,147.33 v2(309.23,148.6)
  IN3 w1.016: 335.52,160.36 335.88,160.01 335.88,157.62 323.31,145.05 310.33,145.05 309.03,146.34
  BOTTOM w0.254: v2(299.66,147.71) 300.02,148.07 Q123.3 ; R197.1 309.37,147.15 v2(309.37,147.96) 309.23,148.1 v2(309.23,148.6) U17.29
  vias: v2(333.98,160.69) v2(334.56,160.69)
SLEWA: length 15.3
  IN1 w0.254: v2(90.75,88.42) 90.75,90.26 v2(87.21,93.81)
  BOTTOM w0.203: PU300.15 85.28,92.85 85.89,93.46 86.85,93.46 v2(87.21,93.81) PR310.1
  BOTTOM w0.254: v2(90.75,88.42) 91.18,88 v1(91.18,86.47) 90.62,85.91 90.62,85.48 90.44,85.31 PR300.2
SLICE_BAT_ON: length 117.2
  TOP w0.102: v3(148.86,138.62) 148.83,138.62 149.33,139.11 PQ508.2 ; U37.A31 186.07,120.39 186.05,120.37 186.05,120.37 185.9,120.23 v3(185.32,120.23) 184.8,119.72 R307.2 ; PU505.1 152.83,157.61 152.77,157.67 149.95,157.67 149.67,157.95 149.67,160.41 149.27,160.82 148.61,160.82 148.35,161.07 146.57,161.07 v1(146.24,160.74) 145.61,160.11 v3(145.61,159.57) ; v2(143.83,145.93) 144.34,146.44 PU500.2
  TOP w0.254: v2(128.66,159.7) 128.07,160.29 PR543.2
  IN1 w0.097: v3(148.86,138.62) 155.57,131.91 155.57,130.5 156.64,129.43 156.64,126.9 156.28,126.54 156.28,123.06 156.3,123.03 156.76,122.57 156.76,120.34 157.73,119.37 157.73,118.19 157.74,118.19 157.74,118.01 157.74,117.82 157.73,117.82 157.73,116.64 158.73,115.65 165.24,115.65 165.75,115.13 167.83,115.13 168.17,115.48 172.58,115.48 173.5,116.39 173.5,117.46 175.1,119.06 175.1,120.26 175.78,120.94 177.07,120.94 177.44,121.31 178.95,121.31 178.95,121.31 179.14,121.31 179.14,121.31 180.59,121.31 181.68,120.22 185.3,120.22 v3(185.32,120.23) ; v3(145.61,159.57) 128.82,159.57 128.67,159.73 128.67,159.7 v2(128.66,159.7)
  BOTTOM w0.102: v3(145.61,159.57) 145.61,151.45 144.29,150.13 144.29,147 143.83,146.54 v2(143.83,145.93) 143.83,143.65 v3(148.86,138.62)
SLICE_BAT_PRES#: length 254.3
  TOP w0.102: PU506.1 151.12,166.24 v3(151.9,165.47) ; PU500.1 144.19,147.09 v2(143.57,147.71) 143.57,149.21 142.26,150.53 142.26,151.45 142.87,152.06 143.07,152.06 143.57,152.56 PQ503.5 143.57,154.08 144.8,155.31 v1(144.8,158.05) v3(144.8,160.16) ; PR562.2 154.02,152.51 154.63,153.12 156.37,153.12 PU503.1 156.38,153.81 156.78,154.22 158.6,154.22 159.03,154.65 159.03,156.11 v3(158.84,156.3) ; v2(187.65,116.97) 187.21,116.54 R285.2 ; v2(188.1,119.86) 188.1,119.9 187.86,120.14 U37.B33 ; PQ1.2 134.7,139.77 134.7,138.53 134.76,138.47 PC4.1 135.39,137.49 135.39,135.51 v2(135.42,135.47)
  TOP w0.254: v3(141.71,132.24) 142.08,132.61 PR566.1 142.42,131.31 PD514.1 ; v2(132.63,161.25) 132.46,161.08 PR549.2
  IN1 w0.097: v2(187.65,116.97) 187.49,116.82 181.44,116.82 178.82,114.2 177.72,114.2 175.03,111.51 168.71,111.51 168.02,110.82 165.39,110.82 164.92,111.29 164.31,111.29 163.55,112.05 163.34,112.05 160.98,112.05 160.89,111.96 157.95,111.96 157.95,111.96 157.03,111.96 156.36,111.29 156.18,111.29 155.5,111.29 153.38,113.41 153.38,115.71 152.39,116.7 152.39,125.24 153.04,125.9 153.04,128.66 151.51,130.19 151.51,131.71 150.2,133.02 146.46,136.76 144.37,136.76 142.84,136.76 141.55,135.47 v2(135.42,135.47) ; v2(132.63,161.25) 133.87,160.01 144.64,160.01 v3(144.8,160.16) 147.16,160.16 149.11,158.2 149.11,156.27 149.6,155.78 154.65,155.78 155.64,156.78 158.36,156.78 v3(158.84,156.3) 159.1,156.55 159.1,162.14 159.89,162.93 159.89,163.77 160.17,164.05 160.17,168 163.06,170.89 163.06,172.86 163.59,173.39 164.91,173.39 165.17,173.14 167.21,173.14 169.53,175.46 169.53,176.38 174.14,180.99 174.14,181.65 175.06,182.57 175.06,182.78 175.57,183.29 176.71,183.29 177.52,182.48 180.32,182.48 180.33,182.48 180.7,182.48 181.02,182.16 201.62,182.16 202.05,182.59 v2(203.75,182.59)
  IN3 w0.102: v3(151.9,165.47) 150.05,163.63 148.26,163.63 v3(144.8,160.16) ; v2(188.1,119.86) 187.65,119.4 v2(187.65,116.97)
  BOTTOM w0.102: v2(203.75,182.59) 204.77,181.57 204.77,178.67 203.95,177.86 JDOCK1.141 203.95,175.72 204.09,175.59 204.34,175.59 204.45,175.69 JDOCK1.143 ; v2(135.42,135.47) 137.86,135.47 141.09,132.24 v3(141.71,132.24) 142.71,133.25 142.71,134.7 141.82,135.58 141.82,145.96 v2(143.57,147.71)
SLICE_PERF_EN: length 87.3
  TOP w0.102: v2(169.52,126.82) 169.06,127.28 169.06,127.73 169.07,127.74 169.19,127.86 U38.B37 ; PR563.2 PR561.2 v1(144.16,143.83) 144.8,144.46 v3(145.18,144.46)
  TOP w0.254: PQ516.2 v3(147.89,157.92) ; PQ523.5 v2(138.68,157.8)
  IN1 w0.097: v2(138.68,157.8) 138.68,157.05 140.25,155.49 142.31,155.49 144.74,157.92 v3(147.89,157.92) ; v2(169.52,126.82) 170.7,128.01 170.7,132.7 172.51,134.5 v3(172.51,148.86)
  IN2 w0.102: v3(172.51,148.86) 172.38,148.98 166.08,148.98 163.57,146.47 159.12,146.47 158.83,146.18 158.83,146.17 158.61,145.95 158.6,145.95 157.6,144.94 150.74,144.94 148.56,142.76 145.71,142.76 145.18,143.29 v3(145.18,144.46)
  BOTTOM w0.102: v3(147.89,157.92) 146.22,156.25 146.22,145.5 v3(145.18,144.46)
SLP_ME_CSW_DEV#: length 73.5
  TOP w0.102: U37.B58 195.78,122.64 195.44,122.3 195.44,122.08 v2(195.44,122.08) ; RC289.2 177.94,91.48 v6(178.27,91.15) 178.71,90.72 v3(179.72,90.72)
  IN2 w0.102: v2(195.44,122.08) 195.89,121.63 198.31,121.63 198.95,120.99 198.95,118.13 199.66,117.42 199.66,106.15 201.2,104.62 201.64,104.17 v2(201.64,103.59)
  IN3 w0.102: v3(179.72,90.72) 179.93,90.72 184.58,95.36 196.17,95.36 200.68,99.87 200.68,102.63 v2(201.64,103.59)
  BOTTOM w0.076: 170.77,84.58 170.77,84.57 168.57,82.36 168.03,82.36 UC1.E2
  BOTTOM w0.102: 170.77,84.58 171.77,85.58 171.77,86.83 175.66,90.72 v3(179.72,90.72)
SM_RCOMP0: length 7.3
  TOP w0.381: v2(131.37,64.38) 131.13,64.62 131.13,66.25 v6(131.33,66.46) 131.33,67.99 131.98,68.64 132.76,68.64 133.56,69.44 RC125.1
  BOTTOM w0.229: v2(131.37,64.38) 131.58,64.18 UC1.AU60
SM_RCOMP1: length 7.9
  TOP w0.305: v2(131.11,63.03) v6(129.78,63.03) 128.24,63.03 126.88,61.67 126.02,61.67 v2(125.39,62.3)
  BOTTOM w0.305: v2(131.11,63.03) 131.3,63.23 UC1.AV60 ; RC129.1 125.15,62.06 v2(125.39,62.3)
SM_RCOMP2: length 6.4
  TOP w0.381: RC133.1 130.48,69.16 v6(129.68,68.36) 129.68,66.74 130.39,66.03 v2(130.39,64.35)
  BOTTOM w0.229: v2(130.39,64.35) 130.58,64.15 UC1.AU61
SMART_DET#: length 332.8
  TOP w0.102: v3(75.5,19.39) 75.5,19.77 78.1,22.37 79.98,22.37 80.09,22.37 v1(81.57,22.37) 83.96,19.98 83.96,19.44 84.46,18.95 86.26,18.95 87.77,20.46 88.64,20.46 88.92,20.73 88.92,21.37 89.06,21.52 JEXP1.33 ; v3(189.75,133.46) 189.34,133.46 189.25,133.36 189.25,131.79 R484.2 188.84,131.18 U37.A15
  IN2 w0.102: v3(75.5,19.39) 75.5,16.47 77.56,14.41 105.81,14.41 106.01,14.21 113.48,14.21 116.23,11.45 137.87,11.45 139.97,9.36 150.56,9.36 152.64,11.44 226.63,11.44 231.26,16.06 231.26,28.21 230.52,28.94 230.52,38.52 231.31,39.31 231.31,46.04 231.54,46.27 231.54,56.47 217.62,70.39 217.62,80.76 212.08,86.3 212.08,91.46 211.19,92.35 211.19,102.22 210.23,103.19 210.23,103.69 208.3,105.62 208.3,127.53 205.35,130.48 205.35,130.93 203.86,132.42 199.54,132.42 198.67,133.29 196.49,133.29 195.17,134.61 192.75,134.61 191.79,133.64 189.93,133.64 v3(189.75,133.46)
SML1_SMBCLK: length 91.8
  TOP w0.076: 171.21,65.16 171.2,65.15 170.66,65.15 170.11,64.59 169.89,64.38 v2(169.89,63.18)
  TOP w0.102: 171.21,65.16 171.69,65.65 172.17,65.65 172.66,66.13 172.66,67.79 174.71,69.84 176.55,69.84 177.29,69.1 179.38,69.1 179.82,69.54 179.82,69.86 v3(180.03,70.07) ; v2(164.5,119.76) 164.69,119.57 U38.B6
  IN3 w0.102: v3(180.03,70.07) 179.73,70.36 179.73,71.61 179.27,72.07 178.63,72.07 177.58,73.11 177.58,73.86 178.06,74.33 178.51,74.33 179,74.81 182.83,74.81 184.39,76.38 184.39,85.36 184.52,85.48 184.52,86.85 183.51,87.87 183.51,89.78 184.08,90.36 184.31,90.36 184.31,90.36 184.51,90.36 185.2,91.05 v3(185.41,91.05)
  BOTTOM w0.076: v2(169.89,63.18) 169.54,62.83 169.08,62.83 168.33,63.58 167.38,63.58 167.05,63.91 UC1.AU3
  BOTTOM w0.102: v3(185.41,91.05) 185.31,91.05 185.13,91.22 185.13,91.86 184.42,92.57 183.04,92.57 180,95.61 180,95.92 179.42,96.51 177.23,96.51 174.49,99.25 174.49,100.11 170.81,103.8 170.81,107.49 168.55,109.75 168.55,111.56 166.51,113.59 166.51,118.02 165.85,118.68 164.61,118.68 164.5,118.79 v2(164.5,119.76) ; RC36.1 180.25,71.36 180.25,70.3 v3(180.03,70.07)
SML1_SMBDATA: length 92.1
  TOP w0.076: 171.21,67.77 171.21,66.05
  TOP w0.102: v2(164.05,117.49) 164.44,117.88 U38.A5 ; v2(171.44,68.41) 171.44,68 171.21,67.77 ; v4(179.39,70.04) 179.59,69.84 179.59,69.63 179.29,69.33 177.38,69.33 176.65,70.06 174.62,70.06 172.43,67.88 172.43,66.23 172.08,65.87 171.39,65.87 171.21,66.05
  IN3 w0.102: v4(179.39,70.04) 179.5,70.15 179.5,71.51 179.18,71.84 178.53,71.84 177.36,73.01 177.36,73.95 177.96,74.56 178.42,74.56 178.9,75.04 182.74,75.04 184.17,76.47 184.17,85.45 184.29,85.58 184.29,86.76 183.28,87.78 183.28,89.88 183.99,90.59 184.25,90.59 184.26,90.59 184.42,90.59 184.6,90.77 v3(184.6,91.03)
  BOTTOM w0.076: 170.78,69.08 170.77,69.09 168.54,69.09 168.26,69.37 168.01,69.37 167.85,69.21 167.85,69.04 167.61,68.8 167.1,68.8 UC1.AH3
  BOTTOM w0.102: 170.78,69.08 v2(171.44,68.41) ; v2(164.05,117.49) 164.05,118.27 164.23,118.45 165.76,118.45 166.28,117.93 166.28,113.5 168.32,111.47 168.32,109.65 170.58,107.39 170.58,103.7 174.26,100.02 174.26,99.15 177.14,96.28 179.32,96.28 179.77,95.83 179.77,95.52 182.95,92.34 184.33,92.34 184.9,91.76 184.9,91.34 v3(184.6,91.03) ; RC37.1 179.98,70.62 v4(179.39,70.04)
SNUB_1.5VRUN:
  vias: v1(226.48,93.98)
SNUB_1.35V: length 1.6
  BOTTOM w0.102: PC109.2 52.23,9.07 v1(52.57,8.72)
SOFT_START_GC: length 9.3
  TOP w0.102: PR20.2 131.1,145.75 v1(131.8,145.05)
  TOP w0.254: v2(128.35,150.05) 128.95,150.65 128.95,150.99 129.15,151.19 PU701.2 ; v2(129.84,145.93) 130.02,145.75 PR20.2
  BOTTOM w0.254: v2(128.35,150.05) 128.35,149.55 128.2,149.4 128.2,148.03 129.84,146.39 v2(129.84,145.93)
SP_TPM_LPC_EN: length 33
  TOP w0.102: v3(191.74,135.83) 191.74,135.52 v1(191.12,134.9) 190.67,134.45 188.84,134.45 188.1,135.19 R193.1 ; v3(201.97,123.94) 202.3,124.27 203.42,124.27 203.67,124.52 R304.2 ; v2(195.35,121.18) 195.35,121.22 195.77,121.64 U37.B56
  IN3 w0.102: v3(201.97,123.94) 201.62,123.58 200.14,123.58 198.17,121.61 195.77,121.61 195.35,121.2 v2(195.35,121.18) 195.14,121.4 195.14,121.65 193.67,123.12 193.67,126 193.74,126.07 193.74,127.66 191.84,129.56 191.84,130.52 191.68,130.67 191.68,135.77 v3(191.74,135.83)
SP_TPM_LPC_EN_R: length 4.4
  TOP w0.102: U25.28 185.9,135.49 186.1,135.29 186.24,135.29 186.47,135.06 v1(186.79,135.06) 187.14,135.06 187.42,135.34 187.42,136.36 187.65,136.59 R193.2
SPI_CLK32: length 12.9
  BOTTOM w0.102: R20.1 R45.2 197.12,64.25 197.12,67.87 197.01,67.98 196.59,67.98 196.49,67.87 196.49,67 196.38,66.89 196.09,66.89 195.98,67 195.98,67.87 195.87,67.98 195.55,67.98 195.44,67.87 195.44,67.28 195.33,67.17 195.04,67.17 194.94,67.28 194.94,67.8 194.83,67.91 194.12,67.91 193.31,67.09 U2.6
SPI_CLK64: length 13.1
  BOTTOM w0.102: R7.1 R57.2 207.86,66.61 207.86,71.64 208.17,71.94 210.07,71.94 210.25,71.77 210.25,69.94 210.33,69.86 210.45,69.86 210.55,69.76 U1.6
SPI_DIN32: length 13
  BOTTOM w0.102: U2.2 199.13,68.36 198.77,68.72 198.34,68.72 197.42,69.63 195.91,69.63 195.8,69.52 195.8,69.02 195.91,68.91 197.44,68.91 197.93,68.41 197.93,66.48 198.49,65.92 198.49,65.04 R15.2
SPI_DIN64: length 13.4
  BOTTOM w0.102: U1.2 205.75,68.49 205.86,68.6 205.86,69.14 205.75,69.25 205.51,69.25 205.4,69.36 205.4,69.86 206.14,70.6 206.64,70.6 207,70.24 207,68.19 206.64,67.83 206.55,67.83 206.44,67.72 206.44,67.51 206.33,67.4 206.02,67.4 205.91,67.51 205.91,67.82 205.8,67.93 205.48,67.93 205.38,67.82 205.38,66.67 205.27,66.56 204.21,66.56 204.11,66.45 R4.2
SPI_DO32: length 13.1
  BOTTOM w0.102: R21.1 195.6,64.49 195.49,64.6 194.22,64.6 194.21,64.59 192.12,64.59 192.01,64.7 192.01,65.03 192.12,65.14 194.19,65.14 194.3,65.25 194.3,65.43 194.41,65.54 194.67,65.54 194.78,65.43 194.78,65.25 194.89,65.14 195.23,65.14 195.34,65.25 195.34,65.92 195.45,66.03 195.46,66.03 195.57,66.14 195.57,66.53 195.46,66.64 194.22,66.64 193.41,65.82 U2.5
SPI_DO64: length 13.2
  BOTTOM w0.102: U1.5 211.41,72.55 211.24,72.73 v6(210.07,72.73) 207.84,72.73 207.51,72.4 207.51,67.14 R9.1
SPI_PCH_CS0#_R: length 12.8
  BOTTOM w0.102: U1.1 203.05,67.22 202.94,67.33 202.94,69.42 202.83,69.53 201.47,69.53 201.36,69.42 201.36,69.13 201.47,69.02 202.29,69.02 202.4,68.91 202.4,68.65 202.29,68.54 v6(202,68.54) 201.52,68.54 201.41,68.43 201.41,68.17 201.52,68.06 202.32,68.06 202.43,67.95 202.43,67.66 202.32,67.55 202.18,67.55 202.07,67.44 202.07,66.77 202.18,66.66 203.11,66.66 203.22,66.55 R3.2
SPI_PCH_CS1#_R: length 13.2
  BOTTOM w0.102: U2.1 197.99,69.63 197.88,69.74 197.88,70.26 197.77,70.37 196.7,70.37 196.59,70.48 196.59,71.89 196.7,72 197.06,72 v1(197.17,71.89) 197.17,71.04 197.28,70.93 197.67,70.93 197.78,71.04 197.78,71.78 197.89,71.89 198.2,71.89 198.31,71.78 198.31,71.09 198.42,70.98 199.3,70.98 199.41,70.87 199.41,70.58 199.52,70.47 200.01,70.47 200.12,70.58 R14.2
SPI_PCH_DO2_32: length 13.9
  BOTTOM w0.102: R23.1 R19.2 201.44,64.32 201.55,64.43 201.55,65.33 201.66,65.44 201.99,65.44 202.1,65.33 202.1,64.92 202.21,64.81 202.5,64.81 202.61,64.92 202.61,65.87 202.5,65.98 v1(201.96,65.98) 201.78,65.98 201.67,66.08 201.67,66.37 201.56,66.48 198.5,66.48 198.39,66.59 198.39,68.08 198.5,68.19 198.84,68.19 198.95,68.08 198.95,67.2 199.06,67.09 U2.3
SPI_PCH_DO2_64: length 104.5
  TOP w0.102: v3(205.76,133.69) 204.59,134.86 v6(203.37,134.86) 193.39,134.86 191.66,133.13 R8.1
  IN1 w0.097: v3(202.89,71.21) 203.11,71.43 203.11,72.03 203.24,72.16 203.24,72.49 203.11,72.62 203.11,73.26 201.5,74.87 201.5,74.87 200.99,75.39 200.99,75.39 200.75,75.63 200.75,78.01 197.43,81.33 197.43,83.81 196.34,84.91 196.34,96.2 194.55,97.98 194.55,103.99 197.68,107.13 197.68,107.73 199.45,109.5 199.45,109.9 203.13,113.58 203.42,113.58 207.2,117.36 207.2,126.3 206.41,127.09 206.41,131.13 206.84,131.56 206.84,132.02 206.34,132.52 206.34,133.11 v3(205.76,133.69)
  BOTTOM w0.102: R6.2 207.25,67.78 207.25,70.86 206.86,71.26 206.42,71.26 206.31,71.37 206.31,72.43 206.19,72.55 205.96,72.55 205.83,72.43 205.83,70.85 204.74,69.76 U1.3 203.19,69.76 202.5,70.45 202.5,70.83 v3(202.89,71.21)
SPI_PCH_DO3_32: length 12.9
  BOTTOM w0.102: U2.7 193.96,68.36 194.07,68.47 194.07,70.08 194.18,70.19 194.52,70.19 194.63,70.08 194.63,68.6 194.74,68.49 197.47,68.49 197.58,68.38 197.58,64.68 R16.1
SPI_PCH_DO3_64: length 13.3
  BOTTOM w0.102: R5.1 208.55,66.25 208.19,66.61 208.19,71.36 208.37,71.54 209.61,71.54 209.72,71.43 209.72,71.09 209.61,70.98 208.99,70.98 208.88,70.87 208.88,70.45 208.99,70.34 209.16,70.34 209.36,70.14 209.36,69.07 209.62,68.82 210.46,68.82 210.79,68.49 U1.7
SPI_WP#_SEL: length 101.4
  TOP w0.102: R8.2 191.54,131.16 191.54,131.14 v2(190.25,129.84) 190.33,129.75 U37.A12
  IN1 w0.097: v3(202.25,62.97) 202.76,63.48 202.76,64.17 203.57,64.98 203.57,69.66 202.41,70.82 202.41,71.41 202.43,71.42 202.43,73.06 200.27,75.22 200.27,77.81 196.96,81.13 196.96,83.61 195.86,84.71 195.86,95.99 194.07,97.78 194.07,104.19 197.21,107.32 197.21,107.93 198.82,109.54 198.82,109.95 202.93,114.06 203.22,114.06 206.72,117.56 206.72,126.11 205.93,126.89 205.93,131.33 v2(206.37,131.76)
  BOTTOM w0.102: v2(206.37,131.76) 200.63,131.76 199.62,130.75 197.37,130.75 196,129.37 190.71,129.37 v2(190.25,129.84) ; v3(202.25,62.97) 201.75,62.47 201.03,62.47 R23.2
SPKR: length 205.6
  IN3 w0.254: v2(172.66,73.11) 172.66,73.44 173.23,74.01 173.23,76.05 174.62,77.43 174.62,79.18 173.85,79.95 173.85,80.2 171.16,82.89 171.16,87.42 175.32,91.58 176.34,91.58 178.22,93.46 179.67,93.46 184.52,98.31 190.34,98.31 190.72,98.31 191.66,99.25 194.66,99.25 196.46,101.05 198.51,101.05 199.25,101.79 199.25,103.38 204.49,108.62 206.92,108.62 215.38,117.08 219.72,117.08 223.75,121.12 223.75,126.87 224.44,127.56 225.16,127.56 226.28,128.68 226.28,129.25 230.17,133.13 231.26,133.13 v2(233.34,135.22)
  BOTTOM w0.102: UC1.V2 167.71,74.34 168,74.62 168.09,74.62 168.38,74.92 169.46,74.92 169.58,75.04 171.15,75.04 171.86,74.33 171.86,74.34
  BOTTOM w0.254: 171.86,74.34 171.88,74.34 171.87,74.33 172.66,73.54 v2(172.66,73.11) 173.03,73.11 RC222.2 ; v2(233.34,135.22) 234.1,135.98 240.38,135.98 244.31,139.91 263.76,139.91 273.38,149.53 281.79,149.53 284.9,152.64 292.2,152.64 292.86,153.3 293.67,154.11 293.67,160.07 296.33,162.72 306.39,162.72 307.78,164.12 311.6,164.12 312.26,163.46 R387.2
SRCDET: length 5
  TOP w0.102: U6.C2 176.62,155.28 176.62,154.75 175.94,154.06 175.94,153.55 v1(175.23,152.84) 174.64,152.26 R69.1
SRN_B: length 19.4
  TOP w0.254: PC426.1 118.09,164.35 118.23,164.21 PU402.13 ; PC426.1 118.28,165.25 118.28,166.94 118.74,167.4 124.07,167.4 125.66,168.98 125.66,171.95 v3(125.49,172.12) ; PC426.1 117.26,165.06 v1(117.01,164.81) 116.71,164.81 PC425.2
  BOTTOM w0.254: v3(125.49,172.12) 125.87,172.5 PR426.2
SRP_B: length 17.8
  TOP w0.254: v3(126.25,172.12) 126.08,171.94 126.08,168.9 124.2,167.02 119.12,167.02 118.76,166.66 v1(118.76,166.15) 118.76,166.1 119,165.86 PC426.2 ; PC426.2 119.84,165.06 PC427.1 ; PC426.2 118.73,164.79 PU402.12
  BOTTOM w0.254: PR426.3 125.87,171.74 v3(126.25,172.12)
SRTCRST#: length 50.2
  TOP w0.102: v3(200.17,56.18) 200.17,55.94 195.22,50.99 178.2,50.99 174.56,54.63 v6(174.56,56.93) 174.56,57.52 171.29,60.79 170.14,60.79 169.79,61.14 169.47,61.45 169.05,61.45 167.58,62.93 v2(164.39,62.93)
  BOTTOM w0.076: UC1.AV6 164.69,63.23 v2(164.39,62.93)
  BOTTOM w0.102: RC8.2 CC3.2 198.16,58.74 ME1.2 199.28,57.07 v3(200.17,56.18)
STRAP0: length 8.2
  BOTTOM w0.102: v1(76.7,109.79) 76.25,110.24 74.81,110.24 RV2654.1 ; RV2654.1 73.72,110.69 71.16,108.14 UV1.D1 ; RV2654.1 RV2653.2
STRAP1: length 10.3
  BOTTOM w0.102: UV1.D2 70.48,108.5 71.01,108.5 71.39,108.88 71.39,109 73.42,111.04 73.42,111.62 RV2650.1 RV2649.2 74.83,113.92 76.51,113.92 v1(76.9,114.31)
STRAP2: length 7.4
  BOTTOM w0.102: RV2647.2 RV2648.1 v1(73.21,107.71) 70.81,107.71 70.81,107.71 70.49,107.71 70.49,107.71 68.95,107.71 68.53,107.29 UV1.E4
STRAP3: length 6.9
  BOTTOM w0.102: RV2652.1 RV2651.2 v1(73.3,106.03) 72.63,106.03 72.18,106.49 71.52,106.49 71.06,106.95 69.67,106.95 UV1.E3
STRAP4: length 11.1
  BOTTOM w0.102: UV1.D3 69.67,108.48 69.67,109.19 69.87,109.38 71.11,109.38 72.79,111.06 72.79,112.81 RV93.2 RV94.1 73.85,115.84 v1(73.47,115.84)
STRAPREF0: length 2.2
  TOP w0.102: v5(67.2,106.87) 67.18,106.9 RV2723.1 v1(67.18,108.51)
  BOTTOM w0.127: UV1.F6 66.83,106.5 v5(67.2,106.87)
STSTART_DCBLOCK_GC: length 32.7
  TOP w0.254: v3(144.08,163.61) 144.31,163.61 144.73,164.03 151.25,164.03 151.54,164.32 156.26,164.32 156.86,164.92 v1(156.86,166.71) PR513.2 ; PU701.16 v2(135.02,155.7)
  BOTTOM w0.254: v3(144.08,163.61) 143.65,164.04 141.82,164.04 139.03,161.25 137.71,161.25 135.5,159.04 135.5,156.18 v2(135.02,155.7)
SUS_ON: length 360.7
  TOP w0.102: v2(195.19,123.14) 195.19,123.41 195.41,123.64 U37.B60 ; v2(199.13,127.05) 199.13,127.6 199.46,127.93 R308.2 ; v3(200.22,109.97) 200.04,110.15 v6(198.07,110.15) R422.1
  IN2 w0.102: v2(195.19,123.14) 195.73,123.68 198.54,123.68 199.23,123 199.23,118.68 200.17,117.74 200.17,115.12 200.22,115.07 v3(200.22,109.97) 202.94,107.25 202.94,105.06 203.77,104.22 203.77,99.92 206.24,97.46 206.24,88.54 208.98,85.8 208.98,84.32 210.71,82.59 210.71,81.63 213.96,78.38 213.96,71.86 213.58,71.48 213.5,71.4 213.43,71.32 213.25,71.15 213.25,70.12 213.25,67.66 213.92,66.99 214.5,66.41 214.62,66.41 217.06,63.97 217.06,57.95 214.09,54.98 214.09,52.79 215.26,51.62 215.26,50.97 215.26,48.86 215.28,48.83 215.28,48.83 217.11,47 217.12,46.99 217.13,46.98 218.2,45.91 218.74,45.91 220.56,44.08 220.56,41.77 220.84,41.49 223.69,41.49 224.53,40.65 224.53,39.69 227.98,36.23 227.98,35.72 229.76,33.95 229.76,24.83 230.75,23.84 230.75,16.32 226.33,11.9 152.31,11.9 150.3,9.89 140.41,9.89 138.3,12 116.73,12 113.83,14.9 79.1,14.9 77,17 77,20.4 75.61,21.79 65.59,21.79 65.32,22.06 54.42,22.06 54.32,22.16 43.25,22.16 42.69,22.72 39.73,22.72 37.25,20.23 35.45,20.23 v3(34.69,19.47)
  IN3 w0.102: v2(195.19,123.14) 195.19,123.45 195.32,123.58 195.96,123.58 196.42,124.04 196.42,124.33 199.13,127.04 v2(199.13,127.05)
  BOTTOM w0.102: v3(34.69,19.47) 33.93,20.23 32.88,20.23 32.45,19.8 32.45,19.23 31.55,18.33 31.55,14.68 32.84,13.39 PR108.1
SUS_STAT#/LPCPD#: length 20.3
  TOP w0.102: RC74.2 182.24,74.89 v1(181.75,74.89) 181.6,74.89 v2(180.89,75.6)
  IN2 w0.076: 170.88,70.14 170.88,70.07 169.92,69.11 166.85,69.11 v2(166.49,69.47)
  IN2 w0.102: 170.88,70.14 171.22,70.48 172.74,70.48 173.7,71.44 174.05,71.44 175.47,72.86 176.43,72.86 177.71,74.14 179.81,74.14 180.89,75.22 v2(180.89,75.6)
  BOTTOM w0.076: v2(166.49,69.47) 166.19,69.77 UC1.AG4
SUSACK#: length 89.6
  TOP w0.102: U37.A58 198.18,124.39 v2(198.26,124.47)
  IN2 w0.102: v2(211.27,81.65) 211.27,82.36 209.36,84.26 209.36,85.74 206.47,88.64 206.47,97.55 204,100.02 204,104.32 203.17,105.16 203.17,107.63 201.23,109.56 200.93,109.87 200.93,114.74 200.4,115.28 200.4,117.84 199.53,118.7 199.53,123.2 v2(198.26,124.47)
  BOTTOM w0.102: v2(211.27,81.65) v1(211.27,80.89) 211.04,80.66 207.31,80.66 205.96,79.31 203.65,79.31 202.28,77.94 201.39,77.94 200.55,77.1 200.55,75.5 199.72,74.67 197.44,74.67 197.25,74.87 197.25,75.78 197.09,75.93 192.95,75.93 192.04,76.85 190.08,76.85 189.45,76.21 186.48,76.21 186.33,76.06 186.33,75.3 185.87,74.84 185.11,74.84 184.93,75.02 184.93,75.68 184.61,76 180.04,76 RC98.2 RC86.1
SUSACK#_R: length 39.2
  TOP w0.102: RC82.2 184.22,62.08 183.8,62.49 v2(183.4,62.49)
  IN2 w0.076: 170.88,69.76 170.07,68.95 169.61,68.95 169.26,68.59 v2(169.26,68.24)
  IN2 w0.102: v2(178.55,73.7) 177.48,72.63 175.61,72.63 174.18,71.21 173.79,71.21 172.82,70.24 171.36,70.24 170.88,69.76
  IN3 w0.076: v2(169.26,68.24) 169.26,67.91 170.17,66.99 170.17,66.36 169.84,66.03 168.93,66.03 168.67,65.77 168.67,65.06 170.4,63.33 170.4,63.03 170.81,62.62 171.03,62.62
  IN3 w0.102: v2(183.4,62.49) 182.94,62.95 180.67,62.95 178.53,60.82 174.54,60.82 172.74,62.62 171.03,62.62
  BOTTOM w0.076: v2(169.26,68.24) 169.26,68.34 169.01,68.59 168.29,68.59 168.26,68.62 168.01,68.62 167.73,68.34 UC1.AK2
  BOTTOM w0.102: v2(178.55,73.7) 178.71,73.85 RC86.2 ; v2(183.4,62.49) 183.76,62.14 v1(183.91,62.14)
SW1: length 16.9
  IN2 w1.016: 226.82,161.51 223.94,164.4 218.35,164.4 218.35,164.38 216.68,162.7 215.2,162.7 212.84,160.34
  vias: v2(213.12,159.44) v2(213.12,158.86) v2(227.39,157.42) v2(227.39,156.79) v2(227.39,156.09) v2(227.52,161.81) v2(227.52,160.54) v2(227.52,159.65) v2(228.03,161.17) v2(228.03,160.15) v2(228.03,158.58) v2(228.03,157.92) v2(228.03,157.11) v2(228.03,156.34) v2(228.05,159.24) v2(228.51,160.67) v2(228.54,159.68) v2(228.59,158.81) v2(228.59,158.18) v6(229.35,161.99)
SW2: length 13
  IN2 w1.016: 213.66,151.88 214.07,151.88 214.07,151.88 216.43,151.88 217.14,152.59 225.34,152.59 226.05,151.88
  vias: v1(228.4,151.62) v2(213.23,154.01) v2(213.22,153.35) v2(226.12,152.03) v2(226.76,152.03) v2(227.52,154.06) v2(227.52,153.42) v2(227.52,152.79) v2(227.52,150.38) v2(227.52,149.74) v2(227.52,149.11) v2(228.15,154.06) v2(228.15,153.42) v2(228.15,152.79) v2(228.15,150.38) v2(228.15,149.74) v2(228.15,149.11)
SW_1.35V: length 7.9
  TOP w1.016: 51.04,18.45 43.15,18.45
  vias: v1(55.44,20) v2(42.05,18.07) v2(42.69,18.07) v2(51.6,18.38) v2(52.19,18.38)
SW_++VDDRP: length 14.2
  IN2 w1.016: 34.56,34.2 35.07,34.71 38.25,34.71 40.91,37.37 40.91,40.86
  BOTTOM w0.102: PC705.1 33.5,40.61 v1(33.1,41.01)
  BOTTOM w0.254: PU700.8 34.83,32.67 v2(34.77,32.74)
  vias: v2(34.77,33.33) v2(40.47,42.2) v2(41.08,42.2)
SW_+V1.05SP: length 1.5
  BOTTOM w0.102: v6(85.03,61.86) 84.78,62.11 84.78,63.28
SW_DPB_AUX: length 40.4
  TOP w0.089: C94.2 160.84,154.58 161.36,154.06 161.99,154.06 162.31,154.06 162.68,154.42 v3(163.31,154.42) ; U6.J13 181.16,163.06 181.16,163.64 181.36,163.84 181.36,164.03 181.6,164.27 181.6,164.71 v3(181.19,165.11) 181.07,165.11 181.03,165.15 181.03,165.51 181.48,165.96 182.16,165.96 v3(182.16,165.96) 182.63,165.96 183.28,166.62 183.28,168.89 182.99,169.18 182.99,169.7 183.1,169.81 183.26,169.81 183.37,169.7 R47.1
  IN3 w0.089: v3(163.31,154.42) 163.31,154.61 163.03,154.89 163.03,155.37 164.81,157.15 164.81,159.79 165.47,160.44 165.47,160.83 165.78,161.15 165.78,163.14 166.61,163.97 174.17,163.97 175.93,165.72 178.88,165.72 179.77,164.83 180.91,164.83 181.08,165 v3(181.19,165.11)
SW_DPB_AUX#: length 40.4
  TOP w0.089: C95.2 161.76,155.64 161.66,155.74 161.38,155.74 161.29,155.65 161.29,154.68 161.53,154.45 162.15,154.45 162.52,154.82 163.49,154.82 163.84,154.47 v3(164.13,154.47) ; U6.J14 180.73,163.39 180.58,163.54 180.58,163.75 180.73,163.89 180.85,163.89 180.97,164.01 180.97,164.2 181.17,164.4 v3(181.17,164.45) 180.64,164.98 180.64,165.68 181.32,166.36 182.46,166.36 182.89,166.78 v3(182.89,168.36) 182.89,168.73 182.6,169.02 182.6,169.42 R44.1
  IN3 w0.089: v3(164.13,154.47) 163.77,154.47 163.69,154.55 163.69,154.7 163.36,155.03 163.36,155.23 165.14,157.01 165.14,159.65 165.8,160.3 165.8,160.7 166.11,161.01 166.11,163 166.75,163.64 174.31,163.64 176.06,165.39 178.75,165.39 179.63,164.5 181.12,164.5 v3(181.17,164.45)
SW_DPB_AUX#_C: length 1.9
  TOP w0.089: C95.1 161.76,156.83 162.07,157.14 U11.5
SW_DPB_AUX_C: length 2.1
  TOP w0.089: C94.1 160.12,156.9 U11.2
SW_DPC_AUX: length 16.6
  TOP w0.089: U6.B11 176.01,161.72 175.4,161.72 175.28,161.84 174.11,161.84 173.88,161.61 v1(172.93,161.61) 172.48,161.61 v3(172.38,161.71) R92.1 ; C98.2 166.26,154.57 v3(166.36,154.47)
  IN3 w0.089: v3(166.36,154.47) 166.53,154.63 166.53,156.95 169.87,160.29 169.87,161.03 170.39,161.56 172.23,161.56 v3(172.38,161.71)
SW_DPC_AUX#: length 16.7
  TOP w0.089: R91.1 172.13,160.82 v3(172.38,161.07) 172.52,161.21 174.16,161.21 v1(174.21,161.26) 174.39,161.44 174.64,161.44 174.64,161.44 175.28,161.44 U6.A11 ; v3(167.02,154.47) 166.71,154.78 166.71,155.69 166.79,155.77 167.01,155.77 167.17,155.61 C99.2
  IN3 w0.089: v3(167.02,154.47) 166.86,154.63 166.86,156.81 170.2,160.15 170.2,160.9 170.53,161.23 172.23,161.23 v3(172.38,161.07)
SW_DPC_AUX#_C: length 2
  TOP w0.089: U13.5 167.65,156.68 C99.1
SW_DPC_AUX_C: length 2.1
  TOP w0.089: C98.1 165.7,156.75 U13.2
SW_LAN_TX0+: length 159.2
  TOP w0.089: U23.38 192.42,173.29 v2(192.37,173.33)
  IN1 w0.089: v2(330.28,171.93) 330.28,173.37 329.75,173.91 328.84,174.82 275.45,174.82 274.76,174.13 266.86,174.13 264.09,176.9 258.62,176.9 240.58,176.9 232.88,184.59 225.34,184.59 219.48,178.74 213.27,178.74 211.29,176.75 211.29,176.75 211.24,176.71 210.58,176.05 210.58,176.04 209.73,175.2 206.73,175.2 205.05,176.87 194.72,176.87 192.37,174.52 v2(192.37,173.33)
  BOTTOM w0.089: JIO1.31 334.99,170.45 334.94,170.5 333.87,170.5 v1(332.67,171.7) 331.75,172.62 330.51,172.62 330.28,172.4 v2(330.28,171.93)
SW_LAN_TX0-: length 159.1
  TOP w0.089: v2(192.96,173.33) 192.81,173.18 192.81,172.93 192.92,172.82 U23.37
  IN1 w0.089: v2(329.7,171.93) 329.95,172.19 329.95,173.24 329.51,173.68 328.7,174.49 275.59,174.49 274.9,173.8 266.72,173.8 263.95,176.57 258.76,176.57 240.44,176.57 232.75,184.26 225.48,184.26 219.62,178.41 213.41,178.41 211.62,176.62 210.91,175.91 209.87,174.87 206.59,174.87 204.92,176.54 194.86,176.54 192.7,174.39 192.7,173.56 192.93,173.33 v2(192.96,173.33)
  BOTTOM w0.089: v2(329.7,171.93) 329.75,171.93 329.89,172.07 329.89,172.56 330.34,173.01 v1(330.71,173.01) 331.92,173.01 332.64,172.29 332.95,171.98 334.03,170.9 334.89,170.9 334.94,170.95 JIO1.29
