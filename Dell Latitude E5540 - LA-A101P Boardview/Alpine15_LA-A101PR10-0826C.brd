# Allegro board Alpine15_LA-A101PR10-0826C.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
CLKA0#: length 47.7
  TOP w0.102: v2(35.09,106.97) 35.28,106.78 35.28,106.69 35.09,106.5 34.46,106.5 34.39,106.44 33.66,106.44 33.2,105.98 33.2,105.92 32.78,105.5 UV5.K7
  IN1 w0.097: v2(51.51,107.72) 51.15,108.07 47.65,108.07 47.45,108.27 47.45,108.42 47.32,108.55 47.09,108.55 46.96,108.42 46.96,108.27 46.76,108.07 46.33,108.07 46.13,108.27 46.13,108.66 46.03,108.75 45.74,108.75 45.64,108.66 45.64,108.27 45.44,108.07 45.01,108.07 44.81,108.27 44.81,108.66 44.71,108.75 44.42,108.75 44.32,108.66 44.32,108.27 44.12,108.07 42.71,108.07 38.9,104.26 38.9,103.42 38.06,102.58 33.78,102.58 32.6,103.76 32.6,105.35 33.69,106.44 34.95,106.44 35.17,106.65 35.17,106.91 35.1,106.97 v2(35.09,106.97) 35.39,107.27 35.39,107.45 35.24,107.6 34.92,107.6 33.98,108.54 33.22,108.54 32.56,109.19 32.56,110.13 33.13,110.69 33.78,110.69 34.18,111.09 34.18,111.71 v2(33.98,111.92)
  BOTTOM w0.102: RV2708.2 RV2706.2 33.84,113.11 34.17,112.78 34.17,112.11 v2(33.98,111.92) ; v2(35.09,106.97) 35.23,107.11 35.23,107.2 34.31,108.12 33.82,108.12 33.7,108.24 33.18,108.24 UV4.K7
  BOTTOM w0.122: UV1.D25 51.13,108.15 51.51,107.77 v2(51.51,107.72)
CLKA1: length 53
  TOP w0.102: RV2718.2 35.57,85.28 RV2717.1 35.19,85.69 35.19,86.03 v2(35.32,86.16) ; UV7.J7 33.44,89.85 33.44,90.16 33.77,90.49 34.51,90.49 34.56,90.54 35.29,90.54 35.55,90.8 35.55,90.96 v2(35.8,91.21)
  IN1 w0.097: v2(35.32,86.16) 35.11,86.37 35.11,86.63 34.88,86.86 33.46,86.86 32.68,87.64 32.68,89.37 33.82,90.52 35.27,90.52 35.52,90.77 35.52,90.93 v2(35.8,91.21) 35.51,91.51 35.51,91.77 35.25,92.03 35,92.03 34.55,92.47 31.71,92.47 31.58,92.6 31.58,94.24 31.69,94.35 32.28,94.35 32.51,94.58 32.51,94.95 32.28,95.18 31.69,95.18 31.58,95.29 31.58,95.63 31.71,95.76 36.89,95.76 37.72,96.59 43.27,96.59 48.01,101.32 53.44,101.32 53.58,101.46 53.85,101.46 53.97,101.34 v5(53.97,101.08)
  BOTTOM w0.102: UV6.J7 33.5,92.92 33.5,92.76 33.55,92.71 33.8,92.71 33.93,92.58 34.42,92.58 35.5,91.5 35.5,91.22 35.62,91.1 35.69,91.1 v2(35.8,91.21)
  BOTTOM w0.122: UV1.N22 53.61,100.68 53.97,101.04 v5(53.97,101.08)
CLKA1#: length 53.2
  TOP w0.102: v2(34.74,86.16) 35,85.9 35,85.62 RV2717.2 34.68,85.28 RV2719.2 ; UV7.K7 32.79,89.75 33.21,90.17 33.21,90.23 33.67,90.69 34.4,90.69 34.47,90.75 35.19,90.75 35.29,90.86 35.29,91.03 v2(35.1,91.22)
  IN1 w0.097: v2(34.74,86.16) 34.94,86.36 34.94,86.55 34.81,86.68 33.39,86.68 32.5,87.57 32.5,89.45 33.75,90.7 35.19,90.7 35.34,90.85 35.34,90.98 v2(35.1,91.22) 35.32,91.44 35.32,91.71 35.18,91.85 34.92,91.85 34.48,92.29 31.64,92.29 31.41,92.52 31.41,94.31 31.62,94.52 32.21,94.52 32.33,94.65 32.33,94.88 32.21,95.01 31.62,95.01 31.41,95.22 31.41,95.71 31.64,95.94 36.82,95.94 37.65,96.77 43.2,96.77 47.94,101.5 53.37,101.5 53.51,101.64 53.69,101.64 v5(53.95,101.9)
  BOTTOM w0.102: v2(35.1,91.22) 35.24,91.36 35.24,91.45 34.33,92.37 33.84,92.37 33.71,92.49 33.19,92.49 UV6.K7
  BOTTOM w0.122: v5(53.95,101.9) 53.95,101.89 53.57,101.51 UV1.M22
CLKRQ_GPU#: length 7.8
  TOP w0.102: v2(68.11,94.45) 69.46,94.45 v1(70.08,95.06) 70.66,95.65 QC11.4 71.61,96.32 RV2433.2
  BOTTOM w0.102: UV1.AC6 67.29,92.8 67.99,92.8 68.11,92.92 v2(68.11,94.45)
CLKRUN#: length 137.1
  TOP w0.102: v3(178.43,128.15) 178.43,130.27 v1(177.25,131.44) 176.18,132.52 176.18,134.06 177.45,135.33 U25.15 ; U37.B20 187.51,126.66 188.03,126.66 188.15,126.78 v2(188.61,126.78) ; U38.A32 171.64,127.94 172.43,128.73 v2(172.43,129.13)
  IN1 w0.076: 169.21,75.41 168.67,75.41 168.14,74.88 v2(165.68,74.88)
  IN1 w0.097: v2(188.61,126.78) 188.49,126.9 186.27,126.9 185.81,127.36 179.22,127.36 v3(178.43,128.15) 177.61,128.15 176.51,127.05 174.03,127.05 172.43,128.65 v2(172.43,129.13) ; v3(179.47,76.9) 179.05,77.32 177.42,77.32 176.77,76.67 176.77,76.14 176.02,75.39 174.29,75.39 174.01,75.67 170.97,75.67 170.71,75.41 169.21,75.41
  IN3 w0.102: v3(204.84,106.46) 204.84,105.57 201.39,102.12 201.39,98.89 196.64,94.14 189.93,94.14 189.45,94.63 185.99,94.63 185.32,93.95 184.17,93.95 181.09,90.87 181.09,83.43 179.19,81.52 179.19,77.18 v3(179.47,76.9)
  BOTTOM w0.076: UC1.V5 165.51,74.7 v2(165.68,74.88)
  BOTTOM w0.102: RC80.2 179.7,78.12 179.7,77.43 179.47,77.2 v3(179.47,76.9) ; v3(204.84,106.46) 204.84,106.87 198.95,112.76 188.79,112.76 183.97,117.57 183.97,119.66 183.3,120.33 183.3,125.79 183.66,126.15 185.82,126.15 186.31,126.64 188.47,126.64 v2(188.61,126.78)
CODEC_IRQ: length 7.6
  TOP w0.076: RC154.1 171.4,75.07 169.41,77.06 168.74,77.06 v1(167.15,78.65) 166.76,78.65 v2(166.58,78.47)
  BOTTOM w0.076: v2(166.58,78.47) 166.19,78.08 UC1.L4
CPU_DETECT#: length 177.5
  TOP w0.076: v2(128.92,84.06) v1(128.92,84.71)
  TOP w0.102: R284.2 194.82,130.82 v2(195.01,130.63) 194.56,130.18 194.56,129.8 194.84,129.53 U37.A3
  IN1 w0.097: v2(195.01,130.63) 195.59,131.21 199.5,131.21 202.03,128.68 202.03,125.14 202.6,124.57 202.6,123.66 199.89,120.95 199.89,118.37 198.61,117.09 198.61,116.58 196.09,114.05 195.56,114.05 194.67,113.16 192.59,113.16 191.13,111.7 191.13,111.46 190.4,110.73 190.07,110.73 190.05,110.75 189.76,110.75 189.75,110.73 189.41,110.73 189.4,110.75 188.94,110.75 187.81,109.62 185.92,109.62 185.42,110.13 182.88,110.13 177.8,105.04 175.49,105.04 173.67,103.22 165.98,103.22 165.33,103.86 161.72,103.86 160.66,102.8 153.16,102.8 152.24,103.72 152.24,104.99 151.06,106.16 150.82,106.16 150.48,106.5 131.37,106.5 v3(130.06,105.19)
  IN2 w0.102: v3(130.06,105.19) 130.06,104.81 132.63,102.25 144.43,102.25 145.69,101 145.69,98.72 145.1,98.13 145.1,93.36 148.96,89.5 148.96,85.7 149.75,84.92 149.75,77.99 148.02,76.26 133.34,76.26 132.91,76.69 130.14,76.69 129.73,77.1 129.73,83.25 v2(128.92,84.06)
  BOTTOM w0.076: v2(128.92,84.06) 128.92,83.83 129.18,83.57 129.65,83.57 129.72,83.5 130.3,83.5 130.59,83.21 130.59,82.98 UC1.D61
CPU_DPB_AUX: length 116.6
  TOP w0.102: C19.1 183.15,150.58 183.28,150.46 183.28,150.18 182.92,149.82 182.41,149.82 179.26,146.67 178.49,146.67 178.48,146.68 177.94,146.68 177.93,146.67 176.8,146.67 175.17,145.05 163.22,145.05 162.33,144.16 161.73,144.16 161.64,144.25 v4(161.64,144.46) ; v2(168.33,95.39) 168.34,95.39 168.94,95.99 168.94,96.26 168.85,96.35 RC153.2
  BOTTOM w0.076: UC1.B5 165,83.75 165.14,83.62 165.27,83.62 165.38,83.72 165.38,84 165.09,84.28 165.09,84.83 165.46,85.2 165.46,87.19 166.85,88.58 166.85,88.62 166.87,88.63
  BOTTOM w0.102: v4(161.64,144.46) 161.48,144.31 161.2,144.31 160.79,143.89 160.79,141.38 153.34,133.94 153.34,133.12 147.07,126.85 147.07,120.42 147.41,120.07 147.41,113.07 149.04,111.44 149.04,109.55 145.94,106.46 145.94,104.01 146.75,103.2 151.7,103.2 151.97,102.92 157.25,102.92 161.75,98.42 162.37,98.42 162.93,97.87 162.93,97.37 163.36,96.94 164.68,96.94 165.15,97.41 167.59,97.41 168.33,96.67 v2(168.33,95.39) 168.33,93.51 167.07,92.26 167.07,88.84 166.87,88.63
CPU_DPB_AUX#: length 116.5
  TOP w0.102: C20.1 183.49,150.29 183.49,150.09 183.01,149.6 182.5,149.6 179.35,146.46 v3(178.21,146.46) 176.89,146.46 175.26,144.83 163.31,144.83 162.42,143.94 161.85,143.94 v3(161.66,143.75) ; RC147.2 169.15,96.46 169.15,95.9 168.93,95.67 v2(168.93,95.41)
  BOTTOM w0.076: UC1.C5 165.37,83.48 165.54,83.65 165.54,84.07 165.26,84.35 165.26,84.76 165.62,85.13 165.62,87.12 166.97,88.47 167.01,88.47 167.02,88.48
  BOTTOM w0.102: 167.02,88.48 167.29,88.75 167.29,92.17 168.55,93.42 168.55,95.03 v2(168.93,95.41) 168.55,95.8 168.55,96.76 167.68,97.62 165.06,97.62 164.59,97.15 163.45,97.15 163.15,97.46 163.15,97.95 162.46,98.64 161.84,98.64 157.34,103.14 152.06,103.14 151.79,103.42 146.84,103.42 146.16,104.09 146.16,106.37 149.25,109.46 149.25,111.53 147.63,113.16 147.63,120.16 147.29,120.51 147.29,126.76 153.56,133.03 153.56,133.85 161,141.29 161,143.8 161.29,144.09 161.43,144.09 161.47,144.06 161.6,144.06 161.66,143.99 v3(161.66,143.75)
CPU_DPB_AUX#_C: length 6
  TOP w0.102: C20.2 183.54,151.74 183.54,152.27 183.09,152.73 182.4,152.73 180.51,154.62 180.51,155.27 U6.H2
CPU_DPB_AUX_C: length 6
  TOP w0.102: U6.H1 180.19,154.64 182.32,152.5 v3(182.69,152.5) 183.01,152.5 183.33,152.18 183.33,151.34 183.2,151.22 183.07,151.22 182.9,151.4 C19.2
CPU_DPB_CTRLCLK: length 18.3
  TOP w0.102: v4(166.72,95.36) 166.56,95.2 166.38,95.2 166.19,95.39 166.19,98.22 166.75,98.78 RP1.8
  BOTTOM w0.076: UC1.B9 162.55,83.91 162.98,84.35 162.98,85.01 163.3,85.32 163.3,85.61 163.19,85.73 163.19,88.51 163.24,88.56 163.24,88.56 164.55,89.87 164.55,89.89 164.57,89.9
  BOTTOM w0.102: 164.57,89.9 165.29,90.63 165.29,94.63 165.73,95.06 166.41,95.06 v4(166.72,95.36)
CPU_DPB_CTRLDAT: length 18.7
  TOP w0.102: RP1.7 166.25,98.6 165.97,98.32 v3(165.97,97.52) 165.97,95.29 166.3,94.96 166.49,94.96 v3(166.74,94.7)
  BOTTOM w0.076: 164.73,89.74 164.71,89.73 164.7,89.73 163.39,88.42 163.39,85.81 163.5,85.7 163.5,85.24 163.15,84.88 163.15,84.24 162.79,83.89 UC1.C9
  BOTTOM w0.102: v3(166.74,94.7) 166.61,94.83 165.82,94.83 165.52,94.53 165.52,90.54 164.73,89.74
CPU_DPC_AUX: length 19.1
  TOP w0.076: v2(164.76,87.16) 164.94,87.16 165.62,87.84 170.04,87.84 171.17,88.98
  TOP w0.102: RC155.2 171.59,92.24 171.69,92.14 173.17,92.14 173.35,91.96 173.35,91.71 173.17,91.53 v1(172.47,91.53) 171.77,91.53 171.59,91.35 171.59,91.1 171.77,90.92 172.3,90.92 172.48,90.74 172.48,90.49 172.3,90.31 171.69,90.31 171.59,90.21 171.59,89.39 171.17,88.98
  BOTTOM w0.076: UC1.A6 164.68,84.85 164.68,84.97 164.91,85.2 164.91,87.01 v2(164.76,87.16)
CPU_DPC_AUX#: length 19.1
  TOP w0.076: 171.21,87.73 171.16,87.68 165.79,87.68 164.79,86.68 v2(164.3,86.68)
  TOP w0.102: RC149.2 177.05,92.14 176.85,91.93 175.42,91.93 v6(172.85,89.37) 171.21,87.73
  BOTTOM w0.076: UC1.B6 164.02,84.01 164.05,84.03 164.05,84.67 164.35,84.97 164.35,86.63 v2(164.3,86.68)
CPU_PWR_DEBUG#: length 71.5
  TOP w0.102: v3(115.76,67.73) 116.53,66.97 118.38,66.97 120.11,65.24 120.11,63.16 104.48,47.53 RC108.1
  IN1 w0.097: v3(115.76,67.73) 115.76,68.12 117.94,70.29 v2(118.01,70.29)
  BOTTOM w0.076: UC1.H59 131.82,80.7 130.77,80.7 130.64,80.83 129.87,80.83 129.7,80.66 128.71,80.66 128.57,80.52 128.13,80.52
  BOTTOM w0.102: 128.13,80.52 127.92,80.3 123.54,80.3 123.15,80.69 121.73,80.69 RC258.1 RC253.2 119.73,79.82 119.62,79.72 118,79.72 117.66,79.37 117.66,79.35 116.44,78.13 112.93,78.13 v6(111.5,76.7) 111.5,73.73 113.02,72.21 114.84,72.21 115.81,73.19 117.26,73.19 118.01,72.44 v2(118.01,70.29)
CPU_PWR_DEBUG#_R: length 6.3
  TOP w0.102: JXDP1.45 98.7,48.36 99.54,47.53 v1(99.8,47.53) RC108.2
CPU_VTT_ON: length 4.5
  TOP w0.102: R305.2 v1(186.03,130.23) 186.6,129.65 187.03,129.65 188.08,128.6 U37.B17
CPU_XDP_PRDY#: length 64.3
  TOP w0.102: v3(96.97,42.3) 97.15,42.12 v1(97.15,39.03) 96.48,38.36 JXDP1.5
  IN3 w0.102: v2(126.56,79.54) 124.91,77.89 124.07,77.89 123.59,77.41 123.59,75.86 123.16,75.42 123.16,74.41 122.57,73.82 122.14,73.82 121.5,73.19 120.21,73.19 119.7,72.68 118.3,72.68 117.92,73.06 116.78,73.06 115.15,71.44 115.15,62.27 107.53,54.65 107.53,50.08 100.02,42.56 97.22,42.56 v3(96.97,42.3)
  BOTTOM w0.076: UC1.J62 129.93,79.62 129.63,79.33 129.13,79.33 129.13,79.33 127.44,79.33 127.43,79.33 127.09,79.33
  BOTTOM w0.102: 127.09,79.33 126.76,79.33 v2(126.56,79.54)
CPU_XDP_PREQ#: length 68
  TOP w0.102: JXDP1.3 93.8,37.86 v2(93.12,38.54)
  IN3 w0.102: v2(93.12,38.54) 93.27,38.39 93.97,38.39 95.82,40.25 95.82,42.07 96.99,43.24 100.37,43.24 107.25,50.13 107.25,54.69 114.93,62.36 114.93,71.64 116.65,73.37 118.25,73.37 118.56,73.06 119.73,73.06 120.11,73.44 120.92,73.44 121.21,73.74 121.21,74.6 122.86,76.25 122.86,77.27 v3(123.05,77.46)
  BOTTOM w0.076: 127.09,78.14 127.45,78.14 v1(127.56,78.25) 127.9,78.6 129.03,78.6 129.21,78.42 129.7,78.42 129.71,78.43 129.72,78.43 UC1.K62
  BOTTOM w0.102: 127.09,78.14 123.74,78.14 v3(123.05,77.46) 122.67,77.07 RC120.2
CPU_XDP_TCLK: length 80.5
  TOP w0.076: v2(131.13,82.33) 129.55,82.33 v6(129.14,81.91) 128.77,81.55 127.75,81.55
  TOP w0.102: v3(108.04,79.34) 108.09,79.29 115.29,79.29 116.06,80.05 116.74,80.05 117.18,80.49 118.37,80.49 118.94,81.06 124.64,81.06 125.12,81.55 126.69,81.55 127.75,81.55 ; v3(99.2,78.52) 99.2,78.47 101.55,76.12 102.12,75.55 102.68,74.99 102.68,64.91 106.42,61.17 106.42,55.89 104.18,53.66 100.96,53.66 98.76,53.66 96.47,51.36 JXDP1.57
  IN1 w0.097: v3(99.2,78.52) 105.49,78.52 106.7,79.74 107.64,79.74 v3(108.04,79.34)
  BOTTOM w0.076: v2(131.13,82.33) 131.46,81.99 UC1.E60
  BOTTOM w0.102: RC124.1 98.05,83.69 98.07,83.66 RC97.1 98.96,83.53 98.5,83.07 98.5,81.92 RC127.2 98.31,80.83 98.31,79.41 v3(99.2,78.52)
CPU_XDP_TDI: length 21.5
  IN3 w0.102: v3(117.21,82.51) 113.96,79.26 108.86,79.26 108.28,78.68 102.99,78.68 v3(101.87,79.79)
  BOTTOM w0.102: v3(117.21,82.51) 117.44,82.28 v1(117.72,82.28) RC209.2 RC119.2 ; v3(101.87,79.79) 102.06,79.61 UC6.6
CPU_XDP_TDI_R: length 11.4
  TOP w0.102: v6(123.5,81.58) 123.31,81.77 v2(123.31,82.16)
  BOTTOM w0.076: 126.84,81.27 127.63,81.27 127.78,81.12 UC1.F63
  BOTTOM w0.102: 126.84,81.27 124.02,81.27 123.31,81.98 v2(123.31,82.16) 122.88,82.16 122.42,81.7 120.3,81.7 RC209.1
CPU_XDP_TDO: length 24.5
  IN3 w0.102: v2(109.54,78.5) 109.49,78.45 101.71,78.45 v3(100.85,79.3)
  BOTTOM w0.102: RC208.2 RC122.2 119.73,81.42 119.45,81.7 117.85,81.7 117.39,81.24 117.39,79.54 116.41,78.56 v1(111.06,78.56) 109.6,78.56 v2(109.54,78.5) ; v3(100.85,79.3) 100.56,79.01 UC6.3
CPU_XDP_TDO_R: length 9
  TOP w0.102: v2(126.9,80.68) v6(126.28,80.68)
  BOTTOM w0.076: 126.9,80.68 126.98,80.76 127.75,80.76 127.82,80.83 129.63,80.83 129.93,81.12 UC1.F62
  BOTTOM w0.089: 125.99,80.69 125.99,80.68 v2(126.9,80.68) 126.9,80.68
  BOTTOM w0.102: RC208.1 122.96,81.2 123.39,80.77 125.91,80.77 125.99,80.69
CPU_XDP_TMS: length 34.8
  TOP w0.102: v3(103.5,77.63) v6(103.5,76.96)
  IN3 w0.102: v3(103.5,77.63) 103.83,77.96 109.72,77.96 110.76,79.01 114.29,79.01 118.63,83.35 120.08,83.35 v3(120.62,83.88)
  BOTTOM w0.076: UC1.E61 130.74,81.91 130.45,82.21 129.66,82.21 129.64,82.22 128.65,82.22 127.42,83.45 126.84,83.45
  BOTTOM w0.102: 126.84,83.45 126.28,83.45 126.03,83.7 123.51,83.7 123.28,83.48 123.28,82.96 122.61,82.28 RC118.2 122.14,82.99 121.25,83.88 v3(120.62,83.88) ; v3(103.5,77.63) 103.5,77.3 103.09,76.9 UC6.8
CPU_XDP_TRST#: length 42.8
  TOP w0.076: v2(131.77,82.32) 131.43,81.97 130.98,81.97 130.89,82.07 130.31,82.07 129.56,81.32 127.75,81.32
  TOP w0.102: 127.75,81.32 125.24,81.32 124.76,80.83 119.45,80.83 v6(119.22,80.61) 118.82,80.21 117.23,80.21 116.84,79.82 116.24,79.82 115.34,78.93 107.79,78.93 v3(107.38,79.34)
  IN1 w0.097: v3(98.43,74.62) 98.9,75.09 99.54,75.09 100.2,75.75 101.69,75.75 102.84,76.9 102.84,77.66 103.48,78.3 105.58,78.3 106.61,79.34 v3(107.38,79.34)
  BOTTOM w0.076: UC1.E59 132.11,81.97 v2(131.77,82.32)
  BOTTOM w0.254: UC6.11 101.06,75.17 100.47,74.58 100.47,74.51 99.61,73.64 RC135.1 RC131.2 98.44,73.87 98.44,74.61 v3(98.43,74.62)
CRT_SWITCH: length 65.9
  TOP w0.102: v1(198.95,118.71) 198.4,118.71 v2(198.39,118.7) 197.69,119.4 197.21,119.4 196.98,119.64 U37.B52
  IN1 w0.097: v3(184.85,154.19) 184.85,153.8 188.97,149.68 188.97,145.12 188.99,145.1 188.99,142.38 194.25,137.12 v3(195.42,137.12)
  IN3 w0.102: v3(195.42,137.12) 199.15,133.39 199.15,130.11 202.61,126.65 202.61,123.68 199.38,120.45 199.38,119.48 198.6,118.7 v2(198.39,118.7) ; v3(190.19,168.82) 189.8,168.82 188.64,167.66 188.64,166.16 187.04,164.56 187.04,162.34 185.59,160.9 185.59,154.93 v3(184.85,154.19)
  BOTTOM w0.102: 189.41,168.95 190.06,168.95 v3(190.19,168.82)
CS_1.35V: length 4.4
  BOTTOM w0.102: PR101.2 38.19,17.28 37.77,17.7 v1(37.77,19.43)
  BOTTOM w0.203: PU100.13 38.41,15.25 38.41,15.95 38.19,16.17 PR101.2
CSN1: length 22.7
  BOTTOM w0.203: PC318.2 87.5,91.9 86.93,91.32 PU300.18
  BOTTOM w0.254: PC318.2 PC320.2 89.59,91.9 89.93,92.24 90.39,92.24 91.43,93.28 v1(91.43,93.69) 91.43,94.4 92.45,95.41 93.16,95.41 PR333.2 93.92,94.65 PR329.2 94.3,93.6 94.72,93.18 95.11,93.18 95.8,93.86 95.8,96.3 96.59,97.09 99.46,97.09 99.83,96.72 PL300.3
CSP1: length 11.7
  BOTTOM w0.203: PC318.1 87.91,92.81 86.82,91.72 PU300.17
  BOTTOM w0.254: PH301.1 PR328.2 93.67,96.43 PR333.1 93.03,95.8 v1(92.09,95.8) 91.02,94.73 91.02,93.46 90.19,92.62 89.49,92.62 PC320.1 PC318.1
CSS_GC: length 20.8
  TOP w0.102: v2(134.15,151.5) 134.27,151.5 135.96,149.81 v1(135.96,149.44)
  TOP w0.254: v3(120.03,152.66) PR403.1 ; v2(134.15,151.5) 134.15,152.46 133.92,152.7 PU701.10
  BOTTOM w0.254: v2(134.15,151.5) 133.7,151.95 127.63,151.95 126.58,150.91 121.77,150.91 v3(120.03,152.66)
CSSN_1: length 31
  TOP w0.254: PC408.2 117.23,157.65 PU402.1
  TOP w0.508: 122.27,150.63 PQ403.2 ; 122.27,150.63 122.27,152.13 122.69,152.56 PR418.1 123.03,153.42 v3(123.38,153.07) ; 122.27,150.63 122.27,147.67 121.86,147.26 PU401.5 120.85,147.26 120.34,146.76 PR408.1 ; PQ401.3 113.02,152.58 114.01,153.58 v1(114.56,153.58) v3(115.59,153.58) 115.59,155.01 115.87,155.29 116.31,155.29 116.96,155.94 PR410.2 116.99,156.41 PC408.2 115.89,157.42 PC409.1
  IN2 w0.508: v3(123.38,153.07) 123.1,153.35 118.79,153.35 118.38,152.95 116.22,152.95 v3(115.59,153.58)
CSSP_1: length 29.4
  TOP w0.254: PC408.1 117.73,157.6 v1(117.73,158.34) PU402.2
  TOP w0.508: PR411.2 118.84,148.04 116.53,148.04 115.87,148.7 115.87,150.33 PQ402.3 117.08,152.66 v3(118,153.58) 117.75,153.84 PC438.2 117.87,154.6 PR410.1 117.87,157.38 PC408.1 118.91,157.42 PC407.2 ; PQ403.5 124.53,150.63 v3(124.76,150.41) ; v2(123.36,154.03) 123.07,154.31 PR417.1
  IN2 w0.508: v2(123.36,154.03) 118.45,154.03 v3(118,153.58)
  IN3 w0.508: v2(123.36,154.03) 123.93,154.03 124.85,153.11 124.85,152.39 124.45,151.99 124.45,150.61 124.65,150.41 v3(124.76,150.41)
D_CLKRUN#: length 70.6
  TOP w0.102: U37.A19 185.55,126.39 v2(185.04,126.9) 184.72,126.58 184.72,126.25 184.24,125.76 RP5.3
  IN3 w0.102: v2(185.04,126.9) 185.04,126.88 185.06,126.9 185.06,136.44 186.12,137.5 186.12,143.51 188.36,145.74 188.36,150.84 188.36,150.84 188.36,151.03 187.27,152.11 187.14,152.25 187.14,156.75 188.69,158.3 188.69,159.7 188.03,160.36 188.03,164.23 188.35,164.55 190.2,164.55 191.48,165.84 191.48,168.32 192.12,168.95 192.12,171.89 191.76,172.24 191.76,173.76 193.1,175.1 193.1,179.25 193.97,180.12 195.85,180.12 196.03,179.95 196.03,179.77 195.85,179.59 v2(195.39,179.59)
  BOTTOM w0.102: v2(195.39,179.59) 195.42,179.56 195.77,179.56 196,179.34 196,178.17 196.45,177.72 JDOCK1.111
D_DLDRQ1#: length 70.7
  TOP w0.102: RP5.1 184.38,124.76 v2(184.42,124.73) ; v2(188.91,125.17) 188.39,124.64 U37.B24
  IN3 w0.102: v2(196.79,178.85) 197.91,177.73 197.91,172.94 194.5,169.53 194.5,167.58 196.36,165.72 196.36,159.27 195.85,158.76 195.85,155.88 195.85,155.3 195.45,154.9 194.84,154.29 194.27,154.29 194.26,154.29 193.64,154.29 192.95,153.61 192.95,152.76 190.21,150.02 190.21,145.66 188.92,144.36 188.92,141.02 188.78,140.89 188.74,140.85 188.74,135.39 188.74,128.84 189.14,128.44 189.14,127.29 189.34,127.1 189.34,125.59 v2(188.91,125.17)
  BOTTOM w0.102: JDOCK1.117 197.95,177.74 196.84,178.85 v2(196.79,178.85) ; v2(188.91,125.17) 188.47,124.73 v1(187.57,124.73) v2(184.42,124.73)
D_LAD0: length 69.5
  TOP w0.102: v2(188.2,122.18) 188.16,122.14 U37.B29
  IN3 w0.102: v2(194.38,179.39) 194.91,178.85 194.91,177.94 195.6,177.25 195.6,172.5 193.04,169.94 192.9,169.81 192.9,167.54 194.07,166.37 194.07,160.82 195.16,159.73 195.16,155.59 194.56,154.98 193.36,154.98 192.27,153.89 192.27,153.05 189.22,150 189.22,145.64 187.47,143.88 187.47,135.25 186.02,133.81 186.02,128.19 186.36,127.86 186.76,127.46 186.76,123.62 v2(188.2,122.18)
  BOTTOM w0.102: JDOCK1.97 192.95,178.41 193.93,179.39 v2(194.38,179.39)
D_LAD1: length 69.9
  TOP w0.102: v3(188.97,123.05) 188.57,122.64 U37.B28
  IN3 w0.102: v3(188.97,123.05) 188.49,123.53 188.4,123.53 186.99,124.94 186.99,127.55 186.25,128.29 186.25,133.71 187.7,135.16 187.7,143.79 189.6,145.69 189.6,150.06 192.5,152.95 192.5,153.79 193.45,154.75 194.65,154.75 195.26,155.36 195.26,155.36 195.39,155.49 195.39,159.3 195.39,159.3 195.39,159.49 195.39,159.49 195.39,159.82 194.3,160.91 194.3,166.46 194.17,166.6 193.13,167.63 193.13,169.72 195.82,172.41 195.82,177.53 195.22,178.14 195.22,178.62 v2(195.59,179)
  BOTTOM w0.102: v2(195.59,179) 195.52,178.93 193.97,178.93 193.45,178.41 JDOCK1.99
D_LAD2: length 63.9
  TOP w0.102: v2(185.23,123.9) 185.73,123.39 U37.A25
  IN3 w0.102: v2(185.23,123.9) 186.07,124.74 186.07,127.17 185.28,127.96 185.28,136 186.35,137.07 186.35,143.41 188.59,145.65 188.59,150.74 188.59,151.12 187.37,152.34 187.37,156.65 188.92,158.2 188.92,159.8 188.26,160.46 188.26,164.13 188.44,164.32 190.29,164.32 191.71,165.74 191.71,168.06 192.42,168.77 192.42,172.06 193.79,173.42 193.79,177.04 194.3,177.56 v2(194.3,177.86)
  BOTTOM w0.102: JDOCK1.103 194.45,177.71 v2(194.3,177.86)
D_LAD3: length 64.5
  TOP w0.102: v3(185.87,123.94) 185.91,123.89 U37.A24
  IN3 w0.102: v2(194.3,178.45) 194.68,178.07 194.68,177.44 194.01,176.77 194.01,173.33 192.68,171.99 192.68,168.62 191.94,167.88 191.94,165.65 190.39,164.1 188.54,164.1 188.48,164.04 188.48,160.55 189.14,159.89 189.14,158.08 187.6,156.53 187.6,152.44 188.68,151.35 188.81,151.22 188.81,150.65 188.81,145.55 186.58,143.32 186.58,136.97 185.56,135.96 185.56,128 186.17,127.4 186.3,127.27 186.3,124.62 185.87,124.19 v3(185.87,123.94)
  BOTTOM w0.102: v2(194.3,178.45) 194.3,178.46 194.95,177.81 JDOCK1.105
D_LFRAME#: length 63
  TOP w0.102: U37.B23 188.23,125.14 v3(188.26,125.17)
  IN3 w0.102: v2(195.6,178.42) 195.6,178.11 196.05,177.65 196.05,171.51 193.36,168.81 193.36,167.73 194.26,166.83 194.53,166.56 194.53,161.01 195.62,159.92 195.62,159.58 195.62,155.4 195.35,155.13 194.75,154.52 194.56,154.52 193.55,154.52 192.73,153.7 192.73,152.86 189.98,150.11 189.98,145.75 188.69,144.45 188.69,141.12 188.51,140.94 188.51,132.04 187.95,131.49 187.95,129.3 188.71,128.55 188.71,127.24 189.11,126.85 189.11,125.89 188.7,125.49 188.58,125.49 v3(188.26,125.17)
  BOTTOM w0.102: JDOCK1.109 195.95,177.75 195.6,178.11 v2(195.6,178.42)
D_SERIRQ: length 72.7
  TOP w0.102: U37.A20 185.67,125.89 v2(185.15,125.37) 185.05,125.26 RP5.2
  IN3 w0.102: v2(185.15,125.37) 185.15,126.03 184.6,126.58 184.6,127.68 184.75,127.83 184.75,136.46 185.89,137.61 185.89,143.6 188.13,145.84 188.13,150.93 187.18,151.89 186.91,152.15 186.91,156.86 187.75,157.69 187.75,157.69 187.98,157.92 187.98,157.92 188.46,158.41 188.46,159.61 187.8,160.27 187.8,164.32 188.26,164.78 190.1,164.78 191.25,165.93 191.25,168.41 191.89,169.05 191.89,171.79 191.53,172.15 191.53,173.86 192.87,175.2 192.87,178.55 192.87,178.96 192.87,179.16 192.87,179.35 193.74,180.22 193.88,180.35 195.94,180.35 196.26,180.04 196.26,179.77 196.49,179.54 v2(196.82,179.54)
  BOTTOM w0.102: v2(196.82,179.54) 196.35,179.07 196.35,178.59 196.56,178.37 196.94,178.37 197.45,177.86 JDOCK1.115
DAI_12MHZ#: length 5.5
  TOP w0.102: RE4.1 189.5,175.62 v2(189.88,175.24) 189.88,175.01 v1(189.65,174.79)
  BOTTOM w0.102: R137.1 191.64,173.68 190.33,174.99 190.13,174.99 v2(189.88,175.24) 189.95,175.32 JDOCK1.89
DAI_BCLK#: length 6.2
  TOP w0.102: RE5.1 186.94,177.36 187.19,177.61 v2(187.19,178.09)
  BOTTOM w0.102: R139.1 186.95,174.7 JDOCK1.77 186.95,177.5 187.19,177.74 v2(187.19,178.09)
DAI_DI: length 3.9
  BOTTOM w0.102: R144.1 189.87,173.97 189.55,174.28 189.02,174.28 188.45,174.85 JDOCK1.83
DAI_DO#: length 4.5
  BOTTOM w0.102: JDOCK1.85 188.95,175.7 188.81,175.56 188.81,175 189.17,174.64 190.18,174.64 190.75,174.06 R141.1
DAI_LRCK#: length 4
  BOTTOM w0.102: JDOCK1.79 187.45,174.81 187.84,174.42 188.34,174.42 188.98,173.79 R143.1
DAT_DDC2_CRT: length 165.5
  IN1 w0.097: v3(183.68,167.47) 185.1,167.47 187.4,165.17 202.32,165.17 202.56,165.4 211.14,165.4 216.27,170.53 222.26,170.53 225.21,167.58 248.74,167.58 248.85,167.47 249.54,166.78 261.27,166.78 262.14,165.9 282.26,165.9 285.08,163.08 288.51,163.08 292.71,167.28 307.28,167.28 307.73,166.83 316.6,166.83 316.86,166.57 330.94,166.57 331.49,167.12 v2(338.61,167.12)
  BOTTOM w0.102: U39.12 183.24,167.92 v3(183.68,167.47) ; v2(338.61,167.12) 338.78,166.95 JIO1.46
DAT_DDC2_DOCK: length 21.7
  IN3 w0.102: v2(179.4,173.76) 179.25,173.62 177.77,173.62 176.62,174.77 176.62,175.78 176.37,176.03 176.37,179.35 176.6,179.58 176.6,179.92 v2(176.5,180.02)
  BOTTOM w0.102: v2(179.4,173.76) 181.04,172.12 181.04,169.39 182,168.44 182.61,168.44 182.72,168.55 U39.13 ; JDOCK1.46 177.95,181.58 176.5,180.12 v2(176.5,180.02)
DAT_KBD: length 74.9
  TOP w0.102: RP4.6 167.15,134.1 v3(167.07,134.02) ; U38.B41 167.19,127.99 167.51,127.67 167.51,127.64 v2(167.61,127.55)
  IN1 w0.097: v2(179.49,179.23) 179.26,179.23 177.05,177.02 175.64,175.61 175.64,174.62 169.73,168.71 169.73,166.54 169.24,166.05 169.24,165.14 169.24,164.75 168.81,164.32 168.81,159.78 167.91,158.88 167.91,158.28 167.22,157.59 167.22,155.61 167.78,155.05 167.78,154.48 167.84,154.42 167.88,154.38 167.88,153.68 167.43,153.22 167.43,151.04 169.03,149.44 169.03,148.67 167.89,147.53 167.89,137.81 167.15,137.07 167.15,134.1 v3(167.07,134.02) 166.77,133.72 166.77,133.08 167.3,132.55 167.3,130.01 167.51,129.8 167.51,127.64 v2(167.61,127.55)
  BOTTOM w0.102: v3(167.07,134.02) 167.07,133.9 v1(166.72,133.54) ; JDOCK1.80 187.45,183.65 187.39,183.59 187.39,179.76 186.68,179.06 186.04,179.06 185.69,179.41 179.67,179.41 v2(179.49,179.23)
DAT_MSE: length 71
  TOP w0.102: v2(167.02,127.52) 166.69,127.85 U38.B42 ; RP4.5 166.65,134.3 v3(166.39,134.03)
  IN1 w0.097: v2(167.02,127.52) 167.02,129.61 166.82,129.81 166.82,132.35 166.29,132.88 166.29,132.9 166.28,132.9 166.28,133.93 v3(166.39,134.03) 166.64,134.29 166.64,137.33 167.41,138.1 167.41,147.73 167.99,148.3 167.99,149.29 165.13,152.14 165.13,154.65 166.75,156.26 166.75,157.79 167.44,158.48 167.44,159.64 168.33,160.54 168.33,161.59 167.91,162.01 167.91,162.6 168.33,163.02 168.33,164.52 168.76,164.94 168.76,166.25 169.25,166.74 169.25,168.92 175.16,174.83 175.16,175.81 176.29,176.94 176.57,177.22 176.57,177.82 176.93,178.18 176.93,178.18 177.28,178.54 v2(177.28,178.68)
  BOTTOM w0.102: v2(177.28,178.68) 177.44,178.83 178.09,178.83 178.76,178.17 179.79,178.17 180.07,178.45 185.21,178.45 185.95,177.7 JDOCK1.73
DAT_TP_SIO: length 41.7
  TOP w0.102: R441.1 148.53,104 149.14,104.61 v3(149.22,104.61) ; U38.B40 167.69,128.05 167.99,127.75 167.99,127.34 167.61,126.96 v2(167.61,126.88)
  IN3 w0.102: v2(150.59,116.88) 150.38,117.08 150.38,117.61 152.54,119.77 152.54,123.9 154.13,125.49 154.6,125.49 154.91,125.18 157.19,125.18 158.13,124.24 158.94,124.24 159.02,124.32 161.73,124.32 162.04,124.62 163.46,124.62 163.64,124.81 163.97,125.14 163.97,125.62 164.14,125.79 165.76,125.79 166.12,126.15 167.15,126.15 167.61,126.61 v2(167.61,126.88)
  BOTTOM w0.102: v3(149.22,104.61) 149.04,104.79 149.04,105.37 150.22,106.55 150.22,108.36 150.74,108.88 150.74,110.35 150.74,111.15 150.74,115.12 150.41,115.45 150.41,116.7 v2(150.59,116.88)
DC_BLOCK_GC: length 64.5
  TOP w0.102: v3(101.85,179.74) 103.03,179.74 v1(103.1,179.82)
  TOP w0.254: PU701.7 131.65,150.83 132.9,149.57 v3(132.9,149.31)
  IN3 w0.254: v3(132.9,149.31) 130.01,149.31 129.02,148.32 129.02,146.77 128.39,146.14 127.6,146.14 126.41,144.94 123.03,144.94 116.55,151.42 115.46,151.42 113.73,153.15 112.72,153.15 108.47,157.39 106.34,157.39 102.4,161.33 102.4,165.49 101.06,166.84 101.06,168.29 100.04,169.3 100.04,173.32 100.8,174.08 100.8,177.35 100.42,177.73 100.42,178.95 v3(101.21,179.74)
DC_IN_SS: length 2.2
  TOP w0.254: PR529.2 125.89,153.7 v1(126.57,153.7) PU701.34
DC_TEST_A3_B3: length 0.7
  BOTTOM w0.089: UC1.A3 167,84.03 UC1.B3
DC_TEST_A4: length 14
  TOP w0.102: v1(174.2,91.91) 173.43,92.67 v3(172.99,92.67) 173.19,92.87 173.73,92.87 174.23,93.38 RC139.2
  BOTTOM w0.076: UC1.A4 166.25,84.74 167.4,85.89 167.4,87.08 168.95,88.63
  BOTTOM w0.102: 168.95,88.63 v3(172.99,92.67)
DC_TEST_A60: length 7.4
  BOTTOM w0.102: 125.78,86.1 125.7,86.02 RC143.2
  BOTTOM w0.109: UC1.A60 131.42,84.77 130.39,85.79 128.79,85.79 127.98,86.6 126.18,86.6 v1(126.14,86.56) 125.78,86.21 125.78,86.1
DC_TEST_A61_B61: length 5.4
  BOTTOM w0.076: UC1.B61 130.76,83.97 UC1.A61 130.76,84.69 130.47,84.97 129.91,84.97 129.45,85.43 127.83,85.43 127.71,85.32 126.84,85.32
  BOTTOM w0.102: 126.84,85.32 v1(126.58,85.32)
DC_TEST_A62: length 7
  BOTTOM w0.076: 128.9,85.13 128.57,84.8 126.84,84.8
  BOTTOM w0.102: v1(123.84,85.58) 123.89,85.64 RC143.1 125.29,85.13 125.95,85.13 126.28,84.8 126.84,84.8 ; 128.9,85.13 129.38,85.13 129.95,84.55 UC1.A62
DC_TEST_AV1: length 17.2
  TOP w0.102: v1(179.85,61.52) 180.18,61.19 v2(180.18,60.87)
  IN2 w0.102: v2(181.32,60.4) 180.85,60.87 v2(180.18,60.87)
  BOTTOM w0.076: UC1.AV1 168.4,63.24 169.87,61.76 170.78,61.76
  BOTTOM w0.102: v2(180.18,60.87) 178.66,60.87 178.3,60.51 173.12,60.51 171.87,61.76 170.78,61.76 ; RC145.2 180.2,60.26 181.18,60.26 v2(181.32,60.4)
DC_TEST_AW1: length 12.3
  BOTTOM w0.076: 170.77,61.25 168.81,61.25 168.14,61.92 UC1.AW1
  BOTTOM w0.102: 170.77,61.25 171.16,61.25 v1(171.8,60.62) 172.48,59.93 173.87,59.93 174.08,59.73 178.02,59.73 178.15,59.85 RC145.1
DC_TEST_AW63: length 6.8
  BOTTOM w0.102: RC141.2 124.7,60.11 v1(124.86,59.96) 126.97,59.96 UC1.AW63
DC_TEST_AY2_AW2: length 0.7
  BOTTOM w0.076: UC1.AY2 167.48,62.04 UC1.AW2
DC_TEST_AY3_AW3: length 0.7
  BOTTOM w0.076: UC1.AY3 166.87,62.53 UC1.AW3
DC_TEST_AY60: length 11
  BOTTOM w0.076: UC1.AY60 131.39,61.82 130.88,61.3 130.88,61.07
  BOTTOM w0.102: RC141.1 124.43,58.56 v1(125.85,58.56) 128.84,58.56 129.31,59.03 129.31,59.51 130.88,61.07
DC_TEST_AY61_AW61: length 4.5
  BOTTOM w0.076: UC1.AW61 130.73,62.5 UC1.AY61 130.73,61.39 128.78,59.43 v1(128.78,58.91)
DC_TEST_AY62_AW62: length 4.7
  BOTTOM w0.076: v1(127.45,58.97) 130.08,61.6 UC1.AY62 130.08,62.49 UC1.AW62
DC_TEST_B62_B63: length 0.7
  BOTTOM w0.254: UC1.B62 129.65,83.83 UC1.B63
DC_TEST_C1_C2: length 4.8
  BOTTOM w0.076: UC1.C2 168.02,83.3 UC1.C1 168.54,83.42 170.78,85.66
  BOTTOM w0.102: 170.78,85.66 v1(171.14,86.02)
DDI1_LANE_N0: length 103
  TOP w0.102: v4(155.73,143.14) 155.87,143.14 156.07,143.34 156.07,143.62 156.35,143.9 158.66,143.9 160.5,145.74 169.23,145.74 169.24,145.76 169.78,145.76 169.79,145.74 174.5,145.74 176.27,147.51 179.11,147.51 181.56,149.96 181.56,150.14 C156.1
  BOTTOM w0.076: UC1.C54 134.79,82.93 134.75,82.89 134.56,82.89 134.42,82.89 134.21,83.11 134.21,83.24 134.21,83.31 134.24,83.36 134.33,83.47 arc(134.37,83.58) 134.34,83.71 arc(134.28,83.89) 134.31,84.08 134.33,84.13 134.35,84.17 134.35,84.28 134.29,84.45 134.29,84.83 131.8,87.32 131.8,87.75 131.78,87.78 131.78,87.79
  BOTTOM w0.102: v4(155.73,143.14) 155.83,143.04 155.83,141.68 135.56,121.41 135.56,107.69 130.61,102.74 130.61,89.48 131.78,88.31 131.78,87.79
DDI1_LANE_N0_C: length 5.2
  TOP w0.102: C156.2 181.36,151.74 181.36,152.37 v3(180.28,153.45) 179.21,154.52 179.21,155.27 U6.G2
DDI1_LANE_N1: length 103
  TOP w0.102: C158.1 179.73,150.2 179.73,149.93 178.15,148.35 175.71,148.35 173.82,146.46 167.15,146.46 167.14,146.47 166.6,146.47 166.59,146.46 160.22,146.46 158.75,144.98 154.26,144.98 153.95,144.68 153.95,144.42 153.79,144.26 v4(153.61,144.26)
  BOTTOM w0.076: 129.96,87.63 130,87.63 130.38,87.25 130.65,87.25 132.87,85.03 132.87,83.85 132.75,83.73 132.75,83.64 UC1.B58
  BOTTOM w0.102: 129.96,87.63 129.5,88.09 129.18,88.41 129.18,103.29 134.09,108.2 134.09,121.97 153.66,141.54 153.66,143.1 154.09,143.53 154.09,144.39 154.02,144.46 153.81,144.46 v4(153.61,144.26)
DDI1_LANE_N1_C: length 4.7
  TOP w0.102: C158.2 179.58,151.74 179.58,152.16 v3(179.1,152.64) 178.98,152.75 178.58,153.16 178.58,155.28 U6.F2
DDI1_LANE_N2: length 98.9
  TOP w0.102: C160.1 177.86,150.26 177.86,149.89 177.03,149.06 176.39,149.06 176.38,149.07 175.83,149.07 175.82,149.06 175.3,149.06 173.42,147.18 159.96,147.18 158.46,145.68 157.78,145.68 157.62,145.83 157.62,146.24 157.72,146.34 157.9,146.34 v4(158.13,146.11)
  BOTTOM w0.076: 132.88,87.79 132.88,87.78 132.86,87.76 132.86,87.11 135.18,84.79 135.18,84.55 135.02,84.39 134.99,84.39 134.75,84.15 UC1.B55
  BOTTOM w0.102: 132.88,87.79 132.88,88.53 131.59,89.83 131.59,102.32 136.52,107.25 136.52,121.04 157.94,142.47 157.94,145.92 v4(158.13,146.11)
DDI1_LANE_N2_C: length 4.4
  TOP w0.102: U6.E2 177.91,155.27 v3(177.91,153.25) 177.91,152.31 177.76,152.16 177.76,151.75 C160.2
DDI1_LANE_N3: length 97.6
  TOP w0.102: v3(155.67,146.01) 155.88,146.23 155.88,146.38 157.39,147.89 v3(158.92,147.89) 172.86,147.89 174.83,149.86 175.87,149.86 175.99,149.97 175.99,150.23 C162.1
  BOTTOM w0.076: 130.99,87.79 130.99,87.78 131.02,87.76 131.02,87.66 131.02,87.66 131.02,87.52 133.69,84.85 133.69,84.54 133.62,84.34 133.51,84.24 133.37,84.24 133.27,84.33 133.27,84.46 UC1.A57
  BOTTOM w0.102: 130.99,87.79 130.99,87.83 129.87,88.95 129.87,103 134.83,107.95 134.83,121.69 154.36,141.22 154.36,142.8 155.86,144.3 155.86,145.82 v3(155.67,146.01)
DDI1_LANE_N3_C: length 4.9
  TOP w0.102: C162.2 175.87,151.77 175.87,151.93 176.46,152.51 176.46,152.54 176.81,152.89 176.84,152.89 177.26,153.31 177.26,155.26 U6.D2
DDI1_LANE_P0: length 103
  TOP w0.102: C155.1 181.78,150.35 181.78,149.87 179.2,147.29 176.36,147.29 174.59,145.53 v3(169.51,145.53) 160.59,145.53 158.75,143.69 156.44,143.69 156.29,143.53 156.29,143.25 156.4,143.14 v3(156.66,143.14)
  BOTTOM w0.076: 131.99,87.79 131.99,87.78 131.97,87.75 131.97,87.39 134.46,84.9 134.46,84.48 134.52,84.36 134.52,84.14 134.48,84.05 134.47,84.01 134.46,84.01 arc(134.44,83.9) 134.48,83.79 arc(134.53,83.58) 134.46,83.36 134.37,83.26 134.37,83.17 134.49,83.06 134.68,83.06 134.75,83.12 UC1.C55
  BOTTOM w0.102: v3(156.66,143.14) 156.48,143.32 156.25,143.32 156.14,143.2 156.14,142.97 156.05,142.88 156.05,141.59 135.78,121.32 135.78,107.61 130.83,102.65 130.83,89.57 131.99,88.4 131.99,87.79
DDI1_LANE_P0_C: length 5.2
  TOP w0.102: U6.G1 179.43,154.83 179.43,154.61 180.43,153.61 v3(181.4,152.64) 181.58,152.46 181.58,151.34 181.68,151.24 181.85,151.24 182.01,151.4 C155.2
DDI1_LANE_P1: length 103
  TOP w0.102: C157.1 179.94,150.3 179.94,149.84 178.24,148.13 175.8,148.13 173.91,146.24 v3(166.87,146.24) 160.31,146.24 158.84,144.77 154.35,144.77 154.17,144.59 154.17,144.33 154.27,144.24 v3(154.5,144.24)
  BOTTOM w0.076: 130.1,87.79 130.1,87.76 130.45,87.41 130.72,87.41 133.04,85.09 133.04,83.78 133.1,83.71 133.1,83.46 132.8,83.16 UC1.C58
  BOTTOM w0.102: 130.1,87.79 129.88,88.02 129.66,88.24 129.39,88.5 129.39,103.2 134.31,108.11 134.31,121.88 153.88,141.45 153.88,143.01 154.31,143.44 154.31,144.05 v3(154.5,144.24)
DDI1_LANE_P1_C: length 4.7
  TOP w0.102: U6.F1 178.79,154.85 178.79,153.25 179.04,153.01 179.07,153.01 179.47,152.61 179.47,152.58 179.8,152.25 179.8,151.34 179.92,151.22 180.05,151.22 180.23,151.4 C157.2
DDI1_LANE_P2: length 98.9
  TOP w0.102: C159.1 178.08,150.26 178.08,149.8 177.12,148.84 v3(176.1,148.84) 175.39,148.84 173.51,146.96 160.05,146.96 158.55,145.46 157.69,145.46 157.41,145.74 157.41,145.92 v3(157.22,146.11)
  BOTTOM w0.076: UC1.A55 134.95,84.55 135.02,84.62 135.02,84.72 132.69,87.04 132.69,87.76 132.67,87.78 132.67,87.79
  BOTTOM w0.102: 132.67,87.79 132.67,88.44 131.37,89.74 131.37,102.41 136.3,107.34 136.3,121.13 157.72,142.56 157.72,146.16 157.6,146.29 157.39,146.29 v3(157.22,146.11)
DDI1_LANE_P2_C: length 4.3
  TOP w0.102: C159.2 178.41,151.41 178.27,151.27 178.07,151.27 177.98,151.36 177.98,152.08 178.13,152.22 178.13,154.83 U6.E1
DDI1_LANE_P3: length 97.6
  TOP w0.102: C161.1 176.2,150.23 176.2,149.88 175.96,149.64 174.92,149.64 172.95,147.67 159.2,147.67 159.19,147.66 158.64,147.66 158.63,147.67 157.48,147.67 156.1,146.29 156.1,146.19 v4(156.3,145.99)
  BOTTOM w0.076: 131.21,87.79 131.18,87.77 131.18,87.59 133.86,84.92 133.86,84.78 133.86,84.78 133.86,84.56 133.86,84.56 133.86,84.51 133.76,84.24 133.75,84.24 133.58,84.07 133.46,84.07 133.37,83.98 UC1.B57
  BOTTOM w0.102: 131.21,87.79 131.21,87.92 130.09,89.04 130.09,102.91 135.04,107.86 135.04,121.6 154.58,141.13 154.58,142.71 156.07,144.21 156.07,145.76 v4(156.3,145.99)
DDI1_LANE_P3_C: length 4.9
  TOP w0.102: C161.2 176.57,151.5 176.32,151.24 176.19,151.24 176.09,151.34 176.09,151.83 v3(176.81,152.55) 177.47,153.21 177.47,154.85 177.57,154.94 U6.D1
DDR3_DRAMRST#: length 90.9
  TOP w0.102: CD34.1 172.36,15.77 v3(171.21,14.62) ; RC279.1 104.79,13.93 CD3.1 104.79,14.57 104.56,14.79 v6(104.56,16.24) v2(104.56,16.87)
  IN1 w0.097: v3(171.21,14.62) 170.4,13.8 151.93,13.8 150.15,12.02 140.55,12.02 138.77,13.8 118.94,13.8 116.41,16.33 105.1,16.33 v2(104.56,16.87)
  BOTTOM w0.102: v3(171.21,14.62) 171.21,14.64 171.18,14.68 JDIMM2.30 ; v2(104.56,16.87) 104.56,16.8 104.03,16.27 97.7,16.27 96.9,17.07 96.9,17.2 96.68,17.42 JDIMM1.30
DDR3_DRAMRST#_CPU: length 122.6
  TOP w0.102: v3(105.25,16.78) 105.25,15.58 v6(105.83,15) 106.57,14.26 RD3.2 RC279.2
  IN3 w0.102: v3(90.67,34.89) 91.84,33.72 95.65,33.72 101.34,28.03 101.34,26.73 103.34,24.73 103.34,18.68 v3(105.25,16.78)
  BOTTOM w0.076: 159.91,54.65 159.91,55.99 159.78,56.12 159.78,59.52 159.68,59.63 159.68,60.08 159.32,60.44 159.32,61.46 159.23,61.56 159.23,62.05 159.3,62.12 159.3,62.38 159.23,62.46 159.23,62.97 UC1.AV15
  BOTTOM w0.102: v3(90.67,34.89) 98.97,34.89 104.23,40.14 149.52,40.14 151.63,42.25 151.63,51.57 154.41,54.35 159.61,54.35 159.91,54.65
DDR_A_BS0: length 62
  IN1 w0.076: v2(147.72,58.72) 147.72,58.41 147.42,58.11 147.42,55.99 146.35,54.92 146.35,54.06
  IN1 w0.14: 146.35,54.06 146.35,46.13 133.73,33.51 133.53,33.51 133.05,33.99 132.85,33.99 132.65,33.79 132.65,33.59 133.14,33.11 133.14,32.91 132.94,32.71 132.74,32.71 131.31,34.15 131.11,34.15 130.91,33.95 130.91,33.76 132.35,32.32 132.35,32.12 132.15,31.92 131.95,31.92 130.44,33.44 130.24,33.44 130.04,33.24 130.04,33.04 130.48,32.6 130.48,32.41 130.28,32.21 130.09,32.21 129.71,32.58 129.51,32.58 125.19,28.26 125.19,27.8 123.97,26.58 123.97,26.07 123.12,25.23 v2(123.12,24.86)
  BOTTOM w0.076: v2(147.72,58.72) 146.84,59.61 146.84,63.16 147.24,63.57 UC1.AU35
  BOTTOM w0.152: v2(123.12,24.86) 122.97,24.86 122.78,25.05 JDIMM1.109
DDR_A_BS1: length 62.1
  IN1 w0.076: 146.77,54.06 146.77,54.1 146.78,54.11 146.78,54.91 148.23,56.35 148.23,58.87 v2(147.72,59.37)
  IN1 w0.14: v2(123.68,21.31) 124.01,21.64 124.01,23.1 123.94,23.16 123.94,23.38 123.84,23.48 123.84,25.32 126,27.48 126,28.46 129.31,31.77 129.72,31.77 131.05,30.43 131.25,30.43 131.45,30.63 131.45,30.83 130.67,31.61 130.67,31.81 130.87,32 131.06,32 131.84,31.22 132.04,31.22 146.77,45.95 146.77,54.06
  BOTTOM w0.076: v2(147.72,59.37) 147.36,59.37 147,59.73 147,62.93 UC1.AV35
  BOTTOM w0.152: JDIMM1.108 122.48,20.11 v2(123.68,21.31)
DDR_A_BS2: length 60.4
  IN1 w0.14: v2(111.62,23.34) 112.09,23.81 112.09,24.42 112.27,24.6 112.27,28.16 112.3,28.19 112.3,28.2 130.74,46.65 133.07,46.65 134.01,47.59 134.01,47.78 133.36,48.43 133.36,48.63 133.56,48.82 133.76,48.82 134.4,48.18 134.6,48.18 134.8,48.38 134.8,48.57 133.83,49.54 133.83,49.74 136.85,52.76 136.85,53.93 137.69,54.76 137.95,54.76 139.46,56.27 139.91,56.27 142.24,58.6 142.24,60.17 v2(143,60.93)
  BOTTOM w0.076: v2(143,60.93) 143.39,61.32 143.39,61.4 143.39,61.4 143.39,61.75 UC1.AY41
  BOTTOM w0.152: JDIMM1.79 113.78,25.5 v2(111.62,23.34)
DDR_A_CAS#: length 61.6
  IN1 w0.076: 148.03,54.06 148.03,55.11 148.74,55.83 148.74,62.55 v2(147.72,63.58)
  IN1 w0.14: 148.03,54.06 148.03,45.3 147.46,44.74 147.46,44.54 147.82,44.19 147.82,43.99 147.62,43.79 147.42,43.79 147.07,44.15 146.87,44.15 146.67,43.95 146.67,43.75 147.03,43.39 147.03,43.2 146.83,43 146.63,43 146.28,43.36 146.08,43.36 145.88,43.16 145.88,42.96 146.24,42.6 146.24,42.41 146.04,42.21 145.84,42.21 145.49,42.57 145.29,42.57 145.09,42.37 145.09,42.17 145.45,41.81 145.45,41.62 145.25,41.42 145.05,41.42 144.69,41.78 144.5,41.78 144.3,41.58 144.3,41.38 144.66,41.02 144.66,40.83 144.46,40.63 144.26,40.63 143.9,40.98 143.71,40.98 143.51,40.79 143.51,40.59 143.87,40.23 143.87,40.04 143.67,39.84 143.47,39.84 143.11,40.19 142.92,40.19 132.07,29.35 132.07,27.34 131.68,26.95 127.37,26.95 125.28,24.86 v2(125.18,24.86)
  BOTTOM w0.076: UC1.AU34 148.02,63.88 v2(147.72,63.58)
  BOTTOM w0.152: v2(125.18,24.86) 124.74,24.86 124.58,25.03 JDIMM1.115
DDR_A_D0: length 64.9
  IN3 w0.102: v2(123.48,66.99) 117.32,60.83 117.32,34.5 120.82,31 120.96,31 121.27,31.31 121.42,31.31 121.56,31.17 121.56,31.02 121.25,30.71 121.25,30.57 121.39,30.42 121.54,30.42 121.85,30.73 121.99,30.73 122.14,30.59 122.14,30.45 121.83,30.14 121.83,29.99 121.97,29.85 122.11,29.85 122.42,30.16 122.57,30.16 122.71,30.02 122.71,29.87 122.4,29.56 122.4,29.42 122.54,29.27 122.69,29.27 123,29.58 123.14,29.58 123.29,29.44 123.29,29.3 123.12,29.13 123.12,28.7 124.07,27.74 124.07,27.44 127.99,23.52 v2(128.24,23.52)
  BOTTOM w0.076: v2(123.48,66.99) 124.09,66.99 125.55,68.45 127.74,68.45 128.43,69.15 129.13,69.15 129.26,69.28 UC1.AH63
  BOTTOM w0.102: v2(128.24,23.52) 128.87,24.15 128.87,25.46 128.78,25.56 JDIMM1.129
DDR_A_D1: length 65.9
  IN3 w0.102: v2(128.24,22) 127.51,22 125.62,23.88 125.62,25.06 117.01,33.66 117.01,61.13 123.82,67.94 v2(124.24,67.94)
  BOTTOM w0.076: v2(124.24,67.94) 124.76,67.94 125.46,68.64 127.69,68.64 128.37,69.31 129.06,69.31 129.31,69.57 129.58,69.57 129.76,69.48 129.96,69.48 UC1.AH62
  BOTTOM w0.102: v2(128.24,22) 129.38,23.13 JDIMM1.131
DDR_A_D2: length 63.6
  IN3 w0.102: v2(132.56,22.67) 132.02,23.21 132.02,24.5 125.92,30.6 125.92,30.75 126.31,31.13 126.31,31.28 126.16,31.42 126.02,31.42 125.63,31.03 125.48,31.03 125.34,31.18 125.34,31.32 125.73,31.71 125.73,31.85 125.59,32 125.44,32 125.05,31.61 124.91,31.61 124.77,31.75 124.77,31.9 125.16,32.28 125.16,32.43 125.01,32.57 124.87,32.57 124.55,32.26 124.41,32.26 124.27,32.4 124.27,32.55 124.58,32.86 124.58,33 120.62,36.96 120.62,59.3 126.64,65.33 126.64,66.89 v2(126.44,67.1)
  BOTTOM w0.076: UC1.AK63 129.39,67.8 129.12,67.8 128.89,67.57 127.44,67.57 126.98,67.1 v2(126.44,67.1)
  BOTTOM w0.102: v2(132.56,22.67) 132.18,22.67 132.05,22.79 132.05,25.08 132.38,25.41 JDIMM1.141
DDR_A_D3: length 64.5
  IN3 w0.102: v2(132.56,21.14) 131.56,22.14 131.56,24.49 123.67,32.38 123.67,32.52 124.08,32.93 124.08,33.08 123.93,33.22 123.79,33.22 123.38,32.81 123.24,32.81 123.09,32.96 123.09,33.1 123.5,33.51 123.5,33.65 123.36,33.79 123.21,33.79 122.81,33.39 122.66,33.39 122.52,33.53 122.52,33.68 122.93,34.08 122.93,34.23 122.78,34.37 122.64,34.37 122.41,34.14 122.27,34.14 122.13,34.29 122.13,34.43 122.35,34.66 122.35,34.8 120.32,36.84 120.32,60.21 125.6,65.5 v2(125.6,66.21)
  BOTTOM w0.076: UC1.AK62 129.93,67.92 129.63,67.63 129.19,67.63 128.96,67.4 127.52,67.4 126.76,66.64 126.41,66.64 125.98,66.21 v2(125.6,66.21)
  BOTTOM w0.102: v2(132.56,21.14) 132.08,20.66 JDIMM1.140
DDR_A_D4: length 66.1
  IN3 w0.102: v2(130.28,19.71) 128.67,21.32 128.67,24.4 128,25.07 126.88,25.07 125.09,26.86 125.09,28.07 117.72,35.44 117.72,60.62 124.62,67.52 v2(124.62,68.45)
  BOTTOM w0.076: UC1.AH61 130.43,69.66 129.77,69.66 129.63,69.73 129.25,69.73 129,69.49 128.31,69.49 127.62,68.8 124.98,68.8 v2(124.62,68.45)
  BOTTOM w0.102: v2(130.28,19.71) 129.68,19.11 JDIMM1.132
DDR_A_D5: length 66.9
  IN3 w0.102: v2(124.32,66.64) 124.17,66.64 118.02,60.49 118.02,48.85 118.13,48.75 118.48,48.75 118.58,48.65 118.58,48.45 118.48,48.35 118.3,48.35 118.2,48.24 118.2,48.04 118.3,47.94 118.48,47.94 118.58,47.84 118.58,35.02 125.4,28.2 125.4,26.98 126.97,25.41 128.11,25.41 129,24.52 129,22.52 v2(130.28,21.23)
  BOTTOM w0.076: 125.59,66.9 126.59,67.9 128.75,67.9 128.98,68.13 129.07,68.13 129.32,68.38 129.62,68.38 129.77,68.31 129.9,68.31 130.06,68.38 130.27,68.38 130.32,68.36 130.41,68.32 130.42,68.31 130.61,68.31 130.63,68.32 131,68.32 131.02,68.31 131.26,68.31 131.46,68.51 UC1.AH60
  BOTTOM w0.102: JDIMM1.130 129.08,20.03 v2(130.28,21.23) ; v2(124.32,66.64) 125.33,66.64 125.59,66.9
DDR_A_D6: length 64.9
  IN3 w0.076: 125.27,63.53 127.07,65.32 127.07,67.3 v2(126.86,67.5)
  IN3 w0.102: v2(132.56,24.19) 132.56,24.53 129.91,27.18 129.91,28.1 129.54,28.47 129.4,28.47 129.05,28.12 128.9,28.12 128.76,28.27 128.76,28.41 129.11,28.76 129.11,28.91 128.97,29.05 128.82,29.05 128.47,28.7 128.33,28.7 128.18,28.84 128.18,28.99 128.53,29.34 128.53,29.48 128.39,29.63 128.25,29.63 127.9,29.27 127.75,29.27 127.61,29.42 127.61,29.56 127.96,29.91 127.96,30.06 127.82,30.2 127.67,30.2 127.32,29.85 127.18,29.85 127.03,29.99 127.03,30.14 127.38,30.49 127.38,30.63 127.24,30.78 127.1,30.78 126.92,30.6 126.78,30.6 126.64,30.75 126.64,30.89 126.81,31.06 126.81,31.21 120.93,37.09 120.93,59.18 125.27,63.53
  BOTTOM w0.076: UC1.AK61 130.47,68.03 130.33,68.17 130.23,68.22 130.1,68.22 130.08,68.21 129.99,68.17 129.94,68.14 129.74,68.14 129.58,68.22 129.39,68.22 129.14,67.96 129.05,67.96 128.82,67.73 127.1,67.73 v2(126.86,67.5)
  BOTTOM w0.102: v2(132.56,24.19) 132.56,23.94 132.69,23.82 133.2,23.82 133.33,23.94 133.33,24.63 133.2,24.76 132.69,24.76 132.56,24.89 132.56,25.13 132.69,25.25 132.85,25.25 132.98,25.38 JDIMM1.143
DDR_A_D7: length 65.7
  IN3 w0.102: v2(125.16,65.79) 124.3,64.93 124.3,64.68 120.01,60.39 120.01,35.64 120.26,35.39 120.62,35.39 120.72,35.5 121.04,35.5 121.18,35.36 121.18,35.22 120.87,34.9 120.87,34.75 121.01,34.61 121.15,34.61 121.47,34.93 121.61,34.93 121.76,34.78 121.76,34.64 121.44,34.32 121.44,34.18 126.83,28.79 126.83,27.92 127.91,26.84 128.76,26.84 130.98,24.62 130.98,19.72 131.38,19.32 132.27,19.32 v2(132.56,19.62)
  BOTTOM w0.076: UC1.AK60 131.23,68.03 130.94,67.74 130.69,67.74 130.67,67.76 130.41,67.76 130.28,67.63 129.87,67.63 129.7,67.47 129.26,67.47 129.01,67.22 127.58,67.22 126.83,66.48 126.48,66.48 125.8,65.79 v2(125.16,65.79)
  BOTTOM w0.102: JDIMM1.142 132.68,19.5 v2(132.56,19.62)
DDR_A_D8: length 72.5
  IN1 w0.076: v2(126.32,64.07) 126.64,64.07 126.74,63.97 126.74,63.8 126.22,63.28 125.72,63.28 125.39,63.61 125.31,63.61
  IN1 w0.097: v2(90.16,28.54) 89.88,28.26 89.88,27.54 89.75,27.42 89.58,27.42 89.45,27.54 89.45,28.99 89.6,29.15 89.94,29.15 90.03,29.24 90.03,29.44 89.94,29.53 89.56,29.53 89.45,29.65 89.45,29.81 89.56,29.92 89.94,29.92 90.03,30.02 90.03,30.21 89.94,30.3 89.56,30.3 89.45,30.42 89.45,30.58 89.56,30.69 89.94,30.69 90.03,30.79 90.03,30.98 89.94,31.08 89.58,31.08 89.45,31.2 89.45,31.41 89.58,31.53 89.91,31.53 90.03,31.66 90.03,32.06 117.59,59.62 120.12,59.62 120.62,60.11 120.76,60.11 120.97,59.91 121.09,59.91 121.24,60.06 121.24,60.18 120.98,60.44 120.98,60.58 121.12,60.71 121.25,60.71 121.5,60.47 121.65,60.47 121.77,60.59 121.77,60.74 121.52,60.99 121.52,61.12 121.66,61.26 121.8,61.26 122.05,61.01 122.2,61.01 122.32,61.14 122.32,61.29 122.07,61.53 122.07,61.67 122.21,61.81 122.34,61.81 122.6,61.55 122.73,61.55 122.88,61.7 122.88,61.82 122.62,62.08 122.62,62.22 122.75,62.35 122.89,62.35 123.15,62.09 123.27,62.09 123.42,62.24 123.42,62.36 123.18,62.61 123.18,62.77 123.29,62.88 123.45,62.88 123.68,62.65 123.83,62.65 124,62.82 124,62.97 123.79,63.18 123.79,63.32 124.08,63.61 125.31,63.61
  BOTTOM w0.076: v2(126.32,64.07) 126.32,64.72 127.04,65.44 127.04,65.89 127.87,66.72 129.2,66.72 129.33,66.85 UC1.AM63
  BOTTOM w0.102: v2(90.16,28.54) 89.78,28.15 JDIMM1.7
DDR_A_D9: length 73.4
  IN1 w0.076: v2(125.52,64.78) 125.31,64.78
  IN1 w0.097: 125.31,64.78 123.79,64.78 121.84,62.83 121.7,62.83 121.6,62.93 121.46,62.93 121.33,62.8 121.33,62.66 121.43,62.56 121.43,62.42 121.29,62.28 121.16,62.28 121.05,62.38 120.91,62.38 120.78,62.25 120.78,62.11 120.88,62.01 120.88,61.87 120.75,61.74 120.61,61.74 120.47,61.88 120.33,61.88 120.19,61.74 120.19,61.61 120.34,61.46 120.34,61.33 120.2,61.19 120.06,61.19 119.92,61.33 119.78,61.33 119.65,61.2 119.65,61.06 119.79,60.92 119.79,60.78 119.65,60.64 119.52,60.64 119.37,60.79 119.24,60.79 119.01,60.57 117.21,60.57 88.46,31.81 88.46,24.22 88.33,24.09 87.95,24.09 87.77,23.91 87.77,20.31 v2(88.46,19.62)
  BOTTOM w0.076: UC1.AM62 129.93,66.85 129.63,67.14 129.39,67.14 129.14,66.88 127.8,66.88 126.71,65.79 126.71,65.44 126.05,64.78 v2(125.52,64.78)
  BOTTOM w0.102: v2(88.46,19.62) 88.88,19.2 JDIMM1.4
DDR_A_D10: length 71.4
  IN1 w0.076: v2(126.8,62.55) 126.8,61.98 126.43,61.61 126.15,61.61
  IN1 w0.097: 126.15,61.61 125.21,61.61 121.27,57.67 118.76,57.67 107.76,46.67 107.6,46.67 107.59,46.67 107.17,46.67 107.17,46.67 107.15,46.67 107.02,46.54 107.02,46.4 107.19,46.23 107.19,46.1 107.05,45.96 106.91,45.96 106.75,46.13 106.61,46.13 106.47,45.99 106.47,45.85 106.64,45.69 106.64,45.55 106.5,45.41 106.37,45.41 106.2,45.58 106.06,45.58 105.93,45.45 105.93,45.31 106.1,45.14 106.1,45 105.96,44.87 105.82,44.87 105.65,45.04 105.52,45.04 105.38,44.9 105.38,44.76 105.55,44.59 105.55,44.46 105.41,44.32 105.28,44.32 105.11,44.49 104.97,44.49 104.83,44.35 104.83,44.22 105,44.05 105,43.91 104.87,43.78 104.73,43.78 104.56,43.94 104.42,43.94 104.29,43.81 104.29,43.67 104.46,43.5 104.46,43.37 104.32,43.23 104.18,43.23 104.02,43.4 103.88,43.4 103.74,43.26 103.74,43.12 103.91,42.96 103.91,42.82 103.77,42.68 103.64,42.68 103.47,42.85 103.33,42.85 103.2,42.71 103.2,42.58 103.36,42.41 103.36,42.27 103.23,42.14 103.09,42.14 102.92,42.3 102.79,42.3 102.65,42.17 102.65,42.03 102.82,41.86 102.82,41.73 102.68,41.59 102.55,41.59 102.38,41.76 102.24,41.76 102.1,41.62 102.1,41.49 102.27,41.32 102.27,41.18 102.14,41.04 102,41.04 101.83,41.21 101.69,41.21 101.56,41.08 101.56,40.94 101.73,40.77 101.73,40.63 101.59,40.5 101.45,40.5 101.29,40.67 101.15,40.67 101.01,40.53 101.01,40.39 101.18,40.23 101.18,40.09 101.04,39.95 100.91,39.95 100.74,40.12 100.6,40.12 91.84,31.36 91.84,27.73 91.74,27.64 91.58,27.64 91.48,27.54 91.48,27.35 91.58,27.25 91.74,27.25 91.84,27.15 91.84,26.96 91.74,26.87 91.58,26.87 91.48,26.77 91.48,26.58 91.58,26.48 91.74,26.48 91.84,26.38 91.84,26.19 91.74,26.09 91.58,26.09 91.48,26 91.48,25.8 91.58,25.71 91.74,25.71 91.84,25.61 91.84,24.73 91.56,24.45 v2(91.46,24.45)
  BOTTOM w0.076: v2(126.8,62.55) 126.8,63.36 128.41,64.97 128.72,64.97 129.12,65.37 129.39,65.37 UC1.AP63
  BOTTOM w0.102: JDIMM1.17 92.78,25.7 91.53,24.45 v2(91.46,24.45)
DDR_A_D11: length 72.3
  IN1 w0.076: v2(127.3,62.88) 127.3,62.24 126.33,61.28
  IN1 w0.097: v2(93.36,19.54) 92.42,19.54 92.29,19.67 92.29,19.84 92.42,19.96 92.87,19.96 92.98,20.07 92.98,20.23 92.87,20.35 92.27,20.35 92.17,20.44 92.17,22.08 92.08,22.17 91.58,22.17 91.48,22.27 91.48,22.46 91.58,22.56 92.08,22.56 92.17,22.66 92.17,22.85 92.08,22.95 91.58,22.95 91.48,23.04 91.48,23.24 91.58,23.33 91.89,23.33 92.17,23.61 92.17,31.25 98.93,38.01 99.07,38.01 99.12,37.95 99.28,37.95 99.4,38.06 99.4,38.22 99.34,38.28 99.34,38.41 99.48,38.55 99.61,38.55 99.81,38.35 99.95,38.35 100.09,38.49 100.09,38.62 99.88,38.82 99.88,38.96 100.02,39.1 100.16,39.1 100.36,38.9 100.5,38.9 100.63,39.03 100.63,39.17 100.43,39.37 100.43,39.51 100.56,39.64 101.21,39.64 118.93,57.35 121.4,57.35 125.33,61.28 126.33,61.28
  BOTTOM w0.076: UC1.AP62 129.93,65.49 129.63,65.2 129.18,65.2 128.78,64.8 128.48,64.8 127.3,63.62 v2(127.3,62.88)
  BOTTOM w0.102: v2(93.36,19.54) 93.08,19.26 JDIMM1.18
