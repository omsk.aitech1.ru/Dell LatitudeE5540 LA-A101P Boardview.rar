# Allegro board Alpine15_LA-A101PR10-0826C.brd (continued)
## Nets (continued)
GND: C3.2 C5.2 C6.2 C7.2 C8.2 C9.2 C10.2 C11.2 C12.2 C13.2 C14.2 C15.2 C16.2 C17.2 C18.2 C21.2 C22.2 C23.2 C24.2 C25.2 C26.2 C27.2 C28.2 C29.2 C30.2 C34.2 C42.2 C43.2 C50.2 C73.2 C75.2 C76.1 C85.1 C87.2 C88.2 C93.2 C97.2 C101.2 C102.2 C111.2 C112.2 C113.2 C114.2 C118.2 C119.2 C120.2 C121.2 C122.2 C123.2 C124.2 C125.2 C126.2 C127.2 C128.2 C129.2 C130.2 C135.2 C136.2 C137.2 C139.2 C141.2 C142.2 C144.2 C145.2 C147.2 C148.2 C149.2 C152.2 C153.2 C154.2 C163.2 C177.2 C180.2 C182.2 C183.2 C184.2 C185.2 C186.2 C188.2 C189.2 C190.2 C192.2 C193.2 C194.2 C198.2 C200.2 C201.2 C202.2 C203.2 C204.2 C206.2 C207.2 C210.2 C211.2 C212.2 C213.2 C214.2 C215.2 C216.1 C217.1 C218.1 C219.1 C220.1 C223.1 C224.1 C225.1 C226.1 C227.2 C228.2 C229.2 C230.1 C231.1 C232.1 C233.1 C234.1 C239.2 C240.2 C241.2 C246.2 C247.2 C248.2 C249.2 C250.2 C251.2 C252.2 C253.2 C255.2 C257.2 C258.2 C259.2 C260.1 C261.1 C262.2 C263.2 C264.2 C265.2 C266.2 C267.2 C268.2 C273.2 C288.2 C289.2 C290.2 C291.2 C310.2 C311.2 C316.2 C317.2 C318.2 C319.2 C328.2 C329.2 C330.2 C331.2 C332.2 C333.2 C334.2 C336.2 C337.2 C338.2 C339.2 C340.2 C342.2 C343.2 C344.2 C345.2 C346.2 C347.2 C348.2 C349.2 C350.2 C351.2 C352.2 C353.2 C354.2 C355.2 C356.2 C357.2 C360.2 C362.2 C363.2 C364.2 C365.2 C366.2 C367.2 C368.2 C369.2 C371.2 C374.2 C375.2 C376.2 C377.2 C378.2 C379.2 C380.2 C384.2 C386.2 C387.2 C389.2 C390.2 C391.2 C393.2 C395.2 C396.2 C397.2 C398.2 C399.2 C400.2 C401.2 C402.2 C403.2 C404.2 C405.2 C406.1 C408.2 C409.2 C410.2 C414.2 C422.2 C425.2 C426.2 C427.2 C430.2 C431.2 C432.2 C434.2 C435.2 C436.2 C437.2 C439.2 C440.2 C441.2 C442.2 C443.2 C444.2 C451.2 C452.2 C453.1 C454.2 C455.2 C456.2 C458.1 C459.1 C460.2 C461.2 C462.2 C482.2 C633.2 C634.2 C635.2 C636.2 C645.2 C809.2 C1001.2 C1185.2 C1186.2 C1187.2 C1188.2 C1189.2 C2962.2 C2963.2 C2964.2 C2965.2 C2972.2 C2980.2 C2987.2 C2988.2 C2989.2 C2990.2 C2991.2 C2992.2 C3002.2 C3003.2 C3004.2 C3005.2 C3022.2 C3023.2 C3024.2 C3025.2 C3026.2 C3027.2 C3028.2 C3029.2 C3030.1 C3031.2 C3032.2 C3033.2 C3034.2 CC1.1 CC2.1 CC3.1 CC4.1 CC5.2 CC6.2 CC7.2 CC8.2 CC9.2 CC10.2 CC11.2 CC12.2 CC13.2 CC14.1 CC15.1 CC16.2 CC17.2 CC18.2 CC19.2 CC20.2 CC21.2 CC22.2 CC23.2 CC24.2 CC25.1 CC26.2 CC27.2 CC28.2 CC29.2 CC30.2 CC31.2 CC32.2 CC33.2 CC34.2 CC35.2 CC36.2 CC37.2 CC38.2 CC39.2 CC40.2 CC41.2 CC42.2 CC43.2 CC44.2 CC45.2 CC46.2 CC47.2 CC48.2 CC49.2 CC50.2 CC51.2 CC52.2 CC53.2 CC54.2 CC55.2 CC56.2 CC57.1 CC58.2 CC59.2 CC60.2 CC61.2 CC62.2 CC63.2 CC64.2 CC65.2 CC66.2 CC68.2 CC71.2 CC73.2 CC74.2 CC75.2 CC76.2 CC77.2 CC78.2 CC79.2 CC80.1 CC81.2 CC82.2 CC84.2 CC85.2 CC86.2 CD1.2 CD2.2 CD3.2 CD4.2 CD5.2 CD6.2 CD7.2 CD8.2 CD9.2 CD10.2 CD11.2 CD12.2 CD13.2 CD14.2 CD15.2 CD16.2 CD17.2 CD18.2 CD19.2 CD20.2 CD21.2 CD22.2 CD23.2 CD24.2 CD25.2 CD26.2 CD27.2 CD28.2 CD29.2 CD30.2 CD31.2 CD32.2 CD33.2 CD34.2 CD35.2 CD36.2 CD37.2 CD38.2 CD39.2 CD40.2 CD41.2 CD42.2 CD43.2 CD44.2 CD45.2 CD46.2 CD47.2 CD48.2 CD49.2 CD50.2 CD51.2 CD52.2 CD53.2 CD54.2 CD55.2 CD56.2 CD57.2 CD58.2 CD59.2 CD60.2 CD61.2 CE7.2 CE8.2 CE9.2 CE10.2 CE11.2 CE14.2 CE20.2 CE22.2 CMOS1.1 CV86.2 CV87.2 CV88.2 CV89.2 CV90.2 CV91.2 CV94.2 CV95.2 CV96.2 CV97.2 CV100.2 CV101.2 CV102.2 CV103.2 CV104.2 CV105.2 CV226.2 CV227.2 CV228.2 CV231.2 CV232.2 CV233.2 CV234.2 CV235.2 CV236.2 CV239.2 CV240.2 CV2901.2 CV2902.2 CV2918.2 CV2919.2 CV2920.2 CV2921.2 CV2926.2 CV2927.2 CV2928.2 CV2929.2 CV2930.2 CV2931.2 CV2932.2 CV2933.2 CV2934.2 CV2935.2 CV2936.2 CV2937.2 CV2938.2 CV2939.2 CV2940.2 CV2941.2 CV2942.2 CV2943.2 CV2944.2 CV2945.2 CV2946.2 CV2947.2 CV2948.2 CV2949.2 CV2950.2 CV2951.2 CV2952.2 CV2953.2 CV2954.2 CV2955.2 CV2956.2 CV2957.2 CV2958.2 CV2959.2 CV2960.2 CV2961.2 CV2962.2 CV2963.2 CV2964.2 CV2965.2 CV2966.2 CV2967.2 CV2968.2 CV2969.2 CV3047.2 CV3048.2 CV3049.2 CV3050.2 CV3051.2 CV3052.2 CV3053.2 CV3054.2 CV3056.2 CV3057.2 CV3058.2 CV3059.2 CV3060.2 CV3061.2 CV3062.2 CV3063.2 CV3064.2 D1.2 D2.1 D17.3 D17.8 D18.1 D20.1 D22.1 D27.1 D77.1 D78.1 D87.1 D88.1 DE1.1 DE2.1 H1.1(TP-1) H2.1(TP-1) H3.1(TP-1) H4.1(TP-1) H5.1(TP-1) H6.1(TP-1) H7.1(TP-1) H8.1(TP-1) H9.1(TP-1) H10.1(TP-1) H11.1(TP-1) H12.1(TP-1) H13.1(TP-1) H14.1(TP-1) H15.1(TP-1) H16.1(TP-1) H17.1(TP-1) H18.1(TP-1) H19.1(TP-1) H20.1(TP-1) H21.1(TP-1) H22.1(TP-1) H23.1(TP-1) H24.1(TP-1) H25.1(TP-1) H26.1(TP-1) H27.1(TP-1) H28.1(TP-1) H36.1(TP-1) H37.1(TP-1) H40.1(TP-1) HDMIU1.2 JAPS1.8 JAPS1.10 JAPS1.12 JAPS1.14 JAPS1.19 JAPS1.20 JBIO1.2 JBIO1.6 JBIO1.7 JBIO1.8 JBT1.2 JBT1.3 JBT1.4 JDEG1.10 JDEG1.11 JDEG1.12 JDIMM1.2 JDIMM1.3 JDIMM1.8 JDIMM1.9 JDIMM1.11 JDIMM1.13 JDIMM1.14 JDIMM1.19 JDIMM1.20 JDIMM1.25 JDIMM1.26 JDIMM1.28 JDIMM1.31 JDIMM1.32 JDIMM1.37 JDIMM1.38 JDIMM1.43 JDIMM1.44 JDIMM1.46 JDIMM1.48 JDIMM1.49 JDIMM1.54 JDIMM1.55 JDIMM1.60 JDIMM1.61 JDIMM1.63 JDIMM1.65 JDIMM1.66 JDIMM1.71 JDIMM1.72 JDIMM1.127 JDIMM1.128 JDIMM1.133 JDIMM1.134 JDIMM1.136 JDIMM1.138 JDIMM1.139 JDIMM1.144 JDIMM1.145 JDIMM1.150 JDIMM1.151 JDIMM1.153 JDIMM1.155 JDIMM1.156 JDIMM1.161 JDIMM1.162 JDIMM1.167 JDIMM1.168 JDIMM1.170 JDIMM1.172 JDIMM1.173 JDIMM1.178 JDIMM1.179 JDIMM1.184 JDIMM1.185 JDIMM1.187 JDIMM1.189 JDIMM1.190 JDIMM1.195 JDIMM1.196 JDIMM2.2 JDIMM2.3 JDIMM2.8 JDIMM2.9 JDIMM2.11 JDIMM2.13 JDIMM2.14 JDIMM2.19 JDIMM2.20 JDIMM2.25 JDIMM2.26 JDIMM2.28 JDIMM2.31 JDIMM2.32 JDIMM2.37 JDIMM2.38 JDIMM2.43 JDIMM2.44 JDIMM2.46 JDIMM2.48 JDIMM2.49 JDIMM2.54 JDIMM2.55 JDIMM2.60 JDIMM2.61 JDIMM2.63 JDIMM2.65 JDIMM2.66 JDIMM2.71 JDIMM2.72 JDIMM2.127 JDIMM2.128 JDIMM2.133 JDIMM2.134 JDIMM2.136 JDIMM2.138 JDIMM2.139 JDIMM2.144 JDIMM2.145 JDIMM2.150 JDIMM2.151 JDIMM2.153 JDIMM2.155 JDIMM2.156 JDIMM2.161 JDIMM2.162 JDIMM2.167 JDIMM2.168 JDIMM2.170 JDIMM2.172 JDIMM2.173 JDIMM2.178 JDIMM2.179 JDIMM2.184 JDIMM2.185 JDIMM2.187 JDIMM2.189 JDIMM2.190 JDIMM2.195 JDIMM2.196 JDOCK1.1 JDOCK1.7 JDOCK1.8 JDOCK1.13 JDOCK1.14 JDOCK1.19 JDOCK1.20 JDOCK1.25 JDOCK1.26 JDOCK1.31 JDOCK1.32 JDOCK1.37 JDOCK1.38 JDOCK1.43 JDOCK1.44 JDOCK1.47 JDOCK1.49 JDOCK1.50 JDOCK1.51 JDOCK1.52 JDOCK1.55 JDOCK1.57 JDOCK1.58 JDOCK1.61 JDOCK1.63 JDOCK1.64 JDOCK1.69 JDOCK1.70 JDOCK1.75 JDOCK1.76 JDOCK1.81 JDOCK1.82 JDOCK1.87 JDOCK1.88 JDOCK1.91 JDOCK1.93 JDOCK1.94 JDOCK1.95 JDOCK1.96 JDOCK1.101 JDOCK1.102 JDOCK1.107 JDOCK1.108 JDOCK1.113 JDOCK1.114 JDOCK1.119 JDOCK1.120 JDOCK1.123 JDOCK1.125 JDOCK1.126 JDOCK1.131 JDOCK1.132 JDOCK1.137 JDOCK1.138 JDOCK1.145 JDOCK1.152 JDOCK1.153 JDOCK1.154 JDOCK1.155 JDOCK1.156 JDOCK1.157 JDOCK1.158 JDOCK1.159 JDOCK1.160 JDOCK1.161 JDOCK1.162 JDOCK1.163 JDOCK1.164 JEXP1.8 JEXP1.9 JEXP1.14 JEXP1.17 JEXP1.20 JEXP1.25 JEXP1.26 JEXP1.32 JEXP1.37 JEXP1.38 JEXP1.41 JEXP1.42 JFAN1.4 JFAN1.5 JFAN1.6 JHDMI1.2 JHDMI1.5 JHDMI1.8 JHDMI1.11 JHDMI1.17 JHDMI1.20 JHDMI1.21 JHDMI1.22 JHDMI1.23 JIO1.1 JIO1.14 JIO1.19 JIO1.20 JIO1.26 JIO1.27 JIO1.32 JIO1.33 JIO1.39 JIO1.40 JIO1.45 JIO1.50 JIO1.51 JIO1.53 JIO1.55 JIO1.56 JIO1.57 JIO1.63 JIO1.64 JIO1.65 JIO1.81 JIO1.82 JKB1.1 JKB1.3 JKB1.11 JKB1.12 JLED1.10 JLED1.12 JLED1.13 JLED1.14 JLVDS1.3 JLVDS1.5 JLVDS1.15 JLVDS1.18 JLVDS1.25 JLVDS1.28 JLVDS1.41 JLVDS1.42 JLVDS1.43 JLVDS1.44 JLVDS1.45 JMED1.6 JMED1.7 JMED1.8 JMINI1.4 JMINI1.9 JMINI1.15 JMINI1.18 JMINI1.21 JMINI1.26 JMINI1.27 JMINI1.29 JMINI1.34 JMINI1.35 JMINI1.43 JMINI1.50 JMINI1.53 JMINI1.54 JMINI2.4 JMINI2.9 JMINI2.15 JMINI2.18 JMINI2.21 JMINI2.26 JMINI2.27 JMINI2.29 JMINI2.34 JMINI2.35 JMINI2.43 JMINI2.50 JMINI2.53 JMINI2.54 JPWR1.6 JPWR1.9 JPWR1.11 JPWR1.12 JSATA1.1 JSATA1.4 JSATA1.7 JSATA1.11 JSATA1.13 JSATA1.17 JSATA1.19 JSATA1.23 JSATA1.24 JSATA2.1 JSATA2.4 JSATA2.7 JSATA2.12 JSATA2.13 JSATA2.14 JSATA2.15 JSD1.3 JSD1.6 JSD1.10 JSD1.13 JSD1.17 JSD1.20 JSD1.21 JSD1.22 JSD1.23 JSD1.24 JSD1.25 JSD1.26 JSIM1.2 JSIM1.9 JSIM1.10 JSIM1.11 JSIM1.12 JSPK1.5 JSPK1.6 JTAA1.18 JTAA1.20 JTAA1.21 JTAA1.22 JTAA1.23 JTAA1.24 JTAA1.25 JTAA1.26 JTAG1.2 JTP1.8 JTP1.9 JTP1.10 JTS1.4 JTS1.5 JTS1.7 JTS1.8 JUDB1.10 JUDB1.11 JUDB1.12 JUDB1.13 JUDB1.16 JUDB1.18 JUDB1.21 JUDB1.22 JUSB1.4 JUSB1.7 JUSB1.10 JUSB1.11 JUSB1.12 JUSB1.13 JXDP1.1 JXDP1.2 JXDP1.7 JXDP1.8 JXDP1.13 JXDP1.14 JXDP1.19 JXDP1.20 JXDP1.25 JXDP1.26 JXDP1.31 JXDP1.32 JXDP1.37 JXDP1.38 JXDP1.49 JXDP1.50 JXDP1.59 ME1.1 PBATT2.1 PBATT2.2 PBATT2.4 PBATT2.10 PBATT2.11 PC3.2 PC4.2 PC6.2 PC9.2 PC10.2 PC11.2 PC12.2 PC51.1 PC52.2 PC53.2 PC54.2 PC55.2 PC56.2 PC57.2 PC58.2 PC59.2 PC67.2 PC68.2 PC69.2 PC70.2 PC71.2 PC72.2 PC100.2 PC101.2 PC102.2 PC103.2 PC105.2 PC106.2 PC107.1 PC111.2 PC112.2 PC114.2 PC115.2 PC116.2 PC150.1 PC151.1 PC152.2 PC153.2 PC154.2 PC155.2 PC156.1 PC157.2 PC158.1 PC159.1 PC163.1 PC200.2 PC201.2 PC203.2 PC204.2 PC205.2 PC206.2 PC207.2 PC300.2 PC301.2 PC302.1 PC303.2 PC306.2 PC307.1 PC309.2 PC310.2 PC311.2 PC312.2 PC313.2 PC314.2 PC315.2 PC316.2 PC317.2 PC319.2 PC321.2 PC322.2 PC323.2 PC324.2 PC360.2 PC361.2 PC362.2 PC363.2 PC364.2 PC365.2 PC366.2 PC367.2 PC368.2 PC369.2 PC370.2 PC371.2 PC372.2 PC373.2 PC374.2 PC375.2 PC376.2 PC377.2 PC378.2 PC379.2 PC380.2 PC381.2 PC382.2 PC383.2 PC384.2 PC385.2 PC386.2 PC387.2 PC388.2 PC389.2 PC401.2 PC402.2 PC406.2 PC410.2 PC411.1 PC412.2 PC414.2 PC415.2 PC416.2 PC419.2 PC420.2 PC421.2 PC422.2 PC423.2 PC428.2 PC429.2 PC430.2 PC431.2 PC432.2 PC433.2 PC434.2 PC435.2 PC436.2 PC437.2 PC439.2 PC500.1 PC502.1 PC503.2 PC504.2 PC506.2 PC507.2 PC508.2 PC510.2 PC511.2 PC512.2 PC513.2 PC514.2 PC515.2 PC600.2 PC601.2 PC602.2 PC603.2 PC604.2 PC605.2 PC613.2 PC614.2 PC615.2 PC619.2 PC621.1 PC623.1 PC624.2 PC625.2 PC626.2 PC628.2 PC660.2 PC661.2 PC662.2 PC663.2 PC664.2 PC665.2 PC666.2 PC667.2 PC668.2 PC669.2 PC670.2 PC671.2 PC672.2 PC673.2 PC674.2 PC675.2 PC676.2 PC677.2 PC678.2 PC679.2 PC680.2 PC683.2 PC684.2 PC700.2 PC701.2 PC702.2 PC703.2 PC706.2 PC708.2 PC709.2 PD1.1 PD2.1 PD5.2 PH302.2 PJP4.2 PJP401.2 PL5.2 PQ3.3 PQ5.6 PQ53.1 PQ53.2 PQ53.3 PQ54.1 PQ54.2 PQ54.3 PQ101.1 PQ101.2 PQ101.3 PQ406.1 PQ406.2 PQ406.3 PQ409.1 PQ410.3 PQ411.3 PQ502.1 PQ502.4 PQ503.1 PQ503.4 PQ506.4 PQ507.1 PQ507.4 PQ508.3 PQ512.3 PQ514.3 PQ515.1 PQ515.4 PQ516.1 PQ516.4 PQ519.1 PQ519.4 PQ521.3 PQ523.1 PQ523.4 PQ525.3 PQ527.3 PQ528.3 PQ529.3 PQ601.1 PQ601.2 PQ601.3 PQ602.1 PQ602.2 PQ602.3 PQ604.1 PQ604.2 PQ604.3 PQ605.1 PQ605.2 PQ605.3 PQ701.1 PQ701.2 PQ701.3 PQ702.4 PR12.2 PR18.2 PR19.2 PR21.2 PR53.1 PR55.2 PR56.1 PR57.1 PR59.2 PR63.2 PR64.2 PR103.2 PR109.2 PR155.1 PR204.2 PR205.2 PR305.2 PR306.2 PR307.2 PR308.2 PR309.2 PR310.2 PR405.2 PR433.2 PR444.2 PR451.2 PR452.2 PR453.2 PR509.2 PR516.2 PR537.2 PR547.2 PR556.2 PR602.2 PR616.1 PR622.1 PR624.2 PR625.2 PR635.2 PR702.1 PR705.2 PR706.2 PR708.2 PU1.2 PU51.21 PU100.1 PU100.3 PU100.14 PU100.21 PU150.10 PU150.11 PU150.12 PU150.13 PU150.14 PU150.19 PU150.23 PU150.24 PU150.25 PU150.29 PU200.11 PU300.19 PU300.22 PU300.29 PU300.33 PU301.3 PU301.9 PU401.1 PU401.2 PU402.14 PU403.4 PU404.4 PU405.3 PU500.3 PU502.3 PU503.3 PU504.3 PU505.3 PU506.3 PU600.22 PU600.25 PU700.11 PU701.5 PU701.14 PU701.23 PU701.32 PU701.37 Q5.1 Q5.4 Q9.3 Q19.1 Q19.4 Q125.4 Q133.3 Q135.3 Q140.1 Q143.1 Q143.4 QV2806.1 QZ5.1 QZ5.4 QZ21.1 QZ21.4 QZ22.4 R25.2 R26.2 R27.2 R32.1 R34.1 R47.2 R53.2 R92.2 R120.1 R121.1 R160.2 R163.2 R167.2 R175.1 R184.2 R185.2 R205.1 R211.2 R214.2 R268.2 R271.2 R303.1 R305.1 R307.1 R308.1 R309.1 R310.1 R311.2 R312.2 R313.1 R320.1 R321.2 R326.2 R342.1 R351.2 R354.1 R366.1 R370.2 R371.1 R373.1 R383.2 R384.2 R394.2 R399.1 R438.2 R474.2 R2577.1 R2581.2 R2583.1 R2585.2 R2586.2 R2592.1 R2593.1 R2626.2 R2634.1 R2644.2 R2678.2 R2689.2 R2695.1 R2696.1 R2698.1 R2705.2 RC2.2 RC22.2 RC32.2 RC46.2 RC47.2 RC50.2 RC52.2 RC69.2 RC76.2 RC78.1 RC83.2 RC85.2 RC115.2 RC125.2 RC127.1 RC128.2 RC129.2 RC131.1 RC132.2 RC133.2 RC136.1 RC152.1 RC153.1 RC154.2 RC155.1 RC156.1 RC158.2 RC159.2 RC168.2 RC169.2 RC189.2 RC191.2 RC195.2 RC198.2 RC221.2 RC232.2 RC233.2 RC235.2 RC236.1 RC237.2 RC238.2 RC239.2 RC240.2 RC241.2 RC258.2 RC260.2 RC287.2 RC288.2 RC305.1 RC306.1 RC324.1 RD5.1 RD6.1 RD11.2 RP3.5 RP16.1 RP18.2 RP18.3 RP18.4 RV29.2 RV45.1 RV46.1 RV88.1 RV89.1 RV90.1 RV92.1 RV93.1 RV2435.2 RV2436.2 RV2437.2 RV2438.2 RV2439.2 RV2440.2 RV2441.1 RV2442.2 RV2444.1 RV2447.2 RV2648.2 RV2650.2 RV2652.2 RV2654.2 RV2703.2 RV2710.2 RV2712.2 RV2714.2 RV2715.2 RV2721.2 RV2722.2 RV2723.2 RV2906.1 RV2907.1 RV2908.1 RV2909.1 SW5.4 SW5.5 SW5.6 SW6.4 SW6.5 SW6.6 U1.4 U2.4 U4.3 U4.8 U5.3 U6.B13 U6.B14 U6.C5 U6.C13 U6.C14 U6.D4 U6.D5 U6.D6 U6.D7 U6.D8 U6.D9 U6.D10 U6.D11 U6.D13 U6.D14 U6.E4 U6.E11 U6.F4 U6.F5 U6.F6 U6.F7 U6.F8 U6.F9 U6.F10 U6.F11 U6.G4 U6.G5 U6.G6 U6.G7 U6.G8 U6.G9 U6.G10 U6.G11 U6.H4 U6.H10 U6.J5 U6.J6 U6.J7 U6.J8 U6.J9 U6.J11 U6.J12 U6.K5 U6.L6 U6.L7 U6.L8 U7.4 U11.7 U13.7 U15.5 U15.10 U15.12 U15.13 U15.15 U15.16 U17.7 U17.42 U17.49 U18.11 U18.15 U19.11 U19.15 U20.3 U21.49 U22.1 U23.43 U24.3 U25.1 U25.2 U25.3 U25.4 U25.8 U25.9 U25.11 U25.18 U25.25 U27.49 U28.2 U29.1 U30.3 U33.1 U34.1 U37.B27 U37.C1 U38.B11 U38.B18 U38.B54 U38.B60 U38.B66 U38.C1 U39.3 U39.11 U39.28 U39.31 U39.33 U41.2 U42.3 U43.11 U43.15 U45.11 U45.15 U46.11 U46.15 U47.3 U51.11 U51.15 U52.6 U52.16 U52.49 U83.10 U83.21 U83.25 U86.3 U87.3 U90.11 U90.37 U91.1 U91.10 U91.12 U91.14 U91.20 U91.25 U91.27 U91.29 U93.2 U94.5 UC1.A11 UC1.A14 UC1.A18 UC1.A24 UC1.A28 UC1.A32 UC1.A36 UC1.A40 UC1.A44 UC1.A48 UC1.A52 UC1.A56 UC1.AA1 UC1.AA58 UC1.AB7 UC1.AB10 UC1.AB20 UC1.AB22 UC1.AC61 UC1.AD3 UC1.AD21 UC1.AD63 UC1.AE5 UC1.AE10 UC1.AE58 UC1.AF11 UC1.AF12 UC1.AF14 UC1.AF15 UC1.AF17 UC1.AF18 UC1.AG1 UC1.AG11 UC1.AG21 UC1.AG23 UC1.AG60 UC1.AG61 UC1.AG62 UC1.AG63 UC1.AH16 UC1.AH17 UC1.AH19 UC1.AH20 UC1.AH22 UC1.AH24 UC1.AH28 UC1.AH30 UC1.AH32 UC1.AH34 UC1.AH36 UC1.AH38 UC1.AH40 UC1.AH42 UC1.AH44 UC1.AH46 UC1.AH49 UC1.AH51 UC1.AH53 UC1.AH55 UC1.AH57 UC1.AJ13 UC1.AJ14 UC1.AJ23 UC1.AJ25 UC1.AJ27 UC1.AJ29 UC1.AJ35 UC1.AJ39 UC1.AJ41 UC1.AJ43 UC1.AJ45 UC1.AJ47 UC1.AJ50 UC1.AJ52 UC1.AJ54 UC1.AJ56 UC1.AJ58 UC1.AJ60 UC1.AJ63 UC1.AK3 UC1.AK23 UC1.AK52 UC1.AL10 UC1.AL13 UC1.AL17 UC1.AL20 UC1.AL22 UC1.AL23 UC1.AL26 UC1.AL29 UC1.AL31 UC1.AL33 UC1.AL36 UC1.AL39 UC1.AL40 UC1.AL45 UC1.AL46 UC1.AL51 UC1.AL52 UC1.AL54 UC1.AL57 UC1.AL60 UC1.AL61 UC1.AM1 UC1.AM17 UC1.AM23 UC1.AM31 UC1.AM52 UC1.AN7 UC1.AN17 UC1.AN23 UC1.AN31 UC1.AN32 UC1.AN35 UC1.AN36 UC1.AN39 UC1.AN40 UC1.AN42 UC1.AN43 UC1.AN45 UC1.AN46 UC1.AN48 UC1.AN49 UC1.AN51 UC1.AN52 UC1.AN60 UC1.AN63 UC1.AP3 UC1.AP10 UC1.AP17 UC1.AP20 UC1.AP22 UC1.AP23 UC1.AP26 UC1.AP29 UC1.AP31 UC1.AP38 UC1.AP39 UC1.AP48 UC1.AP52 UC1.AP54 UC1.AP57 UC1.AR5 UC1.AR11 UC1.AR15 UC1.AR17 UC1.AR23 UC1.AR31 UC1.AR33 UC1.AR39 UC1.AR43 UC1.AR49 UC1.AR52 UC1.AT13 UC1.AT35 UC1.AT37 UC1.AT40 UC1.AT42 UC1.AT43 UC1.AT46 UC1.AT49 UC1.AT61 UC1.AT62 UC1.AT63 UC1.AU1 UC1.AU16 UC1.AU18 UC1.AU20 UC1.AU22 UC1.AU24 UC1.AU26 UC1.AU28 UC1.AU30 UC1.AU33 UC1.AU51 UC1.AU53 UC1.AU55 UC1.AU57 UC1.AU59 UC1.AV8 UC1.AV14 UC1.AV16 UC1.AV20 UC1.AV24 UC1.AV28 UC1.AV33 UC1.AV34 UC1.AV36 UC1.AV39 UC1.AV41 UC1.AV43 UC1.AV46 UC1.AV49 UC1.AV51 UC1.AV55 UC1.AV59 UC1.AW4 UC1.AW16 UC1.AW24 UC1.AW33 UC1.AW35 UC1.AW37 UC1.AW40 UC1.AW42 UC1.AW44 UC1.AW47 UC1.AW50 UC1.AW51 UC1.AW59 UC1.AW60 UC1.AY4 UC1.AY6 UC1.AY11 UC1.AY16 UC1.AY18 UC1.AY22 UC1.AY24 UC1.AY26 UC1.AY30 UC1.AY33 UC1.AY51 UC1.AY53 UC1.AY57 UC1.AY59 UC1.B4 UC1.B20 UC1.B24 UC1.B26 UC1.B28 UC1.B32 UC1.B36 UC1.B40 UC1.B44 UC1.B48 UC1.B52 UC1.B56 UC1.B60 UC1.C11 UC1.C14 UC1.C18 UC1.C20 UC1.C25 UC1.C27 UC1.C38 UC1.C39 UC1.C57 UC1.D2 UC1.D5 UC1.D8 UC1.D12 UC1.D14 UC1.D18 UC1.D21 UC1.D23 UC1.D25 UC1.D26 UC1.D27 UC1.D29 UC1.D30 UC1.D31 UC1.D33 UC1.D34 UC1.D35 UC1.D37 UC1.D38 UC1.D39 UC1.D41 UC1.D42 UC1.D43 UC1.D45 UC1.D46 UC1.D47 UC1.D49 UC1.D50 UC1.D51 UC1.D53 UC1.D54 UC1.D55 UC1.D57 UC1.D59 UC1.D62 UC1.D63 UC1.E11 UC1.E17 UC1.F20 UC1.F26 UC1.F30 UC1.F34 UC1.F38 UC1.F42 UC1.F46 UC1.F50 UC1.F54 UC1.F58 UC1.F61 UC1.G3 UC1.G5 UC1.G6 UC1.G8 UC1.G18 UC1.G22 UC1.H13 UC1.H17 UC1.H57 UC1.J10 UC1.J22 UC1.J59 UC1.J63 UC1.K1 UC1.K12 UC1.L7 UC1.L13 UC1.L15 UC1.L17 UC1.L18 UC1.L20 UC1.L58 UC1.L61 UC1.M22 UC1.N3 UC1.N10 UC1.N21 UC1.P22 UC1.P59 UC1.P62 UC1.P63 UC1.R8 UC1.R10 UC1.R22 UC1.T1 UC1.T58 UC1.U9 UC1.U20 UC1.U22 UC1.U61 UC1.V3 UC1.V7 UC1.V10 UC1.V23 UC1.V58 UC1.W20 UC1.W22 UC1.Y10 UC1.Y59 UC1.Y63 UC2.3 UC3.3 UC4.3 UC5.4 UC6.7 UC6.15 UC7.3 US1.1 UV1.A2 UV1.A26 UV1.AA7 UV1.AB7 UV1.AB11 UV1.AB14 UV1.AB17 UV1.AB20 UV1.AB24 UV1.AC2 UV1.AC5 UV1.AC8 UV1.AC22 UV1.AC26 UV1.AD12 UV1.AD13 UV1.AD15 UV1.AD16 UV1.AD18 UV1.AD19 UV1.AD21 UV1.AD22 UV1.AE11 UV1.AE14 UV1.AE17 UV1.AE20 UV1.AF1 UV1.AF5 UV1.AF8 UV1.AF11 UV1.AF14 UV1.AF17 UV1.AF20 UV1.AF23 UV1.AG2 UV1.AG26 UV1.B1 UV1.B5 UV1.B8 UV1.B11 UV1.B14 UV1.B17 UV1.B20 UV1.B23 UV1.B27 UV1.E2 UV1.E5 UV1.E8 UV1.E11 UV1.E14 UV1.E17 UV1.E20 UV1.E22 UV1.E25 UV1.H2 UV1.H5 UV1.H23 UV1.H25 UV1.K11 UV1.K13 UV1.K15 UV1.K17 UV1.L2 UV1.L5 UV1.L10 UV1.L12 UV1.L14 UV1.L16 UV1.L18 UV1.L23 UV1.L25 UV1.M11 UV1.M13 UV1.M15 UV1.M17 UV1.N10 UV1.N12 UV1.N14 UV1.N16 UV1.N18 UV1.P2 UV1.P5 UV1.P11 UV1.P13 UV1.P15 UV1.P17 UV1.P23 UV1.P26 UV1.R10 UV1.R12 UV1.R14 UV1.R16 UV1.R18 UV1.T11 UV1.T13 UV1.T15 UV1.T17 UV1.U2 UV1.U5 UV1.U10 UV1.U12 UV1.U14 UV1.U16 UV1.U18 UV1.U23 UV1.U26 UV1.V11 UV1.V13 UV1.V15 UV1.V17 UV1.Y2 UV1.Y5 UV1.Y23 UV1.Y26 UV4.A9 UV4.B1 UV4.B3 UV4.B9 UV4.D1 UV4.D8 UV4.E1 UV4.E2 UV4.E8 UV4.F9 UV4.G1 UV4.G8 UV4.G9 UV4.J2 UV4.J8 UV4.M1 UV4.M9 UV4.P1 UV4.P9 UV4.T1 UV4.T9 UV5.A9 UV5.B1 UV5.B3 UV5.B9 UV5.D1 UV5.D8 UV5.E1 UV5.E2 UV5.E8 UV5.F9 UV5.G1 UV5.G8 UV5.G9 UV5.J2 UV5.J8 UV5.M1 UV5.M9 UV5.P1 UV5.P9 UV5.T1 UV5.T9 UV6.A9 UV6.B1 UV6.B3 UV6.B9 UV6.D1 UV6.D8 UV6.E1 UV6.E2 UV6.E8 UV6.F9 UV6.G1 UV6.G8 UV6.G9 UV6.J2 UV6.J8 UV6.M1 UV6.M9 UV6.P1 UV6.P9 UV6.T1 UV6.T9 UV7.A9 UV7.B1 UV7.B3 UV7.B9 UV7.D1 UV7.D8 UV7.E1 UV7.E2 UV7.E8 UV7.F9 UV7.G1 UV7.G8 UV7.G9 UV7.J2 UV7.J8 UV7.M1 UV7.M9 UV7.P1 UV7.P9 UV7.T1 UV7.T9 UV14.3 Y1.2 Y1.4 Y3.2 Y3.4 YV2401.2 YV2401.4
GNDA: C115.2 C116.2 C117.2 C131.2 C138.2 C140.2 C141.1 C142.1 C144.1 C150.2 C167.1 C169.2 C385.2 C412.2 C2980.1 JIO1.67 JIO1.70 JIO1.73 JIO1.74 JIO1.78 JIO1.79 PJP4.1 Q20.3 Q21.1 Q21.4 Q123.1 Q123.4 R39.2 U17.26 U17.36
GNDA_CHG: PC407.1 PC409.2 PC413.1 PC424.2 PC425.1 PC427.2 PC438.1 PJP401.1 PR424.1 PR428.2 PU402.21
VCCSENSE: PR334.1 RC250.2 UC1.E63
VCCST_PWRGD: RC245.2 UC1.B59
VDD_1.35V: PC111.1 PR101.1 PR102.2 PU100.11
VDDA18CR: C3031.1 C3032.1 U90.14
VDDA18PLL: C3033.1 C3034.1 U90.34
VSSSENSE: PR335.1 RC260.1 UC1.E62
3301_ACAV_IN_NB: PR545.1 PU701.24
3301_DSCHRG_FET_GC: PR510.2 PR559.2
3301_PWRSRC: PR558.1 PU701.15
+ALC290_LDO_CAP: C140.1 U17.21
+ALC3226_CPVEE: C138.1 U17.34
+ALC3226_VREF: C167.2 C169.1 U17.25
+AUX_LDO: C241.1 U27.12
+BATT_SUM: PD500.1 PD502.2 PD502.3 PQ501.1 PQ501.2 PQ501.3 PQ504.5 PQ504.6 PQ504.7 PQ504.8 PQ511.5 PQ511.6 PQ511.7 PQ511.8 PR502.1
+BL_PWR_SRC: C439.1 C453.2 JLVDS1.9 JLVDS1.10 JLVDS1.11 Q124.1 Q124.2 Q124.5 Q124.6
+CAP_LDO: C336.1 U37.B46
+CHGR_DC_IN: PD400.1 PR420.1 PR530.1
+COINCELL: JBT1.1 RTCR1.1
+DC1_PWR_SRC: PC52.1 PC53.1 PC54.1 PC55.1 PC56.1 PC57.1 PC58.1 PC59.1 PC68.1 PL51.2 PQ51.5 PQ52.5 PU51.12
+DC_IN: PC5.1 PC11.1 PL4.2 PQ4.1 PQ4.2 PQ4.3 PQ5.3 PR14.1 PR19.1 PR445.1 PR533.1
+DC_IN_SS: PC6.1 PC9.1 PD400.3 PQ4.5 PQ4.6 PQ4.7 PQ4.8 PQ400.5 PQ520.3 PR18.1 PR529.1 PR544.2
+DCIN: PC411.2 PR420.2 PU402.20
+DCIN_JACK: PC10.1 PJPDC1.2 PJPDC1.3 PL4.1
+DCPRRTC: CC36.1 UC1.AE7
+DIMM1_VREF_DQ: CD1.1 CD2.1 JDIMM1.1 RD1.2
+DIMM2_VREF_DQ: CD32.1 CD33.1 JDIMM2.1 RD7.2
+DOCK_PWR_BAR: C317.1 C318.1 CE7.1 D20.2 D20.3 JDOCK1.146 JDOCK1.147 JDOCK1.148 JDOCK1.149 JDOCK1.150 JDOCK1.151 PD400.2 PD505.2 PD505.3 PQ510.5 PQ510.6 PQ510.7 PQ510.8 PQ524.5 PR516.1 PR531.2
+FB_PLLAVDD: CV228.1 CV3057.1 L73.1 LV76.1 UV1.F16 UV1.H22 UV1.P22
+GPU_CORE: PC660.1 PC661.1 PC662.1 PC663.1 PC664.1 PC665.1 PC666.1 PC667.1 PC668.1 PC669.1 PC670.1 PC671.1 PC672.1 PC673.1 PJP601.2 PJP602.2 PJP603.2 RZ40.1 UV1.K10 UV1.K12 UV1.K14 UV1.K16 UV1.K18 UV1.L11 UV1.L13 UV1.L15 UV1.L17 UV1.M10 UV1.M12 UV1.M14 UV1.M16 UV1.M18 UV1.N11 UV1.N13 UV1.N15 UV1.N17 UV1.P10 UV1.P12 UV1.P14 UV1.P16 UV1.P18 UV1.R11 UV1.R13 UV1.R15 UV1.R17 UV1.T10 UV1.T12 UV1.T14 UV1.T16 UV1.T18 UV1.U11 UV1.U13 UV1.U15 UV1.U17 UV1.V10 UV1.V12 UV1.V14 UV1.V16 UV1.V18
+LCDVDD: C430.1 JLVDS1.39 JLVDS1.40 U33.3
+LOM_VCT: C316.1 JDOCK1.116 JDOCK1.118
+NBDOCK_DC_IN_SS: JDOCK1.41 PQ500.1 PQ517.3 PQ522.1 PR528.2
+PBATT: PL1.2 PL2.2 PQ505.1 PQ505.2 PQ505.3 PQ526.3 PR534.2 PR565.1
+PBATT_IN_SS: PD500.2 PD500.3 PD501.2 PQ501.5 PQ501.6 PQ501.7 PQ501.8 PQ505.5 PQ505.6 PQ505.7 PQ505.8 PR509.1
+PCH_ASATA3PLL: CC49.1 CC77.1 LC2.2 RC14.1 RC19.2 UC1.B11
+PCH_AUSB3PLL: CC42.1 CC76.1 LC1.2 RC161.1 RC163.1 UC1.B18
+PCH_DCPSUS: CC61.1 CC62.1 CC66.1 RC276.2 UC1.AH13 UC1.J13
+PCH_DCPSUS1: CC54.1 RC272.2 UC1.AD8 UC1.AD10
+PCH_DCPSUS4: CC53.1 CC75.1 LC4.2 UC1.AB8
+PCH_RTC_VCCSUS3_3: CC30.1 RC261.2 RC264.2 UC1.AH11
+PCH_VCC1P05: CC51.1 CC79.1 LC3.2 UC1.J18 UC1.K19
+PCH_VCCACLKPLL: CC58.1 CC78.1 LC6.2 RC45.2 UC1.A20
+PCH_VCCDSW: C413.2 RC275.2 UC1.AG19 UC1.AG20
+PCH_VCCDSW3_3: C413.1 CC32.1 JAPS1.3 JAPS1.7 RC197.2 RC206.2 RC265.2 RC267.2 RP3.6 RP3.7 RP14.1 UC1.AH10
+PCH_VCCDSW_R: CC65.1 RC275.1
+PECI_VREF: C360.1 R374.1 U38.B51
+PNVVDD: PC674.1 PC675.1 PC676.1 PC677.1 PC678.1 PC679.1 PC680.1 PC683.1 PC684.1 PJP601.1 PJP602.1 PJP603.1 PL601.3 PL601.4 PL602.3 PL602.4 PR620.1
+PWR_SRC: C438.1 PC419.1 PC420.1 PJP100.1 PJP150.2 PJP300.1 PJP600.1 PJP700.2 PL51.1 PL401.2 PR426.1 Q124.4 R2576.1
+PWR_SRC_AC: PC503.1 PC504.1 PC505.1 PD505.1 PL400.1 PQ510.1 PQ510.2 PQ510.3 PR400.4 PR558.2
+RSVD_VCC3P3_1: R178.2 U21.1
+RTC_CELL: C50.1 CC35.1 CC38.1 CC39.1 R208.1 R327.1 R328.1 R332.1 RC1.1 RC6.1 RC7.1 RC8.1 RC73.2 RP17.5 RP17.6 RTCD1.1 UC1.AG10
+RTC_CELL_VBAT: C345.1 R332.2 U38.B64
+SD_IO_LDO: C216.2 C220.2 U27.25
+SDC_IN: PC400.1 PC406.1 PQ400.1 PQ400.2 PQ400.3 PR400.1 PR421.1 PR422.1 PR542.1 PU401.3
+SIM_PWR: C263.1 JMINI2.8 JSIM1.1 U28.5
+SM_VREF_CA: CC67.1 RC68.2 UC1.AP49
+SM_VREF_CA_DIMM: RC67.2 RC68.1 RC69.1 RD12.2 RD13.2
+SM_VREF_CA_DIMMA: CD12.1 CD13.1 JDIMM1.126 RD12.1
+SM_VREF_CA_DIMMB: CD43.1 CD44.1 JDIMM2.126 RD13.1
+SM_VREF_DQ0: CC70.1 RC173.2 UC1.AR51
+SM_VREF_DQ0_DIMM1: RC173.1 RC217.2 RC221.1 RD1.1
+SM_VREF_DQ1: CC69.1 RC126.2 UC1.AP51
+SM_VREF_DQ1_DIMM2: RC126.1 RC130.2 RC132.1 RD7.1
+SWR_LX: L51.1 U52.17
+SWR_V12: C434.1 C435.1 C436.1 C437.1 L51.2 U52.11 U52.15 U52.43
+V_DDR_REF: PC112.1 PU100.4
+VCHGR: PC421.1 PC422.1 PC423.1 PD502.1 PQ504.1 PQ504.2 PQ504.3 PR426.4
+VHDMI_VCC: C87.1 C88.1 HDMIU1.3 JHDMI1.18
+VLDOIN_1.35V: PJP101.1 PU100.19
+VR_CAP: C366.1 U38.B12
+VREFC_UV5: CV2902.1 RV2709.2 RV2710.1 UV4.M8 UV5.M8
+VREFC_UV7: CV2942.1 RV2713.2 RV2714.1 UV6.M8 UV7.M8
+VREFD_UV5: CV2941.1 RV2711.2 RV2712.1 UV4.H1 UV5.H1
+VREFD_UV7: CV2943.1 RV2715.1 RV2716.2 UV6.H1 UV7.H1
+VREFOUT: C131.1 R187.2 R197.2 U17.23
-DCIN_JACK: PC12.1 PJPDC1.4 PJPDC1.5 PL5.1
A_DE_0B: R2636.2 U83.16
A_DE_1B: R2637.2 U83.18
A_EQ_0B: R2634.2 U83.17
A_EQ_1B: R2635.2 U83.15
A_ON: PR154.1 PR703.1 R424.1 RP18.6 U38.B24
AC_DIS: PQ5.5 PR525.1 U37.B12
AC_PRESENT: RP14.8 U38.A54 UC1.AJ8
ACAV_DOCK_SRC#: JDOCK1.42 PR538.2 PR541.1
ACAV_IN: PQ411.2 PQ521.2 PR427.1 PR548.1 R344.2 U38.A64
ACAV_IN#: PQ516.5 PQ521.1 PR519.2 PR532.2
ACAV_IN_NB: PR450.2 PR545.2 U38.B20
ACAVDK_SRC: PR541.2 PU701.4
ACAVIN: PR548.2 PU701.8
ALW_PWRGD_3V_5V: PR60.1 U38.A1
ALWON: PR65.1 U38.A60
AUD_HP_NB_SENSE: C137.1 C408.1 JIO1.68 Q20.2 R163.1 U37.A41
AUD_HP_OUT_L: JIO1.76 R162.2
AUD_HP_OUT_R: JIO1.72 R166.2
AUD_NB_MUTE#: C410.1 R150.2 R153.1 U17.47 U37.A39
AUD_OUT_L: R162.1 U17.33
AUD_OUT_R: R166.1 U17.32
AUD_PC_BEEP: C133.2 C143.2 U17.12
AUD_SENSE_A: R152.1 U17.13
AUD_SENSE_B: R156.1 R157.1 U17.14
AUX_EN_WOWL: RC189.1 U37.B67 U51.3
B-RAMP: PR302.2 PR307.1 PU300.11
B_DE_0B: R2630.2 U83.3
B_DE_1B: R2631.2 U83.6
B_EQ_0B: R2628.2 U83.2
B_EQ_1B: R2629.2 U83.4
BAT1_LED#: R433.1 U37.B64
BAT2_LED#: R429.1 U37.A9
BATDRV#: PQ504.4 PR432.2
BATT_WHITE_LED#: JLED1.6 R429.2
BATT_YELLOW_LED#: JLED1.7 R433.2
BBS_BIT: RC218.2 RC287.1 UC1.L8
BC_CLK_ECE1117: JKB1.2 U38.A20
BC_CLK_ECE5048: U37.A30 U38.A43
BC_DAT_ECE1117: JKB1.4 RP18.8 U38.B21
BC_DAT_ECE5048: R343.2 U37.B31 U38.B45
BC_INT#_ECE1117: JKB1.5 U38.A19
BC_INT#_ECE5048: U37.A29 U38.A42
BEEP: R353.2 U38.B19
BIA_PWM_CVT: D79.2 U52.19
BIA_PWM_EC: D79.3 U38.B25
BIA_PWM_OUT: D79.1 LE2.1 R2585.1
BLUE_CRT: JIO1.38 U39.22
BLUE_DOCK: L71.1 U39.21
BLUE_DOCK_PI: JDOCK1.45 L71.2
BOARD_ID: C368.1 R392.2 U38.B10
BOOT_1.35V: PR100.2 PU100.18
BPM#0: RC194.1 UC1.J60
BPM#1: RC204.1 UC1.H60
BQ24715_3.3V: PR425.2 PR427.2 PR428.1 PU402.5
BQ24715_REGN: PC410.1 PD401.2 PR425.1 PR431.1 PR448.1 PU402.16
BREATH_LED#: JDOCK1.98 Q28.1 R436.1 U37.B39
BREATH_LED#_Q: JPWR1.4 Q28.6
BREATH_WHITE_LED#: JLED1.8 R436.2
BST_3V: PR62.2 PU51.9
BST_5V: PR61.1 PU51.17
BST_+V1.05SP: PC165.1 PU150.5
BST_+VDDRP: PR701.1 PU700.10
BT_LED#: JMINI1.46 Q30.1 R229.1
BT_RADIO_DIS#: D14.1 R225.1 R298.2 U37.A13
BT_RADIO_DIS#_R: D14.2 JMINI1.51 R225.2
CAM_MIC_CBL_DET#: JLVDS1.8 RC193.2 UC1.F4
CARD_SMBCLK: JEXP1.34 RP15.3 U38.A49
CARD_SMBDAT: JEXP1.36 RP15.4 U38.B52
CCD_OFF: R2601.2 U37.B43
CD3301_DCIN: PC511.1 PR533.2 PU701.1
CD3301_SDC_IN: PR542.2 PU701.6
CD_PBATT_OFF: PR543.1 PU701.26
CFD_PWRBTN#_XDP: JXDP1.41 RC107.2
CFG0: JXDP1.9 RC232.1 UC1.AC60
CFG1: JXDP1.11 RC233.1 UC1.AC62
CFG2: JXDP1.15 UC1.AC63
CFG3: JXDP1.17 RC99.2 UC1.AA63
CFG3_R: JXDP1.60 RC99.1
CFG4: JXDP1.27 RC238.1 UC1.AA60
CFG5: JXDP1.29 UC1.Y62
CFG6: JXDP1.33 UC1.Y61
CFG7: JXDP1.35 UC1.Y60
CFG8: JXDP1.10 RC241.1 UC1.V62
CFG9: JXDP1.12 RC240.1 UC1.V61
CFG10: JXDP1.16 RC239.1 UC1.V60
CFG11: JXDP1.18 UC1.U60
CFG12: JXDP1.28 UC1.T63
CFG13: JXDP1.30 UC1.T62
CFG14: JXDP1.34 UC1.T61
CFG15: JXDP1.36 UC1.T60
CFG16: JXDP1.6 UC1.AA62
CFG17: JXDP1.4 UC1.AA61
CFG18: JXDP1.24 UC1.U63
CFG19: JXDP1.22 UC1.U62
CFG_RCOMP: RC235.1 UC1.V63
CHAGER_SRC: PC401.1 PC402.1 PC412.1 PC414.1 PC415.1 PC416.1 PC430.1 PC436.1 PC437.1 PL400.2 PQ404.5
CHARGE_EN: R313.2 U37.A45
CHARGER_CELL_PIN: PD504.2 PR431.2 PU402.10
CHARGER_SMBCLK: PR430.1 RP16.6 U38.B50
CHARGER_SMBDAT: PR429.1 RP16.5 U38.A47
CHG_LGATE: PQ406.4 PU402.15
CHG_UGATE: PQ404.4 PU402.18
CHGVR_DCIN: PR530.2 PU701.35
CIICSCL: R2598.1 U52.13
CIICSDA: R2597.1 U52.14
CLK_27M_IN: R66.1 R107.2 U6.K1
CLK_27M_IN_R: C42.1 R107.1 Y1.1
CLK_27M_OUT: C43.1 R66.2 U6.L1 Y1.3
CLK_BIASREF: RC45.1 UC1.C26
CLK_DDC2_CRT: JIO1.48 U39.14
CLK_DDC2_DOCK: JDOCK1.48 U39.15
CLK_KBD: JDOCK1.78 RP4.8 U38.A38
CLK_MSE: JDOCK1.71 RP4.7 U38.A39
CLK_PCI_5048: R324.1 RC61.2 RC184.2 U37.A28
CLK_PCI_DOCK: JDOCK1.121 R273.1 RC64.2
CLK_PCI_FBIN: CC23.1 RC100.2 UC5.8
CLK_PCI_LPDEBUG: R244.1 RC66.2
CLK_PCI_MEC: R382.1 RC63.2 RC187.2 U38.A29
CLK_PCI_TPM_TCM: R290.1 RC58.2 RC182.2 U25.21
CLK_PCIE_EXP: JEXP1.18 RC188.2 RC200.2
CLK_PCIE_EXP#: JEXP1.16 RC160.2 RC164.2
CLK_PCIE_FMC: JMINI2.13 UC1.C37
CLK_PCIE_FMC#: JMINI2.11 UC1.B38
CLK_PCIE_LAN: RC49.2 U21.44
CLK_PCIE_LAN#: RC48.2 U21.45
CLK_PCIE_MINI2: JMINI1.13 RC60.2
CLK_PCIE_MINI2#: JMINI1.11 RC59.2
CLK_PCIE_MMI: RC54.2 U27.3
CLK_PCIE_MMI#: RC53.2 U27.2
CLK_PEG_VGA: RC179.2 UV1.AE8
CLK_PEG_VGA#: RC157.2 UV1.AD8
CLK_TP_SIO: R444.1 U38.A37
CLKA0: RV2706.1 RV2707.2 UV1.D24 UV4.J7 UV5.J7
CLKA0#: RV2706.2 RV2708.2 UV1.D25 UV4.K7 UV5.K7
CLKA1: RV2717.1 RV2718.2 UV1.N22 UV6.J7 UV7.J7
CLKA1#: RV2717.2 RV2719.2 UV1.M22 UV6.K7 UV7.K7
CLKRQ_GPU#: QC11.4 RV2433.2 UV1.AC6
CLKRUN#: RC80.2 U25.15 U37.B20 U38.A32 UC1.V5
CODEC_IRQ: RC154.1 UC1.L4
CPU_DETECT#: R284.2 U37.A3 UC1.D61
CPU_DPB_AUX: C19.1 RC153.2 UC1.B5
CPU_DPB_AUX#: C20.1 RC147.2 UC1.C5
CPU_DPB_AUX#_C: C20.2 U6.H2
CPU_DPB_AUX_C: C19.2 U6.H1
CPU_DPB_CTRLCLK: RP1.8 UC1.B9
CPU_DPB_CTRLDAT: RP1.7 UC1.C9
CPU_DPC_AUX: RC155.2 UC1.A6
CPU_DPC_AUX#: RC149.2 UC1.B6
CPU_PWR_DEBUG#: RC108.1 RC253.2 RC258.1 UC1.H59
CPU_PWR_DEBUG#_R: JXDP1.45 RC108.2
CPU_VTT_ON: R305.2 U37.B17
CPU_XDP_PRDY#: JXDP1.5 UC1.J62
CPU_XDP_PREQ#: JXDP1.3 RC120.2 UC1.K62
CPU_XDP_TCLK: JXDP1.57 RC97.1 RC124.1 RC127.2 UC1.E60
CPU_XDP_TDI: RC119.2 RC209.2 UC6.6
CPU_XDP_TDI_R: RC209.1 UC1.F63
CPU_XDP_TDO: RC122.2 RC208.2 UC6.3
CPU_XDP_TDO_R: RC208.1 UC1.F62
CPU_XDP_TMS: RC118.2 UC1.E61 UC6.8
CPU_XDP_TRST#: RC131.2 RC135.1 UC1.E59 UC6.11
CRT_SWITCH: U37.B52 U39.30
CS_1.35V: PR101.2 PU100.13
CSN1: PC318.2 PC320.2 PL300.3 PR329.2 PR333.2 PU300.18
CSP1: PC318.1 PC320.1 PH301.1 PR328.2 PR333.1 PU300.17
CSS_GC: PR403.1 PU701.10
CSSN_1: PC408.2 PC409.1 PQ401.3 PQ403.2 PR408.1 PR410.2 PR418.1 PU401.5 PU402.1
CSSP_1: PC407.2 PC408.1 PC438.2 PQ402.3 PQ403.5 PR410.1 PR411.2 PR417.1 PU402.2
D_CLKRUN#: JDOCK1.111 RP5.3 U37.A19
D_DLDRQ1#: JDOCK1.117 RP5.1 U37.B24
D_LAD0: JDOCK1.97 U37.B29
D_LAD1: JDOCK1.99 U37.B28
D_LAD2: JDOCK1.103 U37.A25
D_LAD3: JDOCK1.105 U37.A24
D_LFRAME#: JDOCK1.109 U37.B23
D_SERIRQ: JDOCK1.115 RP5.2 U37.A20
DACA_VDD: UV1.W5
DACA_VREF: UV1.AE2
DAI_12MHZ#: JDOCK1.89 R137.1 RE4.1
DAI_BCLK#: JDOCK1.77 R139.1 RE5.1
DAI_DI: JDOCK1.83 R144.1
DAI_DO#: JDOCK1.85 R141.1
DAI_LRCK#: JDOCK1.79 R143.1
DAT_DDC2_CRT: JIO1.46 U39.12
DAT_DDC2_DOCK: JDOCK1.46 U39.13
DAT_KBD: JDOCK1.80 RP4.6 U38.B41
DAT_MSE: JDOCK1.73 RP4.5 U38.B42
DAT_TP_SIO: R441.1 U38.B40
DC_BLOCK_GC: PQ400.4 PU701.7
DC_IN_SS: PR529.2 PU701.34
DC_TEST_A3_B3: UC1.A3 UC1.B3
DC_TEST_A4: RC139.2 UC1.A4
DC_TEST_A60: RC143.2 UC1.A60
DC_TEST_A61_B61: UC1.A61 UC1.B61
DC_TEST_A62: RC143.1 UC1.A62
DC_TEST_AV1: RC145.2 UC1.AV1
DC_TEST_AW1: RC145.1 UC1.AW1
DC_TEST_AW63: RC141.2 UC1.AW63
DC_TEST_AY2_AW2: UC1.AW2 UC1.AY2
DC_TEST_AY3_AW3: UC1.AW3 UC1.AY3
DC_TEST_AY60: RC141.1 UC1.AY60
DC_TEST_AY61_AW61: UC1.AW61 UC1.AY61
DC_TEST_AY62_AW62: UC1.AW62 UC1.AY62
DC_TEST_B62_B63: UC1.B62 UC1.B63
DC_TEST_C1_C2: UC1.C1 UC1.C2
DDI1_LANE_N0: C156.1 UC1.C54
DDI1_LANE_N0_C: C156.2 U6.G2
DDI1_LANE_N1: C158.1 UC1.B58
DDI1_LANE_N1_C: C158.2 U6.F2
DDI1_LANE_N2: C160.1 UC1.B55
DDI1_LANE_N2_C: C160.2 U6.E2
DDI1_LANE_N3: C162.1 UC1.A57
DDI1_LANE_N3_C: C162.2 U6.D2
DDI1_LANE_P0: C155.1 UC1.C55
DDI1_LANE_P0_C: C155.2 U6.G1
DDI1_LANE_P1: C157.1 UC1.C58
DDI1_LANE_P1_C: C157.2 U6.F1
DDI1_LANE_P2: C159.1 UC1.A55
DDI1_LANE_P2_C: C159.2 U6.E1
DDI1_LANE_P3: C161.1 UC1.B57
DDI1_LANE_P3_C: C161.2 U6.D1
DDR3_DRAMRST#: CD3.1 CD34.1 JDIMM1.30 JDIMM2.30 RC279.1
DDR3_DRAMRST#_CPU: RC279.2 RD3.2 UC1.AV15
DDR_A_BS0: JDIMM1.109 UC1.AU35
DDR_A_BS1: JDIMM1.108 UC1.AV35
DDR_A_BS2: JDIMM1.79 UC1.AY41
DDR_A_CAS#: JDIMM1.115 UC1.AU34
DDR_A_D0: JDIMM1.129 UC1.AH63
DDR_A_D1: JDIMM1.131 UC1.AH62
DDR_A_D2: JDIMM1.141 UC1.AK63
DDR_A_D3: JDIMM1.140 UC1.AK62
DDR_A_D4: JDIMM1.132 UC1.AH61
DDR_A_D5: JDIMM1.130 UC1.AH60
DDR_A_D6: JDIMM1.143 UC1.AK61
DDR_A_D7: JDIMM1.142 UC1.AK60
DDR_A_D8: JDIMM1.7 UC1.AM63
DDR_A_D9: JDIMM1.4 UC1.AM62
DDR_A_D10: JDIMM1.17 UC1.AP63
DDR_A_D11: JDIMM1.18 UC1.AP62
DDR_A_D12: JDIMM1.6 UC1.AM61
DDR_A_D13: JDIMM1.5 UC1.AM60
DDR_A_D14: JDIMM1.15 UC1.AP61
DDR_A_D15: JDIMM1.16 UC1.AP60
DDR_A_D16: JDIMM1.159 UC1.AP58
DDR_A_D17: JDIMM1.157 UC1.AR58
DDR_A_D18: JDIMM1.146 UC1.AM57
DDR_A_D19: JDIMM1.148 UC1.AK57
DDR_A_D20: JDIMM1.149 UC1.AL58
DDR_A_D21: JDIMM1.147 UC1.AK58
DDR_A_D22: JDIMM1.158 UC1.AR57
DDR_A_D23: JDIMM1.160 UC1.AN57
DDR_A_D24: JDIMM1.24 UC1.AP55
DDR_A_D25: JDIMM1.22 UC1.AR55
DDR_A_D26: JDIMM1.36 UC1.AM54
DDR_A_D27: JDIMM1.34 UC1.AK54
DDR_A_D28: JDIMM1.23 UC1.AL55
DDR_A_D29: JDIMM1.21 UC1.AK55
DDR_A_D30: JDIMM1.33 UC1.AR54
DDR_A_D31: JDIMM1.35 UC1.AN54
DDR_A_D32: JDIMM1.166 UC1.AY58
DDR_A_D33: JDIMM1.165 UC1.AW58
DDR_A_D34: JDIMM1.175 UC1.AY56
DDR_A_D35: JDIMM1.174 UC1.AW56
DDR_A_D36: JDIMM1.163 UC1.AV58
DDR_A_D37: JDIMM1.164 UC1.AU58
DDR_A_D38: JDIMM1.177 UC1.AV56
DDR_A_D39: JDIMM1.176 UC1.AU56
DDR_A_D40: JDIMM1.42 UC1.AY54
DDR_A_D41: JDIMM1.41 UC1.AW54
DDR_A_D42: JDIMM1.50 UC1.AY52
DDR_A_D43: JDIMM1.51 UC1.AW52
DDR_A_D44: JDIMM1.39 UC1.AV54
DDR_A_D45: JDIMM1.40 UC1.AU54
DDR_A_D46: JDIMM1.52 UC1.AV52
DDR_A_D47: JDIMM1.53 UC1.AU52
DDR_A_D48: JDIMM1.69 UC1.AK40
DDR_A_D49: JDIMM1.67 UC1.AK42
DDR_A_D50: JDIMM1.59 UC1.AM43
DDR_A_D51: JDIMM1.57 UC1.AM45
DDR_A_D52: JDIMM1.56 UC1.AK45
DDR_A_D53: JDIMM1.58 UC1.AK43
DDR_A_D54: JDIMM1.68 UC1.AM40
DDR_A_D55: JDIMM1.70 UC1.AM42
DDR_A_D56: JDIMM1.192 UC1.AM46
DDR_A_D57: JDIMM1.194 UC1.AK46
DDR_A_D58: JDIMM1.183 UC1.AM49
DDR_A_D59: JDIMM1.182 UC1.AK49
DDR_A_D60: JDIMM1.191 UC1.AM48
DDR_A_D61: JDIMM1.193 UC1.AK48
DDR_A_D62: JDIMM1.181 UC1.AM51
DDR_A_D63: JDIMM1.180 UC1.AK51
DDR_A_DQS0: JDIMM1.137 UC1.AJ62
DDR_A_DQS1: JDIMM1.12 UC1.AN61
DDR_A_DQS2: JDIMM1.154 UC1.AN58
DDR_A_DQS3: JDIMM1.29 UC1.AN55
DDR_A_DQS4: JDIMM1.171 UC1.AW57
DDR_A_DQS5: JDIMM1.47 UC1.AW53
DDR_A_DQS6: JDIMM1.64 UC1.AL42
DDR_A_DQS7: JDIMM1.188 UC1.AL49
DDR_A_DQS#0: JDIMM1.135 UC1.AJ61
DDR_A_DQS#1: JDIMM1.10 UC1.AN62
DDR_A_DQS#2: JDIMM1.152 UC1.AM58
DDR_A_DQS#3: JDIMM1.27 UC1.AM55
DDR_A_DQS#4: JDIMM1.169 UC1.AV57
DDR_A_DQS#5: JDIMM1.45 UC1.AV53
DDR_A_DQS#6: JDIMM1.62 UC1.AL43
DDR_A_DQS#7: JDIMM1.186 UC1.AL48
DDR_A_MA0: JDIMM1.98 UC1.AU36
DDR_A_MA1: JDIMM1.97 UC1.AY37
DDR_A_MA2: JDIMM1.96 UC1.AR38
DDR_A_MA3: JDIMM1.95 UC1.AP36
DDR_A_MA4: JDIMM1.92 UC1.AU39
DDR_A_MA5: JDIMM1.91 UC1.AR36
DDR_A_MA6: JDIMM1.90 UC1.AV40
DDR_A_MA7: JDIMM1.86 UC1.AW39
DDR_A_MA8: JDIMM1.89 UC1.AY39
DDR_A_MA9: JDIMM1.85 UC1.AU40
DDR_A_MA10: JDIMM1.107 UC1.AP35
DDR_A_MA11: JDIMM1.84 UC1.AW41
DDR_A_MA12: JDIMM1.83 UC1.AU41
DDR_A_MA13: JDIMM1.119 UC1.AR35
DDR_A_MA14: JDIMM1.80 UC1.AV42
DDR_A_MA15: JDIMM1.78 UC1.AU42
DDR_A_RAS#: JDIMM1.110 UC1.AY34
DDR_A_WE#: JDIMM1.113 UC1.AW34
DDR_B_BS0: JDIMM2.109 UC1.AL35
DDR_B_BS1: JDIMM2.108 UC1.AM36
DDR_B_BS2: JDIMM2.79 UC1.AU49
DDR_B_CAS#: JDIMM2.115 UC1.AM33
DDR_B_D0: JDIMM2.132 UC1.AY31
DDR_B_D1: JDIMM2.131 UC1.AW31
DDR_B_D2: JDIMM2.140 UC1.AY29
DDR_B_D3: JDIMM2.141 UC1.AW29
DDR_B_D4: JDIMM2.129 UC1.AV31
DDR_B_D5: JDIMM2.130 UC1.AU31
DDR_B_D6: JDIMM2.142 UC1.AV29
DDR_B_D7: JDIMM2.143 UC1.AU29
DDR_B_D8: JDIMM2.5 UC1.AY27
DDR_B_D9: JDIMM2.6 UC1.AW27
DDR_B_D10: JDIMM2.15 UC1.AY25
DDR_B_D11: JDIMM2.17 UC1.AW25
DDR_B_D12: JDIMM2.4 UC1.AV27
DDR_B_D13: JDIMM2.16 UC1.AU27
DDR_B_D14: JDIMM2.7 UC1.AV25
DDR_B_D15: JDIMM2.18 UC1.AU25
DDR_B_D16: JDIMM2.146 UC1.AM29
DDR_B_D17: JDIMM2.148 UC1.AK29
DDR_B_D18: JDIMM2.160 UC1.AL28
DDR_B_D19: JDIMM2.158 UC1.AK28
DDR_B_D20: JDIMM2.149 UC1.AR29
DDR_B_D21: JDIMM2.147 UC1.AN29
DDR_B_D22: JDIMM2.157 UC1.AR28
DDR_B_D23: JDIMM2.159 UC1.AP28
DDR_B_D24: JDIMM2.24 UC1.AN26
DDR_B_D25: JDIMM2.22 UC1.AR26
DDR_B_D26: JDIMM2.33 UC1.AR25
DDR_B_D27: JDIMM2.35 UC1.AP25
DDR_B_D28: JDIMM2.21 UC1.AK26
DDR_B_D29: JDIMM2.23 UC1.AM26
DDR_B_D30: JDIMM2.34 UC1.AK25
DDR_B_D31: JDIMM2.36 UC1.AL25
DDR_B_D32: JDIMM2.166 UC1.AY23
DDR_B_D33: JDIMM2.165 UC1.AW23
DDR_B_D34: JDIMM2.174 UC1.AY21
DDR_B_D35: JDIMM2.175 UC1.AW21
DDR_B_D36: JDIMM2.163 UC1.AV23
DDR_B_D37: JDIMM2.164 UC1.AU23
DDR_B_D38: JDIMM2.176 UC1.AV21
DDR_B_D39: JDIMM2.177 UC1.AU21
DDR_B_D40: JDIMM2.39 UC1.AY19
DDR_B_D41: JDIMM2.41 UC1.AW19
DDR_B_D42: JDIMM2.53 UC1.AY17
DDR_B_D43: JDIMM2.52 UC1.AW17
DDR_B_D44: JDIMM2.42 UC1.AV19
DDR_B_D45: JDIMM2.40 UC1.AU19
DDR_B_D46: JDIMM2.51 UC1.AV17
DDR_B_D47: JDIMM2.50 UC1.AU17
DDR_B_D48: JDIMM2.191 UC1.AR21
DDR_B_D49: JDIMM2.183 UC1.AR22
DDR_B_D50: JDIMM2.194 UC1.AL21
DDR_B_D51: JDIMM2.180 UC1.AM22
DDR_B_D52: JDIMM2.181 UC1.AN22
DDR_B_D53: JDIMM2.193 UC1.AP21
DDR_B_D54: JDIMM2.192 UC1.AK21
DDR_B_D55: JDIMM2.182 UC1.AK22
DDR_B_D56: JDIMM2.57 UC1.AN20
DDR_B_D57: JDIMM2.59 UC1.AR20
DDR_B_D58: JDIMM2.69 UC1.AK18
DDR_B_D59: JDIMM2.67 UC1.AL18
DDR_B_D60: JDIMM2.58 UC1.AK20
DDR_B_D61: JDIMM2.56 UC1.AM20
DDR_B_D62: JDIMM2.70 UC1.AR18
DDR_B_D63: JDIMM2.68 UC1.AP18
DDR_B_DQS0: JDIMM2.137 UC1.AV30
DDR_B_DQS1: JDIMM2.12 UC1.AW26
DDR_B_DQS2: JDIMM2.154 UC1.AM28
DDR_B_DQS3: JDIMM2.29 UC1.AM25
DDR_B_DQS4: JDIMM2.171 UC1.AV22
DDR_B_DQS5: JDIMM2.47 UC1.AW18
DDR_B_DQS6: JDIMM2.188 UC1.AM21
DDR_B_DQS7: JDIMM2.64 UC1.AM18
DDR_B_DQS#0: JDIMM2.135 UC1.AW30
DDR_B_DQS#1: JDIMM2.10 UC1.AV26
DDR_B_DQS#2: JDIMM2.152 UC1.AN28
DDR_B_DQS#3: JDIMM2.27 UC1.AN25
DDR_B_DQS#4: JDIMM2.169 UC1.AW22
DDR_B_DQS#5: JDIMM2.45 UC1.AV18
DDR_B_DQS#6: JDIMM2.186 UC1.AN21
DDR_B_DQS#7: JDIMM2.62 UC1.AN18
DDR_B_MA0: JDIMM2.98 UC1.AP40
DDR_B_MA1: JDIMM2.97 UC1.AR40
DDR_B_MA2: JDIMM2.96 UC1.AP42
DDR_B_MA3: JDIMM2.95 UC1.AR42
DDR_B_MA4: JDIMM2.92 UC1.AR45
DDR_B_MA5: JDIMM2.91 UC1.AP45
DDR_B_MA6: JDIMM2.90 UC1.AW46
DDR_B_MA7: JDIMM2.86 UC1.AY46
DDR_B_MA8: JDIMM2.89 UC1.AY47
DDR_B_MA9: JDIMM2.85 UC1.AU46
DDR_B_MA10: JDIMM2.107 UC1.AK36
DDR_B_MA11: JDIMM2.84 UC1.AV47
DDR_B_MA12: JDIMM2.83 UC1.AU47
DDR_B_MA13: JDIMM2.119 UC1.AK33
DDR_B_MA14: JDIMM2.80 UC1.AR46
DDR_B_MA15: JDIMM2.78 UC1.AP46
DDR_B_RAS#: JDIMM2.110 UC1.AM35
DDR_B_WE#: JDIMM2.113 UC1.AK35
DDR_CKE0_DIMMA: JDIMM1.73 UC1.AU43
DDR_CKE1_DIMMA: JDIMM1.74 UC1.AW43
DDR_CKE2_DIMMB: JDIMM2.73 UC1.AY49
DDR_CKE3_DIMMB: JDIMM2.74 UC1.AU50
DDR_CS0_DIMMA#: JDIMM1.114 UC1.AP33
DDR_CS1_DIMMA#: JDIMM1.121 UC1.AR32
DDR_CS2_DIMMB#: JDIMM2.114 UC1.AM32
DDR_CS3_DIMMB#: JDIMM2.121 UC1.AK32
DDR_PG_CTRL: R34.2 U5.2 UC1.AV61
DDR_XDP_SMBCLK_R1: JXDP1.53 RC112.2
DDR_XDP_SMBDAT_R1: JXDP1.51 RC111.2
DDR_XDP_WAN_SMBCLK: JDIMM1.202 JDIMM2.202 QC1.1 R123.2 R218.2 R2598.2 RC112.1 U15.4
DDR_XDP_WAN_SMBDAT: JDIMM1.200 JDIMM2.200 QC1.4 R122.2 R219.2 R2597.2 RC111.1 U15.6
DEVICE_DET#: JSATA2.8 RP17.2 U38.B1
DGPU_CORE_EN: PR627.2 RC305.2 UC1.R5
DGPU_HOLD_RST#: RP9.6 UC1.Y3 UV14.1
DGPU_PEX_RST#: R346.1 RV29.1 RV2427.2 UV14.4
DGPU_PEX_RST_R#: RV2427.1 UV1.AC7
DGPU_PWR_EN: QV2806.2 R155.1 RC306.2 UC1.L3
DGPU_PWROK: PR633.2 PR709.1 R354.2 RP11.6 U37.A56 UC1.P4
DH_1.35V: PQ100.4 PU100.17
DIS_BAT_PROCHOT#: PR514.1 U37.B51
DISP_ON: D80.1 JLVDS1.12 R2581.1
DK_AC_OFF: PD511.2 PU701.25
DK_AC_OFF_EN: PR546.1 PU701.22
DK_CSS_GC: PQ403.1 PQ403.3 PR417.2 PR418.2 PU701.11
DK_PWRBAR: PR531.1 PU701.33
DL_1.35V: PQ101.4 PU100.15
DMIC0: CE11.1 R2595.2 U17.4
DMIC0_R: D77.2 JLVDS1.2 R2595.1
DMIC1: JPWR1.7 U17.46
DMIC_CLK0: C139.1 CE10.1 LE3.2 R2596.2
DMIC_CLK0_R: D77.3 JLVDS1.4 R2596.1
DMIC_CLK1: C130.1 JPWR1.8 LE4.2
DMIC_CLK_L: LE3.1 LE4.1 U17.2
DOCK_AC_OFF: JDOCK1.2 PD509.1 PD511.1 PR537.1
DOCK_AC_OFF_EC: PR546.2 PR547.1 U37.A63
DOCK_DCIN_IS+: JDOCK1.134 PQ403.6
DOCK_DCIN_IS-: JDOCK1.136 PQ403.4
DOCK_DET#: D19.2 PQ512.2 PR560.2 PR564.2 PU506.2 R272.1 U4.10 U37.B41
DOCK_DET_R#: D19.1 D87.2 JDOCK1.142 JDOCK1.144
DOCK_HP_DET: Q21.2 R158.2 U37.A7
DOCK_LOM_ACTLED_YEL#: JDOCK1.100 U23.19
DOCK_LOM_SPD10LED_GRN#: JDOCK1.3 U23.40
DOCK_LOM_SPD100LED_ORG#: JDOCK1.4 U23.20
DOCK_LOM_TRD0+: JDOCK1.104 U23.36
DOCK_LOM_TRD0-: JDOCK1.106 U23.35
DOCK_LOM_TRD1+: JDOCK1.110 U23.32
DOCK_LOM_TRD1-: JDOCK1.112 U23.31
DOCK_LOM_TRD2+: JDOCK1.122 U23.27
DOCK_LOM_TRD2-: JDOCK1.124 U23.26
DOCK_LOM_TRD3+: JDOCK1.128 U23.23
DOCK_LOM_TRD3-: JDOCK1.130 U23.22
DOCK_MIC_DET: Q21.5 R159.2 U37.B8
DOCK_POR_RST#: C357.1 D87.3 JDOCK1.140 RP18.5 U38.A21
DOCK_PSID: JDOCK1.135 PU1.1
DOCK_PWR_BTN#: C342.1 JDOCK1.139 R330.2
DOCK_PWR_SW#: C344.1 R328.2 R330.1 U38.A63
DOCK_SMB_ALERT#: JDOCK1.133 PD512.2 PQ1.3 R292.2 U37.A51
DOCK_SMB_CLK: JDOCK1.127 RP7.4 U38.B4
DOCK_SMB_DAT: JDOCK1.129 RP7.3 U38.A3
DOCK_USBP1+: L53.4 R415.1 UC1.AT10
DOCK_USBP1-: L53.1 R407.1 UC1.AR10
DOCK_USBP1_D+: JDOCK1.72 L53.3 R415.2
DOCK_USBP1_D-: JDOCK1.74 L53.2 R407.2
DOCK_USBP2+: L43.4 R269.1 U4.5
DOCK_USBP2-: L43.1 R270.1 U4.4
DOCK_USBP2_D+: JDOCK1.66 L43.3 R269.2
DOCK_USBP2_D-: JDOCK1.68 L43.2 R270.2
DOCKED: U23.13 U37.A38
DPB_CA_DET: JDOCK1.6 Q133.2 R120.2 U6.M14 U11.1 U11.4
DPB_CA_DET#: Q133.1 R161.1 U11.10 U11.13
DPB_DOCK_AUX: JDOCK1.34 U11.3 U11.11
DPB_DOCK_AUX#: JDOCK1.36 U11.6 U11.8
DPB_DOCK_HPD: C311.1 JDOCK1.40 R271.1 U6.K14
DPB_DOCK_LANE_N0: JDOCK1.12 R261.1
DPB_DOCK_LANE_N1: JDOCK1.18 R256.1
DPB_DOCK_LANE_N2: JDOCK1.24 R264.1
DPB_DOCK_LANE_N3: JDOCK1.30 R267.1
DPB_DOCK_LANE_P0: JDOCK1.10 R260.1
DPB_DOCK_LANE_P1: JDOCK1.16 R254.1
DPB_DOCK_LANE_P2: JDOCK1.22 R262.1
DPB_DOCK_LANE_P3: JDOCK1.28 R258.1
DPB_HPD: RC156.2 U6.J1 UC1.C8
DPB_LANE_N0: C296.1 U6.E14
DPB_LANE_N0_C: C296.2 R261.2
DPB_LANE_N1: C303.1 U6.F14
DPB_LANE_N1_C: C303.2 R256.2
DPB_LANE_N2: C307.1 U6.G14
DPB_LANE_N2_C: C307.2 R264.2
DPB_LANE_N3: C309.1 U6.H14
DPB_LANE_N3_C: C309.2 R267.2
DPB_LANE_P0: C294.1 U6.E13
DPB_LANE_P0_C: C294.2 R260.2
DPB_LANE_P1: C298.1 U6.F13
DPB_LANE_P1_C: C298.2 R254.2
DPB_LANE_P2: C305.1 U6.G13
DPB_LANE_P2_C: C305.2 R262.2
DPB_LANE_P3: C308.1 U6.H13
DPB_LANE_P3_C: C308.2 R258.2
DPC_CA_DET: JDOCK1.5 Q135.2 R121.2 U6.A14 U13.1 U13.4
DPC_CA_DET#: Q135.1 R164.1 U13.10 U13.13
DPC_DOCK_AUX: JDOCK1.33 U13.3 U13.11
DPC_DOCK_AUX#: JDOCK1.35 U13.6 U13.8
DPC_DOCK_HPD: C310.1 JDOCK1.39 R268.1 U6.A6
DPC_DOCK_LANE_N0: JDOCK1.11 R252.2
DPC_DOCK_LANE_N1: JDOCK1.17 R255.2
DPC_DOCK_LANE_N2: JDOCK1.23 R263.2
DPC_DOCK_LANE_N3: JDOCK1.29 R266.2
DPC_DOCK_LANE_P0: JDOCK1.9 R259.2
DPC_DOCK_LANE_P1: JDOCK1.15 R253.2
DPC_DOCK_LANE_P2: JDOCK1.21 R257.2
DPC_DOCK_LANE_P3: JDOCK1.27 R265.2
DPC_LANE_N0: C295.2 U6.A7
DPC_LANE_N0_C: C295.1 R252.1
DPC_LANE_N1: C299.2 U6.A8
DPC_LANE_N1_C: C299.1 R255.1
DPC_LANE_N2: C306.2 U6.A9
DPC_LANE_N2_C: C306.1 R263.1
DPC_LANE_N3: C301.2 U6.A10
DPC_LANE_N3_C: C301.1 R266.1
DPC_LANE_P0: C302.2 U6.B7
DPC_LANE_P0_C: C302.1 R259.1
DPC_LANE_P1: C297.2 U6.B8
DPC_LANE_P1_C: C297.1 R253.1
DPC_LANE_P2: C304.2 U6.B9
DPC_LANE_P2_C: C304.1 R257.1
DPC_LANE_P3: C300.2 U6.B10
DPC_LANE_P3_C: C300.1 R265.1
DQMA0: UV1.D19 UV4.E7
DQMA1: UV1.D14 UV5.E7
DQMA2: UV1.C17 UV5.D3
DQMA3: UV1.C22 UV4.D3
DQMA4: UV1.P24 UV6.E7
DQMA5: UV1.W24 UV7.D3
DQMA6: UV1.AA25 UV7.E7
DQMA7: UV1.U25 UV6.D3
DSCHRG_MOSFET_GC: PR559.1 PU701.29
DSWODVREN: RC73.1 RC78.2 UC1.AW7
DYN_TUR_CURRNT_SET#: PQ410.2 R363.2 U38.A35
EC5048_TX: R397.2 R406.2 U37.B2
EC_32KHZ_ECE5048: R379.1 U37.B35
EC_32KHZ_ECE5048_R: R379.2 U38.B62
EC_WAKE#: RC206.1 RC211.2 U38.B23 UC1.AN5
EDID_CLK: R2582.1 R2600.2 U52.46
EDID_CLK_LCD: JLVDS1.36 R2600.1
EDID_DATA: R2584.1 R2599.2 U52.45
EDID_DATA_LCD: JLVDS1.35 R2599.1
EDP_BIA_PWM: R2577.2 RC33.2 UC1.B8
EDP_BIA_PWM_R: RC33.1 U52.21
EDP_COMP: RC134.2 UC1.D20
EDP_CPU_AUX: C449.2 UC1.B45
EDP_CPU_AUX#: C450.2 UC1.A45
EDP_CPU_AUX#_C: C450.1 U52.3
EDP_CPU_AUX_C: C449.1 U52.4
EDP_CPU_HPD: RC158.1 U52.1 UC1.D6
EDP_CPU_LANE_N0: C446.2 UC1.C45
EDP_CPU_LANE_N0_C: C446.1 U52.8
EDP_CPU_LANE_N1: C448.2 UC1.A47
EDP_CPU_LANE_N1_C: C448.1 U52.10
EDP_CPU_LANE_P0: C445.2 UC1.B46
EDP_CPU_LANE_P0_C: C445.1 U52.7
EDP_CPU_LANE_P1: C447.2 UC1.B47
EDP_CPU_LANE_P1_C: C447.1 U52.9
EN: PC70.1 PR65.2 PU51.6 PU51.20
EN_1.5VRUN: PC206.1 PR203.2 PR205.1 PR206.2 PU200.5
EN_+V1.05SP: PC157.1 PR153.2 PR154.2 PU150.28
EN_+VDDRP: PC708.1 PR703.2 PR704.2 PU700.3
EN_DK_PWRBAR: PR552.1 PR556.1 PU701.17
EN_DOCK_PWR_BAR: PR552.2 U37.B37
EN_I2S_NB_CODEC#: U17.48 U37.B36
EN_INVPWR: Q125.5 R371.2 U38.A25
EN_LCDPWR: D76.1 R2678.1 U33.4
ENVDD_PCH: RC152.2 U37.B38 U86.2 UC1.C6
ERC1: PC512.1 PU701.3
ERC2: PC514.1 PU701.13
ERC3: PC513.1 PU701.12
EXP_PRX_EXPTX_N6: R60.2 R2659.2 UC1.F5
EXP_PRX_EXPTX_N6_CL: R2659.1 R2663.2
EXP_PRX_EXPTX_N6_M: R60.1 U91.7
EXP_PRX_EXPTX_P6: R56.2 R2658.2 UC1.E5
EXP_PRX_EXPTX_P6_CL: R2658.1 R2662.2
EXP_PRX_EXPTX_P6_M: R56.1 U91.6
EXP_PTX_EXPRX_N6: R51.2 R2661.2 UC1.C17
EXP_PTX_EXPRX_N6_CL: R2661.1 R2664.2
EXP_PTX_EXPRX_N6_M: R51.1 U91.5
EXP_PTX_EXPRX_P6: R50.2 R2660.2 UC1.D17
EXP_PTX_EXPRX_P6_CL: R2660.1 R2665.2
EXP_PTX_EXPRX_P6_M: R50.1 U91.4
EXPCLK_REQ#: CE20.1 JEXP1.31 R170.2 R488.1 RC196.2 U93.3
EXPRCRD_STBY_R#: JEXP1.29 R734.1
EXPRESS_DET#: CE22.1 JEXP1.27 R37.2 R419.2 U37.B15 U93.6
EXPRESS_DET#_M: R37.1 U91.3
F-IMAX: PR303.2 PR308.1 PU300.10
FAN1_PWM: JFAN1.3 R408.2 U38.A24
FAN1_TACH: JFAN1.2 R376.2 U38.B22
FB_+VDDRP: PR707.1 PR708.1 PU700.4
FB_VREF: T171.1(TP-1) UV1.D23
FBA_CLK0_C: CV2901.1 RV2707.1 RV2708.1
FBA_CLK1_C: CV2944.1 RV2718.1 RV2719.1
FBA_CMD0: UV1.C27 UV4.L2 UV5.L2
FBA_CMD2: RV2440.1 UV1.E24 UV4.K1 UV5.K1
FBA_CMD3: RV2438.1 UV1.F24 UV4.K9 UV5.K9
FBA_CMD4: UV1.D27 UV4.T7 UV5.T7 UV6.T7 UV7.T7
FBA_CMD5: RV2447.1 UV1.D26 UV4.T2 UV5.T2 UV6.T2 UV7.T2
FBA_CMD6: UV1.F25 UV4.R3 UV5.R3 UV6.R3 UV7.R3
FBA_CMD7: UV1.F26 UV4.R2 UV5.R2 UV6.R2 UV7.R2
FBA_CMD8: UV1.F23 UV4.P3 UV5.P3 UV6.P3 UV7.P3
FBA_CMD9: UV1.G22 UV4.N3 UV5.N3 UV6.N3 UV7.N3
FBA_CMD10: UV1.G23 UV4.P8 UV5.P8 UV6.P8 UV7.P8
FBA_CMD11: UV1.G24 UV4.P7 UV5.P7 UV6.P7 UV7.P7
FBA_CMD12: UV1.F27 UV4.M2 UV5.M2 UV6.M2 UV7.M2
FBA_CMD13: UV1.G25 UV4.L3 UV5.L3 UV6.L3 UV7.L3
FBA_CMD14: UV1.G27 UV4.M7 UV5.M7 UV6.M7 UV7.M7
FBA_CMD15: UV1.G26 UV4.K3 UV5.K3 UV6.K3 UV7.K3
FBA_CMD16: UV1.M24 UV6.L2 UV7.L2
FBA_CMD18: RV2439.1 UV1.K24 UV6.K1 UV7.K1
FBA_CMD19: RV2437.1 UV1.K23 UV6.K9 UV7.K9
FBA_CMD20: UV1.M27 UV4.T3 UV5.T3 UV6.T3 UV7.T3
FBA_CMD21: UV1.M26 UV4.T8 UV5.T8 UV6.T8 UV7.T8
FBA_CMD22: UV1.M25 UV4.R8 UV5.R8 UV6.R8 UV7.R8
FBA_CMD23: UV1.K26 UV4.R7 UV5.R7 UV6.R7 UV7.R7
FBA_CMD24: UV1.K22 UV4.P2 UV5.P2 UV6.P2 UV7.P2
FBA_CMD25: UV1.J23 UV4.N2 UV5.N2 UV6.N2 UV7.N2
FBA_CMD26: UV1.J25 UV4.M3 UV5.M3 UV6.M3 UV7.M3
FBA_CMD27: UV1.J24 UV4.N8 UV5.N8 UV6.N8 UV7.N8
FBA_CMD28: UV1.K27 UV4.N7 UV5.N7 UV6.N7 UV7.N7
FBA_CMD29: UV1.K25 UV4.L7 UV5.L7 UV6.L7 UV7.L7
FBA_CMD30: UV1.J27 UV4.J3 UV5.J3 UV6.J3 UV7.J3
FBA_D0: UV1.E18 UV4.F8
FBA_D1: UV1.F18 UV4.F7
FBA_D2: UV1.E16 UV4.H8
FBA_D3: UV1.F17 UV4.H7
FBA_D4: UV1.D20 UV4.E3
FBA_D5: UV1.D21 UV4.F2
FBA_D6: UV1.F20 UV4.H3
FBA_D7: UV1.E21 UV4.G2
FBA_D8: UV1.E15 UV5.F7
FBA_D9: UV1.D15 UV5.H7
FBA_D10: UV1.F15 UV5.F8
FBA_D11: UV1.F13 UV5.H8
FBA_D12: UV1.C13 UV5.E3
FBA_D13: UV1.B13 UV5.F2
FBA_D14: UV1.E13 UV5.H3
FBA_D15: UV1.D13 UV5.G2
FBA_D16: UV1.B15 UV5.C3
FBA_D17: UV1.C16 UV5.A3
FBA_D18: UV1.A13 UV5.A2
FBA_D19: UV1.A15 UV5.C2
FBA_D20: UV1.B18 UV5.D7
FBA_D21: UV1.A18 UV5.A7
FBA_D22: UV1.A19 UV5.B8
FBA_D23: UV1.C19 UV5.C8
FBA_D24: UV1.B24 UV4.A3
FBA_D25: UV1.C23 UV4.C2
FBA_D26: UV1.A25 UV4.A2
FBA_D27: UV1.A24 UV4.C3
FBA_D28: UV1.A21 UV4.A7
FBA_D29: UV1.B21 UV4.B8
FBA_D30: UV1.C20 UV4.C8
FBA_D31: UV1.C21 UV4.D7
FBA_D32: UV1.R22 UV6.G2
FBA_D33: UV1.R24 UV6.H3
FBA_D34: UV1.T22 UV6.F2
FBA_D35: UV1.R23 UV6.E3
FBA_D36: UV1.N25 UV6.H7
FBA_D37: UV1.N26 UV6.F7
FBA_D38: UV1.N23 UV6.H8
FBA_D39: UV1.N24 UV6.F8
FBA_D40: UV1.V23 UV7.C3
FBA_D41: UV1.V22 UV7.C2
FBA_D42: UV1.T23 UV7.A3
FBA_D43: UV1.U22 UV7.A2
FBA_D44: UV1.Y24 UV7.D7
FBA_D45: UV1.AA24 UV7.A7
FBA_D46: UV1.Y22 UV7.C8
FBA_D47: UV1.AA23 UV7.B8
FBA_D48: UV1.AD27 UV7.H8
FBA_D49: UV1.AB25 UV7.F7
FBA_D50: UV1.AD26 UV7.F8
FBA_D51: UV1.AC25 UV7.H7
FBA_D52: UV1.AA27 UV7.E3
FBA_D53: UV1.AA26 UV7.F2
FBA_D54: UV1.W26 UV7.H3
FBA_D55: UV1.Y25 UV7.G2
FBA_D56: UV1.R26 UV6.D7
FBA_D57: UV1.T25 UV6.A7
FBA_D58: UV1.N27 UV6.C8
FBA_D59: UV1.R27 UV6.B8
FBA_D60: UV1.V26 UV6.C3
FBA_D61: UV1.V27 UV6.C2
FBA_D62: UV1.W27 UV6.A3
FBA_D63: UV1.W25 UV6.A2
FFS_INT2: Q19.2 RC183.2 U15.9 UC1.G2
FFS_INT2_Q: JSATA1.18 Q19.3 R125.2
FMCCLK_REQ#: JMINI2.7 R168.2 R485.1 U93.1
FPR_DET#: JBIO1.5 R481.1 U37.A16
FWP#: R393.2 R399.2 U38.B65
GFB: PR335.2 PU300.23
GPIO8_THERMATRIP#: QC6.1 RV48.1 UV1.A6
GPIO09_GPUHOT#: QC11.1 RV34.1 UV1.F8
GPIO11_NVVDD_VID: PR600.2 PR602.1 PU600.5 QC6.3 U37.A49
GPIO11_NVVDD_VID_R: QC6.4 UV1.E7
GPIO12_AC_DETECT: QC8.1 RV35.1 UV1.D7
GPIO13_NVVDD_PSI: PR634.1 QC8.3
GPIO13_NVVDD_PSI_R: QC8.4 RV2446.1 UV1.B4
GPIO_PSID_SELECT: PU1.6 U37.A6
GPIOA6: R296.2 R339.2 R348.2 U37.B55
GPIOA7: R350.2 R355.2 R389.2 U37.A52
GPU_B+: PC321.1 PC322.1 PC323.1 PC324.1 PC600.1 PC601.1 PC602.1 PC603.1 PC604.1 PC605.1 PC619.1 PJP600.2 PQ600.5 PQ603.5 PR614.1
GPU_COMP: PC622.2 PC623.2 PU600.12
GPU_DSBL/ISEN1: PC626.1 PR636.1 PU600.15
GPU_EN: PD601.2 PR627.1 PU600.3
GPU_FB: PC620.2 PR621.2 PU600.11
GPU_FBRTN: PC616.2 PC617.2 PR611.2 PR615.2 PR616.2 PU600.10
GPU_JTAG_TCK: T186.1(TP-1) UV1.AE5
GPU_JTAG_TDI: T188.1(TP-1) UV1.AE6
GPU_JTAG_TDO: T189.1(TP-1) UV1.AF6
GPU_JTAG_TMS: T187.1(TP-1) UV1.AD6
GPU_JTAG_TRST#: RV88.2 T190.1(TP-1) UV1.AG4
GPU_PGOOD: PC625.1 PR626.2 PR633.1 PR704.1 PU600.16
GPU_PLLVDD: CV236.1 CV3064.1 L73.2 UV1.L6
GPU_PVCC: PC621.2 PR617.1 PR630.1 PR636.2 PU600.21
GPU_PWR_LEVEL: R339.1 R345.2 R355.1
GPU_REFADJ: PR608.2 PU600.6
GPU_REFIN: PC616.1 PR607.1 PR610.1 PU600.7
GPU_SMBCLK: QC9.6 RP7.2 U38.B49
GPU_SMBDAT: QC9.3 RP7.1 U38.B48
GPU_TALERT/ISEN2: PR628.1 PR637.1 PU600.14
GPU_TESTMODE: RV2435.1 UV1.AD9
GPU_TON: PR614.2 PU600.9
GPU_TSNS/ISEN3: PC624.1 PH302.1 PR623.2 PR624.1 PR625.1 PU600.13
GPU_VREF: PC613.1 PR604.1 PR623.1 PU600.8
GPUHOT#: PR637.2 QC11.6 R348.1 R350.1
GREEN_CRT: JIO1.36 U39.25
GREEN_DOCK: L69.1 U39.24
GREEN_DOCK_PI: JDOCK1.59 L69.2
H_CATERR#: RC113.2 UC1.K61
H_CPU_SVIDALRT#: RC248.1 UC1.L62
H_CPUPWRGD: RC106.1 RC115.1 UC1.C61
H_PROCHOT#: PC317.1 PQ502.3 PR326.2 PR442.2 Q9.1 R334.2 RC114.2 RC117.1
H_PROCHOT#_R: RC117.2 UC1.K63
H_THERMTRIP#: Q12.3 R24.2 RC172.1
H_THERMTRIP#_R: RC172.2 UC1.D60
H_VCCST_PWRGD: RC105.1 RC243.1 RC245.1 UC4.4
H_VCCST_PWRGD_XDP: JXDP1.39 RC105.2 RC106.2
H_VR_EN: PR312.2 RC246.1 RC256.2
H_VR_READY: PD300.2 PR317.2 RC247.1 RC255.2 RC256.1 RC259.2
HDD_DET#: JSATA1.12 RC11.1 UC1.U1
HDD_DEVSLP: R52.1 R124.2 UC1.L2
HDD_FALL_INT: R73.1 R75.1 R76.1 R77.1
HDD_LED#: JLED1.5 Q26.3
HDMI_CEC: JHDMI1.13 R473.2
HDMI_HPD_SINK: JHDMI1.19 QZ22.6 R474.1
HDMI_OB: QZ22.3 R462.2 R463.2 R464.2 R465.2 R466.2 R467.2 R468.2 R469.2
HOST_DEB_TX: JDEG1.8 R400.1
HOST_DEBUG_RX: RP16.7 U38.B46
HOST_DEBUG_TX: R396.2 R400.2 U38.B44
HS_IND/CFG_SEL1: R2691.1 R2695.2 U90.25
HSYNC_BUF: JIO1.42 U39.20
HSYNC_DOCK: JDOCK1.65 U39.19
HUB_USBP1+: L54.4 R742.1 U90.2
HUB_USBP1-: L54.1 R741.1 U90.1
HUB_USBP1_R_D+: D78.2 JBIO1.4 L54.3 R742.2
HUB_USBP1_R_D-: D78.3 JBIO1.3 L54.2 R741.2
HUB_USBP2+: L59.1 R487.1 U90.4
HUB_USBP2+_D: JEXP1.10 L59.2 R487.2
HUB_USBP2-: L59.4 R486.1 U90.3
HUB_USBP2-_D: JEXP1.12 L59.3 R486.2
HUB_USBP3+: JMINI1.38 U90.7
HUB_USBP3-: JMINI1.36 U90.6
HUB_USBP4+: L57.4 R483.1 U90.9
HUB_USBP4+_D: JMINI2.38 L57.3 R483.2
HUB_USBP4-: L57.1 R482.1 U90.8
HUB_USBP4-_D: JMINI2.36 L57.2 R482.2
HW_GPS_DISABLE#: JMINI2.51 R282.2 U37.B34
I2C0_SCL: RP8.7 UC1.F3
I2C0_SDA: RP8.8 UC1.F2
I2C1_SCL_TCH_PAD: R449.1 RC176.2 RP8.6 UC1.F1
I2C1_SCL_VMM: RC176.1 U6.A2
I2C1_SDA_TCH_PAD: R450.1 RC174.2 RP8.5 UC1.G4
I2C1_SDA_VMM: RC174.1 U6.A1
I2CC_SCL: RV45.2 UV1.A9
I2CC_SDA: RV46.2 UV1.B9
I2CS_SCL: QC9.1 RV49.2 UV1.D9
I2CS_SDA: QC9.4 RV50.2 UV1.D8
I2S_BCLK: R139.2 U17.16
I2S_DI#: R144.2 U17.24
I2S_DO: R141.2 U17.17
I2S_LRCLK: R143.2 U17.18
I2S_MCLK: R137.2 U17.15
IFPA_IOVDD: UV1.W6
IFPAB_PLLVDD_1: UV1.V7
IFPAB_PLLVDD_2: UV1.W7
IFPB_IOVDD: UV1.Y6
IFPC_IOVDD: UV1.P6
IFPC_PLLVDD_1: UV1.M7
IFPC_PLLVDD_2: UV1.N7
IFPD_IOVDD: UV1.R6
IFPD_PLLVDD_1: UV1.R7
IFPD_PLLVDD_2: UV1.T7
IFPE_IOVDD: UV1.H6
IFPEF_PLLVDD_1: UV1.J7
IFPEF_PLLVDD_2: UV1.K7
IFPF_IOVDD: UV1.J6
IMON: PC300.1 PR301.1 PU300.13
IMVP_PWRGD: PR318.2 R323.2
IMVP_VR_ON: PR313.2 R294.2
INT_SPK_L+: C124.1 R2688.1 U17.40
INT_SPK_L-: C125.1 R2702.1 U17.41
INT_SPK_R+: C126.1 R2703.1 U17.44
INT_SPK_R-: C127.1 R2704.1 U17.43
INT_SPKR_L+: DE2.3 JSPK1.1 R2688.2
INT_SPKR_L-: DE2.2 JSPK1.2 R2702.2
INT_SPKR_R+: DE1.3 JSPK1.3 R2703.2
INT_SPKR_R-: DE1.2 JSPK1.4 R2704.2
INTRUDER#: RC7.2 UC1.AU6
IO_LDOSEL: R212.2 R214.1 U27.18
IO_USBP2+: JUDB1.15 U4.7
IO_USBP2-: JUDB1.14 U4.6
